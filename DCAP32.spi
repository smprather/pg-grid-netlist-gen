.subckt DCAP32 VDD VSS
.ends

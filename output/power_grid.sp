* Power Grid Netlist - FreePDK15
* Generated by pg_grid_netlist_gen
* Grid: 10um x 10um
* Layers: 28

.subckt BUFX12 A Y VDD VSS
.ends BUFX12

* === Metal Segments (R) ===
* Layer: MG2
R_MG2_seg_0 MG2_X_0_Y_0 MG2_X_537_Y_0 237.7m
R_MG2_seg_1 MG2_X_537_Y_0 MG2_X_1075_Y_0 237.7m
R_MG2_seg_2 MG2_X_1075_Y_0 MG2_X_1612_Y_0 237.7m
R_MG2_seg_3 MG2_X_1612_Y_0 MG2_X_2150_Y_0 237.7m
R_MG2_seg_4 MG2_X_2150_Y_0 MG2_X_2688_Y_0 237.7m
R_MG2_seg_5 MG2_X_2688_Y_0 MG2_X_3225_Y_0 237.7m
R_MG2_seg_6 MG2_X_3225_Y_0 MG2_X_3763_Y_0 237.7m
R_MG2_seg_7 MG2_X_3763_Y_0 MG2_X_4300_Y_0 237.7m
R_MG2_seg_8 MG2_X_4300_Y_0 MG2_X_4838_Y_0 237.7m
R_MG2_seg_9 MG2_X_4838_Y_0 MG2_X_5376_Y_0 237.7m
R_MG2_seg_10 MG2_X_5376_Y_0 MG2_X_5913_Y_0 237.7m
R_MG2_seg_11 MG2_X_5913_Y_0 MG2_X_6451_Y_0 237.7m
R_MG2_seg_12 MG2_X_6451_Y_0 MG2_X_6988_Y_0 237.7m
R_MG2_seg_13 MG2_X_6988_Y_0 MG2_X_7526_Y_0 237.7m
R_MG2_seg_14 MG2_X_7526_Y_0 MG2_X_8064_Y_0 237.7m
R_MG2_seg_15 MG2_X_8064_Y_0 MG2_X_8601_Y_0 237.7m
R_MG2_seg_16 MG2_X_8601_Y_0 MG2_X_9139_Y_0 237.7m
R_MG2_seg_17 MG2_X_9139_Y_0 MG2_X_9676_Y_0 237.7m
R_MG2_seg_18 MG2_X_9676_Y_0 MG2_X_10000_Y_0 142.9m
R_MG2_seg_19 MG2_X_0_Y_268 MG2_X_268_Y_268 118.8m
R_MG2_seg_20 MG2_X_268_Y_268 MG2_X_806_Y_268 237.7m
R_MG2_seg_21 MG2_X_806_Y_268 MG2_X_1344_Y_268 237.7m
R_MG2_seg_22 MG2_X_1344_Y_268 MG2_X_1881_Y_268 237.7m
R_MG2_seg_23 MG2_X_1881_Y_268 MG2_X_2419_Y_268 237.7m
R_MG2_seg_24 MG2_X_2419_Y_268 MG2_X_2956_Y_268 237.7m
R_MG2_seg_25 MG2_X_2956_Y_268 MG2_X_3494_Y_268 237.7m
R_MG2_seg_26 MG2_X_3494_Y_268 MG2_X_4032_Y_268 237.7m
R_MG2_seg_27 MG2_X_4032_Y_268 MG2_X_4569_Y_268 237.7m
R_MG2_seg_28 MG2_X_4569_Y_268 MG2_X_5107_Y_268 237.7m
R_MG2_seg_29 MG2_X_5107_Y_268 MG2_X_5644_Y_268 237.7m
R_MG2_seg_30 MG2_X_5644_Y_268 MG2_X_6182_Y_268 237.7m
R_MG2_seg_31 MG2_X_6182_Y_268 MG2_X_6720_Y_268 237.7m
R_MG2_seg_32 MG2_X_6720_Y_268 MG2_X_7257_Y_268 237.7m
R_MG2_seg_33 MG2_X_7257_Y_268 MG2_X_7795_Y_268 237.7m
R_MG2_seg_34 MG2_X_7795_Y_268 MG2_X_8332_Y_268 237.7m
R_MG2_seg_35 MG2_X_8332_Y_268 MG2_X_8870_Y_268 237.7m
R_MG2_seg_36 MG2_X_8870_Y_268 MG2_X_9408_Y_268 237.7m
R_MG2_seg_37 MG2_X_9408_Y_268 MG2_X_9945_Y_268 237.7m
R_MG2_seg_38 MG2_X_9945_Y_268 MG2_X_10000_Y_268 24.05m
R_MG2_seg_39 MG2_X_0_Y_537 MG2_X_537_Y_537 237.7m
R_MG2_seg_40 MG2_X_537_Y_537 MG2_X_1075_Y_537 237.7m
R_MG2_seg_41 MG2_X_1075_Y_537 MG2_X_1612_Y_537 237.7m
R_MG2_seg_42 MG2_X_1612_Y_537 MG2_X_2150_Y_537 237.7m
R_MG2_seg_43 MG2_X_2150_Y_537 MG2_X_2688_Y_537 237.7m
R_MG2_seg_44 MG2_X_2688_Y_537 MG2_X_3225_Y_537 237.7m
R_MG2_seg_45 MG2_X_3225_Y_537 MG2_X_3763_Y_537 237.7m
R_MG2_seg_46 MG2_X_3763_Y_537 MG2_X_4300_Y_537 237.7m
R_MG2_seg_47 MG2_X_4300_Y_537 MG2_X_4838_Y_537 237.7m
R_MG2_seg_48 MG2_X_4838_Y_537 MG2_X_5376_Y_537 237.7m
R_MG2_seg_49 MG2_X_5376_Y_537 MG2_X_5913_Y_537 237.7m
R_MG2_seg_50 MG2_X_5913_Y_537 MG2_X_6451_Y_537 237.7m
R_MG2_seg_51 MG2_X_6451_Y_537 MG2_X_6988_Y_537 237.7m
R_MG2_seg_52 MG2_X_6988_Y_537 MG2_X_7526_Y_537 237.7m
R_MG2_seg_53 MG2_X_7526_Y_537 MG2_X_8064_Y_537 237.7m
R_MG2_seg_54 MG2_X_8064_Y_537 MG2_X_8601_Y_537 237.7m
R_MG2_seg_55 MG2_X_8601_Y_537 MG2_X_9139_Y_537 237.7m
R_MG2_seg_56 MG2_X_9139_Y_537 MG2_X_9676_Y_537 237.7m
R_MG2_seg_57 MG2_X_9676_Y_537 MG2_X_10000_Y_537 142.9m
R_MG2_seg_58 MG2_X_0_Y_806 MG2_X_268_Y_806 118.8m
R_MG2_seg_59 MG2_X_268_Y_806 MG2_X_806_Y_806 237.7m
R_MG2_seg_60 MG2_X_806_Y_806 MG2_X_1344_Y_806 237.7m
R_MG2_seg_61 MG2_X_1344_Y_806 MG2_X_1881_Y_806 237.7m
R_MG2_seg_62 MG2_X_1881_Y_806 MG2_X_2419_Y_806 237.7m
R_MG2_seg_63 MG2_X_2419_Y_806 MG2_X_2956_Y_806 237.7m
R_MG2_seg_64 MG2_X_2956_Y_806 MG2_X_3494_Y_806 237.7m
R_MG2_seg_65 MG2_X_3494_Y_806 MG2_X_4032_Y_806 237.7m
R_MG2_seg_66 MG2_X_4032_Y_806 MG2_X_4569_Y_806 237.7m
R_MG2_seg_67 MG2_X_4569_Y_806 MG2_X_5107_Y_806 237.7m
R_MG2_seg_68 MG2_X_5107_Y_806 MG2_X_5644_Y_806 237.7m
R_MG2_seg_69 MG2_X_5644_Y_806 MG2_X_6182_Y_806 237.7m
R_MG2_seg_70 MG2_X_6182_Y_806 MG2_X_6720_Y_806 237.7m
R_MG2_seg_71 MG2_X_6720_Y_806 MG2_X_7257_Y_806 237.7m
R_MG2_seg_72 MG2_X_7257_Y_806 MG2_X_7795_Y_806 237.7m
R_MG2_seg_73 MG2_X_7795_Y_806 MG2_X_8332_Y_806 237.7m
R_MG2_seg_74 MG2_X_8332_Y_806 MG2_X_8870_Y_806 237.7m
R_MG2_seg_75 MG2_X_8870_Y_806 MG2_X_9408_Y_806 237.7m
R_MG2_seg_76 MG2_X_9408_Y_806 MG2_X_9945_Y_806 237.7m
R_MG2_seg_77 MG2_X_9945_Y_806 MG2_X_10000_Y_806 24.05m
R_MG2_seg_78 MG2_X_0_Y_1075 MG2_X_537_Y_1075 237.7m
R_MG2_seg_79 MG2_X_537_Y_1075 MG2_X_1075_Y_1075 237.7m
R_MG2_seg_80 MG2_X_1075_Y_1075 MG2_X_1612_Y_1075 237.7m
R_MG2_seg_81 MG2_X_1612_Y_1075 MG2_X_2150_Y_1075 237.7m
R_MG2_seg_82 MG2_X_2150_Y_1075 MG2_X_2688_Y_1075 237.7m
R_MG2_seg_83 MG2_X_2688_Y_1075 MG2_X_3225_Y_1075 237.7m
R_MG2_seg_84 MG2_X_3225_Y_1075 MG2_X_3763_Y_1075 237.7m
R_MG2_seg_85 MG2_X_3763_Y_1075 MG2_X_4300_Y_1075 237.7m
R_MG2_seg_86 MG2_X_4300_Y_1075 MG2_X_4838_Y_1075 237.7m
R_MG2_seg_87 MG2_X_4838_Y_1075 MG2_X_5376_Y_1075 237.7m
R_MG2_seg_88 MG2_X_5376_Y_1075 MG2_X_5913_Y_1075 237.7m
R_MG2_seg_89 MG2_X_5913_Y_1075 MG2_X_6451_Y_1075 237.7m
R_MG2_seg_90 MG2_X_6451_Y_1075 MG2_X_6988_Y_1075 237.7m
R_MG2_seg_91 MG2_X_6988_Y_1075 MG2_X_7526_Y_1075 237.7m
R_MG2_seg_92 MG2_X_7526_Y_1075 MG2_X_8064_Y_1075 237.7m
R_MG2_seg_93 MG2_X_8064_Y_1075 MG2_X_8601_Y_1075 237.7m
R_MG2_seg_94 MG2_X_8601_Y_1075 MG2_X_9139_Y_1075 237.7m
R_MG2_seg_95 MG2_X_9139_Y_1075 MG2_X_9676_Y_1075 237.7m
R_MG2_seg_96 MG2_X_9676_Y_1075 MG2_X_10000_Y_1075 142.9m
R_MG2_seg_97 MG2_X_0_Y_1344 MG2_X_268_Y_1344 118.8m
R_MG2_seg_98 MG2_X_268_Y_1344 MG2_X_806_Y_1344 237.7m
R_MG2_seg_99 MG2_X_806_Y_1344 MG2_X_1344_Y_1344 237.7m
R_MG2_seg_100 MG2_X_1344_Y_1344 MG2_X_1881_Y_1344 237.7m
R_MG2_seg_101 MG2_X_1881_Y_1344 MG2_X_2419_Y_1344 237.7m
R_MG2_seg_102 MG2_X_2419_Y_1344 MG2_X_2956_Y_1344 237.7m
R_MG2_seg_103 MG2_X_2956_Y_1344 MG2_X_3494_Y_1344 237.7m
R_MG2_seg_104 MG2_X_3494_Y_1344 MG2_X_4032_Y_1344 237.7m
R_MG2_seg_105 MG2_X_4032_Y_1344 MG2_X_4569_Y_1344 237.7m
R_MG2_seg_106 MG2_X_4569_Y_1344 MG2_X_5107_Y_1344 237.7m
R_MG2_seg_107 MG2_X_5107_Y_1344 MG2_X_5644_Y_1344 237.7m
R_MG2_seg_108 MG2_X_5644_Y_1344 MG2_X_6182_Y_1344 237.7m
R_MG2_seg_109 MG2_X_6182_Y_1344 MG2_X_6720_Y_1344 237.7m
R_MG2_seg_110 MG2_X_6720_Y_1344 MG2_X_7257_Y_1344 237.7m
R_MG2_seg_111 MG2_X_7257_Y_1344 MG2_X_7795_Y_1344 237.7m
R_MG2_seg_112 MG2_X_7795_Y_1344 MG2_X_8332_Y_1344 237.7m
R_MG2_seg_113 MG2_X_8332_Y_1344 MG2_X_8870_Y_1344 237.7m
R_MG2_seg_114 MG2_X_8870_Y_1344 MG2_X_9408_Y_1344 237.7m
R_MG2_seg_115 MG2_X_9408_Y_1344 MG2_X_9945_Y_1344 237.7m
R_MG2_seg_116 MG2_X_9945_Y_1344 MG2_X_10000_Y_1344 24.05m
R_MG2_seg_117 MG2_X_0_Y_1612 MG2_X_537_Y_1612 237.7m
R_MG2_seg_118 MG2_X_537_Y_1612 MG2_X_1075_Y_1612 237.7m
R_MG2_seg_119 MG2_X_1075_Y_1612 MG2_X_1612_Y_1612 237.7m
R_MG2_seg_120 MG2_X_1612_Y_1612 MG2_X_2150_Y_1612 237.7m
R_MG2_seg_121 MG2_X_2150_Y_1612 MG2_X_2688_Y_1612 237.7m
R_MG2_seg_122 MG2_X_2688_Y_1612 MG2_X_3225_Y_1612 237.7m
R_MG2_seg_123 MG2_X_3225_Y_1612 MG2_X_3763_Y_1612 237.7m
R_MG2_seg_124 MG2_X_3763_Y_1612 MG2_X_4300_Y_1612 237.7m
R_MG2_seg_125 MG2_X_4300_Y_1612 MG2_X_4838_Y_1612 237.7m
R_MG2_seg_126 MG2_X_4838_Y_1612 MG2_X_5376_Y_1612 237.7m
R_MG2_seg_127 MG2_X_5376_Y_1612 MG2_X_5913_Y_1612 237.7m
R_MG2_seg_128 MG2_X_5913_Y_1612 MG2_X_6451_Y_1612 237.7m
R_MG2_seg_129 MG2_X_6451_Y_1612 MG2_X_6988_Y_1612 237.7m
R_MG2_seg_130 MG2_X_6988_Y_1612 MG2_X_7526_Y_1612 237.7m
R_MG2_seg_131 MG2_X_7526_Y_1612 MG2_X_8064_Y_1612 237.7m
R_MG2_seg_132 MG2_X_8064_Y_1612 MG2_X_8601_Y_1612 237.7m
R_MG2_seg_133 MG2_X_8601_Y_1612 MG2_X_9139_Y_1612 237.7m
R_MG2_seg_134 MG2_X_9139_Y_1612 MG2_X_9676_Y_1612 237.7m
R_MG2_seg_135 MG2_X_9676_Y_1612 MG2_X_10000_Y_1612 142.9m
R_MG2_seg_136 MG2_X_0_Y_1881 MG2_X_268_Y_1881 118.8m
R_MG2_seg_137 MG2_X_268_Y_1881 MG2_X_806_Y_1881 237.7m
R_MG2_seg_138 MG2_X_806_Y_1881 MG2_X_1344_Y_1881 237.7m
R_MG2_seg_139 MG2_X_1344_Y_1881 MG2_X_1881_Y_1881 237.7m
R_MG2_seg_140 MG2_X_1881_Y_1881 MG2_X_2419_Y_1881 237.7m
R_MG2_seg_141 MG2_X_2419_Y_1881 MG2_X_2956_Y_1881 237.7m
R_MG2_seg_142 MG2_X_2956_Y_1881 MG2_X_3494_Y_1881 237.7m
R_MG2_seg_143 MG2_X_3494_Y_1881 MG2_X_4032_Y_1881 237.7m
R_MG2_seg_144 MG2_X_4032_Y_1881 MG2_X_4569_Y_1881 237.7m
R_MG2_seg_145 MG2_X_4569_Y_1881 MG2_X_5107_Y_1881 237.7m
R_MG2_seg_146 MG2_X_5107_Y_1881 MG2_X_5644_Y_1881 237.7m
R_MG2_seg_147 MG2_X_5644_Y_1881 MG2_X_6182_Y_1881 237.7m
R_MG2_seg_148 MG2_X_6182_Y_1881 MG2_X_6720_Y_1881 237.7m
R_MG2_seg_149 MG2_X_6720_Y_1881 MG2_X_7257_Y_1881 237.7m
R_MG2_seg_150 MG2_X_7257_Y_1881 MG2_X_7795_Y_1881 237.7m
R_MG2_seg_151 MG2_X_7795_Y_1881 MG2_X_8332_Y_1881 237.7m
R_MG2_seg_152 MG2_X_8332_Y_1881 MG2_X_8870_Y_1881 237.7m
R_MG2_seg_153 MG2_X_8870_Y_1881 MG2_X_9408_Y_1881 237.7m
R_MG2_seg_154 MG2_X_9408_Y_1881 MG2_X_9945_Y_1881 237.7m
R_MG2_seg_155 MG2_X_9945_Y_1881 MG2_X_10000_Y_1881 24.05m
R_MG2_seg_156 MG2_X_0_Y_2150 MG2_X_537_Y_2150 237.7m
R_MG2_seg_157 MG2_X_537_Y_2150 MG2_X_1075_Y_2150 237.7m
R_MG2_seg_158 MG2_X_1075_Y_2150 MG2_X_1612_Y_2150 237.7m
R_MG2_seg_159 MG2_X_1612_Y_2150 MG2_X_2150_Y_2150 237.7m
R_MG2_seg_160 MG2_X_2150_Y_2150 MG2_X_2688_Y_2150 237.7m
R_MG2_seg_161 MG2_X_2688_Y_2150 MG2_X_3225_Y_2150 237.7m
R_MG2_seg_162 MG2_X_3225_Y_2150 MG2_X_3763_Y_2150 237.7m
R_MG2_seg_163 MG2_X_3763_Y_2150 MG2_X_4300_Y_2150 237.7m
R_MG2_seg_164 MG2_X_4300_Y_2150 MG2_X_4838_Y_2150 237.7m
R_MG2_seg_165 MG2_X_4838_Y_2150 MG2_X_5376_Y_2150 237.7m
R_MG2_seg_166 MG2_X_5376_Y_2150 MG2_X_5913_Y_2150 237.7m
R_MG2_seg_167 MG2_X_5913_Y_2150 MG2_X_6451_Y_2150 237.7m
R_MG2_seg_168 MG2_X_6451_Y_2150 MG2_X_6988_Y_2150 237.7m
R_MG2_seg_169 MG2_X_6988_Y_2150 MG2_X_7526_Y_2150 237.7m
R_MG2_seg_170 MG2_X_7526_Y_2150 MG2_X_8064_Y_2150 237.7m
R_MG2_seg_171 MG2_X_8064_Y_2150 MG2_X_8601_Y_2150 237.7m
R_MG2_seg_172 MG2_X_8601_Y_2150 MG2_X_9139_Y_2150 237.7m
R_MG2_seg_173 MG2_X_9139_Y_2150 MG2_X_9676_Y_2150 237.7m
R_MG2_seg_174 MG2_X_9676_Y_2150 MG2_X_10000_Y_2150 142.9m
R_MG2_seg_175 MG2_X_0_Y_2419 MG2_X_268_Y_2419 118.8m
R_MG2_seg_176 MG2_X_268_Y_2419 MG2_X_806_Y_2419 237.7m
R_MG2_seg_177 MG2_X_806_Y_2419 MG2_X_1344_Y_2419 237.7m
R_MG2_seg_178 MG2_X_1344_Y_2419 MG2_X_1881_Y_2419 237.7m
R_MG2_seg_179 MG2_X_1881_Y_2419 MG2_X_2419_Y_2419 237.7m
R_MG2_seg_180 MG2_X_2419_Y_2419 MG2_X_2956_Y_2419 237.7m
R_MG2_seg_181 MG2_X_2956_Y_2419 MG2_X_3494_Y_2419 237.7m
R_MG2_seg_182 MG2_X_3494_Y_2419 MG2_X_4032_Y_2419 237.7m
R_MG2_seg_183 MG2_X_4032_Y_2419 MG2_X_4569_Y_2419 237.7m
R_MG2_seg_184 MG2_X_4569_Y_2419 MG2_X_5107_Y_2419 237.7m
R_MG2_seg_185 MG2_X_5107_Y_2419 MG2_X_5644_Y_2419 237.7m
R_MG2_seg_186 MG2_X_5644_Y_2419 MG2_X_6182_Y_2419 237.7m
R_MG2_seg_187 MG2_X_6182_Y_2419 MG2_X_6720_Y_2419 237.7m
R_MG2_seg_188 MG2_X_6720_Y_2419 MG2_X_7257_Y_2419 237.7m
R_MG2_seg_189 MG2_X_7257_Y_2419 MG2_X_7795_Y_2419 237.7m
R_MG2_seg_190 MG2_X_7795_Y_2419 MG2_X_8332_Y_2419 237.7m
R_MG2_seg_191 MG2_X_8332_Y_2419 MG2_X_8870_Y_2419 237.7m
R_MG2_seg_192 MG2_X_8870_Y_2419 MG2_X_9408_Y_2419 237.7m
R_MG2_seg_193 MG2_X_9408_Y_2419 MG2_X_9945_Y_2419 237.7m
R_MG2_seg_194 MG2_X_9945_Y_2419 MG2_X_10000_Y_2419 24.05m
R_MG2_seg_195 MG2_X_0_Y_2688 MG2_X_537_Y_2688 237.7m
R_MG2_seg_196 MG2_X_537_Y_2688 MG2_X_1075_Y_2688 237.7m
R_MG2_seg_197 MG2_X_1075_Y_2688 MG2_X_1612_Y_2688 237.7m
R_MG2_seg_198 MG2_X_1612_Y_2688 MG2_X_2150_Y_2688 237.7m
R_MG2_seg_199 MG2_X_2150_Y_2688 MG2_X_2688_Y_2688 237.7m
R_MG2_seg_200 MG2_X_2688_Y_2688 MG2_X_3225_Y_2688 237.7m
R_MG2_seg_201 MG2_X_3225_Y_2688 MG2_X_3763_Y_2688 237.7m
R_MG2_seg_202 MG2_X_3763_Y_2688 MG2_X_4300_Y_2688 237.7m
R_MG2_seg_203 MG2_X_4300_Y_2688 MG2_X_4838_Y_2688 237.7m
R_MG2_seg_204 MG2_X_4838_Y_2688 MG2_X_5376_Y_2688 237.7m
R_MG2_seg_205 MG2_X_5376_Y_2688 MG2_X_5913_Y_2688 237.7m
R_MG2_seg_206 MG2_X_5913_Y_2688 MG2_X_6451_Y_2688 237.7m
R_MG2_seg_207 MG2_X_6451_Y_2688 MG2_X_6988_Y_2688 237.7m
R_MG2_seg_208 MG2_X_6988_Y_2688 MG2_X_7526_Y_2688 237.7m
R_MG2_seg_209 MG2_X_7526_Y_2688 MG2_X_8064_Y_2688 237.7m
R_MG2_seg_210 MG2_X_8064_Y_2688 MG2_X_8601_Y_2688 237.7m
R_MG2_seg_211 MG2_X_8601_Y_2688 MG2_X_9139_Y_2688 237.7m
R_MG2_seg_212 MG2_X_9139_Y_2688 MG2_X_9676_Y_2688 237.7m
R_MG2_seg_213 MG2_X_9676_Y_2688 MG2_X_10000_Y_2688 142.9m
R_MG2_seg_214 MG2_X_0_Y_2956 MG2_X_268_Y_2956 118.8m
R_MG2_seg_215 MG2_X_268_Y_2956 MG2_X_806_Y_2956 237.7m
R_MG2_seg_216 MG2_X_806_Y_2956 MG2_X_1344_Y_2956 237.7m
R_MG2_seg_217 MG2_X_1344_Y_2956 MG2_X_1881_Y_2956 237.7m
R_MG2_seg_218 MG2_X_1881_Y_2956 MG2_X_2419_Y_2956 237.7m
R_MG2_seg_219 MG2_X_2419_Y_2956 MG2_X_2956_Y_2956 237.7m
R_MG2_seg_220 MG2_X_2956_Y_2956 MG2_X_3494_Y_2956 237.7m
R_MG2_seg_221 MG2_X_3494_Y_2956 MG2_X_4032_Y_2956 237.7m
R_MG2_seg_222 MG2_X_4032_Y_2956 MG2_X_4569_Y_2956 237.7m
R_MG2_seg_223 MG2_X_4569_Y_2956 MG2_X_5107_Y_2956 237.7m
R_MG2_seg_224 MG2_X_5107_Y_2956 MG2_X_5644_Y_2956 237.7m
R_MG2_seg_225 MG2_X_5644_Y_2956 MG2_X_6182_Y_2956 237.7m
R_MG2_seg_226 MG2_X_6182_Y_2956 MG2_X_6720_Y_2956 237.7m
R_MG2_seg_227 MG2_X_6720_Y_2956 MG2_X_7257_Y_2956 237.7m
R_MG2_seg_228 MG2_X_7257_Y_2956 MG2_X_7795_Y_2956 237.7m
R_MG2_seg_229 MG2_X_7795_Y_2956 MG2_X_8332_Y_2956 237.7m
R_MG2_seg_230 MG2_X_8332_Y_2956 MG2_X_8870_Y_2956 237.7m
R_MG2_seg_231 MG2_X_8870_Y_2956 MG2_X_9408_Y_2956 237.7m
R_MG2_seg_232 MG2_X_9408_Y_2956 MG2_X_9945_Y_2956 237.7m
R_MG2_seg_233 MG2_X_9945_Y_2956 MG2_X_10000_Y_2956 24.05m
R_MG2_seg_234 MG2_X_0_Y_3225 MG2_X_537_Y_3225 237.7m
R_MG2_seg_235 MG2_X_537_Y_3225 MG2_X_1075_Y_3225 237.7m
R_MG2_seg_236 MG2_X_1075_Y_3225 MG2_X_1612_Y_3225 237.7m
R_MG2_seg_237 MG2_X_1612_Y_3225 MG2_X_2150_Y_3225 237.7m
R_MG2_seg_238 MG2_X_2150_Y_3225 MG2_X_2688_Y_3225 237.7m
R_MG2_seg_239 MG2_X_2688_Y_3225 MG2_X_3225_Y_3225 237.7m
R_MG2_seg_240 MG2_X_3225_Y_3225 MG2_X_3763_Y_3225 237.7m
R_MG2_seg_241 MG2_X_3763_Y_3225 MG2_X_4300_Y_3225 237.7m
R_MG2_seg_242 MG2_X_4300_Y_3225 MG2_X_4838_Y_3225 237.7m
R_MG2_seg_243 MG2_X_4838_Y_3225 MG2_X_5376_Y_3225 237.7m
R_MG2_seg_244 MG2_X_5376_Y_3225 MG2_X_5913_Y_3225 237.7m
R_MG2_seg_245 MG2_X_5913_Y_3225 MG2_X_6451_Y_3225 237.7m
R_MG2_seg_246 MG2_X_6451_Y_3225 MG2_X_6988_Y_3225 237.7m
R_MG2_seg_247 MG2_X_6988_Y_3225 MG2_X_7526_Y_3225 237.7m
R_MG2_seg_248 MG2_X_7526_Y_3225 MG2_X_8064_Y_3225 237.7m
R_MG2_seg_249 MG2_X_8064_Y_3225 MG2_X_8601_Y_3225 237.7m
R_MG2_seg_250 MG2_X_8601_Y_3225 MG2_X_9139_Y_3225 237.7m
R_MG2_seg_251 MG2_X_9139_Y_3225 MG2_X_9676_Y_3225 237.7m
R_MG2_seg_252 MG2_X_9676_Y_3225 MG2_X_10000_Y_3225 142.9m
R_MG2_seg_253 MG2_X_0_Y_3494 MG2_X_268_Y_3494 118.8m
R_MG2_seg_254 MG2_X_268_Y_3494 MG2_X_806_Y_3494 237.7m
R_MG2_seg_255 MG2_X_806_Y_3494 MG2_X_1344_Y_3494 237.7m
R_MG2_seg_256 MG2_X_1344_Y_3494 MG2_X_1881_Y_3494 237.7m
R_MG2_seg_257 MG2_X_1881_Y_3494 MG2_X_2419_Y_3494 237.7m
R_MG2_seg_258 MG2_X_2419_Y_3494 MG2_X_2956_Y_3494 237.7m
R_MG2_seg_259 MG2_X_2956_Y_3494 MG2_X_3494_Y_3494 237.7m
R_MG2_seg_260 MG2_X_3494_Y_3494 MG2_X_4032_Y_3494 237.7m
R_MG2_seg_261 MG2_X_4032_Y_3494 MG2_X_4569_Y_3494 237.7m
R_MG2_seg_262 MG2_X_4569_Y_3494 MG2_X_5107_Y_3494 237.7m
R_MG2_seg_263 MG2_X_5107_Y_3494 MG2_X_5644_Y_3494 237.7m
R_MG2_seg_264 MG2_X_5644_Y_3494 MG2_X_6182_Y_3494 237.7m
R_MG2_seg_265 MG2_X_6182_Y_3494 MG2_X_6720_Y_3494 237.7m
R_MG2_seg_266 MG2_X_6720_Y_3494 MG2_X_7257_Y_3494 237.7m
R_MG2_seg_267 MG2_X_7257_Y_3494 MG2_X_7795_Y_3494 237.7m
R_MG2_seg_268 MG2_X_7795_Y_3494 MG2_X_8332_Y_3494 237.7m
R_MG2_seg_269 MG2_X_8332_Y_3494 MG2_X_8870_Y_3494 237.7m
R_MG2_seg_270 MG2_X_8870_Y_3494 MG2_X_9408_Y_3494 237.7m
R_MG2_seg_271 MG2_X_9408_Y_3494 MG2_X_9945_Y_3494 237.7m
R_MG2_seg_272 MG2_X_9945_Y_3494 MG2_X_10000_Y_3494 24.05m
R_MG2_seg_273 MG2_X_0_Y_3763 MG2_X_537_Y_3763 237.7m
R_MG2_seg_274 MG2_X_537_Y_3763 MG2_X_1075_Y_3763 237.7m
R_MG2_seg_275 MG2_X_1075_Y_3763 MG2_X_1612_Y_3763 237.7m
R_MG2_seg_276 MG2_X_1612_Y_3763 MG2_X_2150_Y_3763 237.7m
R_MG2_seg_277 MG2_X_2150_Y_3763 MG2_X_2688_Y_3763 237.7m
R_MG2_seg_278 MG2_X_2688_Y_3763 MG2_X_3225_Y_3763 237.7m
R_MG2_seg_279 MG2_X_3225_Y_3763 MG2_X_3763_Y_3763 237.7m
R_MG2_seg_280 MG2_X_3763_Y_3763 MG2_X_4300_Y_3763 237.7m
R_MG2_seg_281 MG2_X_4300_Y_3763 MG2_X_4838_Y_3763 237.7m
R_MG2_seg_282 MG2_X_4838_Y_3763 MG2_X_5376_Y_3763 237.7m
R_MG2_seg_283 MG2_X_5376_Y_3763 MG2_X_5913_Y_3763 237.7m
R_MG2_seg_284 MG2_X_5913_Y_3763 MG2_X_6451_Y_3763 237.7m
R_MG2_seg_285 MG2_X_6451_Y_3763 MG2_X_6988_Y_3763 237.7m
R_MG2_seg_286 MG2_X_6988_Y_3763 MG2_X_7526_Y_3763 237.7m
R_MG2_seg_287 MG2_X_7526_Y_3763 MG2_X_8064_Y_3763 237.7m
R_MG2_seg_288 MG2_X_8064_Y_3763 MG2_X_8601_Y_3763 237.7m
R_MG2_seg_289 MG2_X_8601_Y_3763 MG2_X_9139_Y_3763 237.7m
R_MG2_seg_290 MG2_X_9139_Y_3763 MG2_X_9676_Y_3763 237.7m
R_MG2_seg_291 MG2_X_9676_Y_3763 MG2_X_10000_Y_3763 142.9m
R_MG2_seg_292 MG2_X_0_Y_4032 MG2_X_268_Y_4032 118.8m
R_MG2_seg_293 MG2_X_268_Y_4032 MG2_X_806_Y_4032 237.7m
R_MG2_seg_294 MG2_X_806_Y_4032 MG2_X_1344_Y_4032 237.7m
R_MG2_seg_295 MG2_X_1344_Y_4032 MG2_X_1881_Y_4032 237.7m
R_MG2_seg_296 MG2_X_1881_Y_4032 MG2_X_2419_Y_4032 237.7m
R_MG2_seg_297 MG2_X_2419_Y_4032 MG2_X_2956_Y_4032 237.7m
R_MG2_seg_298 MG2_X_2956_Y_4032 MG2_X_3494_Y_4032 237.7m
R_MG2_seg_299 MG2_X_3494_Y_4032 MG2_X_4032_Y_4032 237.7m
R_MG2_seg_300 MG2_X_4032_Y_4032 MG2_X_4569_Y_4032 237.7m
R_MG2_seg_301 MG2_X_4569_Y_4032 MG2_X_5107_Y_4032 237.7m
R_MG2_seg_302 MG2_X_5107_Y_4032 MG2_X_5644_Y_4032 237.7m
R_MG2_seg_303 MG2_X_5644_Y_4032 MG2_X_6182_Y_4032 237.7m
R_MG2_seg_304 MG2_X_6182_Y_4032 MG2_X_6720_Y_4032 237.7m
R_MG2_seg_305 MG2_X_6720_Y_4032 MG2_X_7257_Y_4032 237.7m
R_MG2_seg_306 MG2_X_7257_Y_4032 MG2_X_7795_Y_4032 237.7m
R_MG2_seg_307 MG2_X_7795_Y_4032 MG2_X_8332_Y_4032 237.7m
R_MG2_seg_308 MG2_X_8332_Y_4032 MG2_X_8870_Y_4032 237.7m
R_MG2_seg_309 MG2_X_8870_Y_4032 MG2_X_9408_Y_4032 237.7m
R_MG2_seg_310 MG2_X_9408_Y_4032 MG2_X_9945_Y_4032 237.7m
R_MG2_seg_311 MG2_X_9945_Y_4032 MG2_X_10000_Y_4032 24.05m
R_MG2_seg_312 MG2_X_0_Y_4300 MG2_X_537_Y_4300 237.7m
R_MG2_seg_313 MG2_X_537_Y_4300 MG2_X_1075_Y_4300 237.7m
R_MG2_seg_314 MG2_X_1075_Y_4300 MG2_X_1612_Y_4300 237.7m
R_MG2_seg_315 MG2_X_1612_Y_4300 MG2_X_2150_Y_4300 237.7m
R_MG2_seg_316 MG2_X_2150_Y_4300 MG2_X_2688_Y_4300 237.7m
R_MG2_seg_317 MG2_X_2688_Y_4300 MG2_X_3225_Y_4300 237.7m
R_MG2_seg_318 MG2_X_3225_Y_4300 MG2_X_3763_Y_4300 237.7m
R_MG2_seg_319 MG2_X_3763_Y_4300 MG2_X_4300_Y_4300 237.7m
R_MG2_seg_320 MG2_X_4300_Y_4300 MG2_X_4838_Y_4300 237.7m
R_MG2_seg_321 MG2_X_4838_Y_4300 MG2_X_5376_Y_4300 237.7m
R_MG2_seg_322 MG2_X_5376_Y_4300 MG2_X_5913_Y_4300 237.7m
R_MG2_seg_323 MG2_X_5913_Y_4300 MG2_X_6451_Y_4300 237.7m
R_MG2_seg_324 MG2_X_6451_Y_4300 MG2_X_6988_Y_4300 237.7m
R_MG2_seg_325 MG2_X_6988_Y_4300 MG2_X_7526_Y_4300 237.7m
R_MG2_seg_326 MG2_X_7526_Y_4300 MG2_X_8064_Y_4300 237.7m
R_MG2_seg_327 MG2_X_8064_Y_4300 MG2_X_8601_Y_4300 237.7m
R_MG2_seg_328 MG2_X_8601_Y_4300 MG2_X_9139_Y_4300 237.7m
R_MG2_seg_329 MG2_X_9139_Y_4300 MG2_X_9676_Y_4300 237.7m
R_MG2_seg_330 MG2_X_9676_Y_4300 MG2_X_10000_Y_4300 142.9m
R_MG2_seg_331 MG2_X_0_Y_4569 MG2_X_268_Y_4569 118.8m
R_MG2_seg_332 MG2_X_268_Y_4569 MG2_X_806_Y_4569 237.7m
R_MG2_seg_333 MG2_X_806_Y_4569 MG2_X_1344_Y_4569 237.7m
R_MG2_seg_334 MG2_X_1344_Y_4569 MG2_X_1881_Y_4569 237.7m
R_MG2_seg_335 MG2_X_1881_Y_4569 MG2_X_2419_Y_4569 237.7m
R_MG2_seg_336 MG2_X_2419_Y_4569 MG2_X_2956_Y_4569 237.7m
R_MG2_seg_337 MG2_X_2956_Y_4569 MG2_X_3494_Y_4569 237.7m
R_MG2_seg_338 MG2_X_3494_Y_4569 MG2_X_4032_Y_4569 237.7m
R_MG2_seg_339 MG2_X_4032_Y_4569 MG2_X_4569_Y_4569 237.7m
R_MG2_seg_340 MG2_X_4569_Y_4569 MG2_X_5107_Y_4569 237.7m
R_MG2_seg_341 MG2_X_5107_Y_4569 MG2_X_5644_Y_4569 237.7m
R_MG2_seg_342 MG2_X_5644_Y_4569 MG2_X_6182_Y_4569 237.7m
R_MG2_seg_343 MG2_X_6182_Y_4569 MG2_X_6720_Y_4569 237.7m
R_MG2_seg_344 MG2_X_6720_Y_4569 MG2_X_7257_Y_4569 237.7m
R_MG2_seg_345 MG2_X_7257_Y_4569 MG2_X_7795_Y_4569 237.7m
R_MG2_seg_346 MG2_X_7795_Y_4569 MG2_X_8332_Y_4569 237.7m
R_MG2_seg_347 MG2_X_8332_Y_4569 MG2_X_8870_Y_4569 237.7m
R_MG2_seg_348 MG2_X_8870_Y_4569 MG2_X_9408_Y_4569 237.7m
R_MG2_seg_349 MG2_X_9408_Y_4569 MG2_X_9945_Y_4569 237.7m
R_MG2_seg_350 MG2_X_9945_Y_4569 MG2_X_10000_Y_4569 24.05m
R_MG2_seg_351 MG2_X_0_Y_4838 MG2_X_537_Y_4838 237.7m
R_MG2_seg_352 MG2_X_537_Y_4838 MG2_X_1075_Y_4838 237.7m
R_MG2_seg_353 MG2_X_1075_Y_4838 MG2_X_1612_Y_4838 237.7m
R_MG2_seg_354 MG2_X_1612_Y_4838 MG2_X_2150_Y_4838 237.7m
R_MG2_seg_355 MG2_X_2150_Y_4838 MG2_X_2688_Y_4838 237.7m
R_MG2_seg_356 MG2_X_2688_Y_4838 MG2_X_3225_Y_4838 237.7m
R_MG2_seg_357 MG2_X_3225_Y_4838 MG2_X_3763_Y_4838 237.7m
R_MG2_seg_358 MG2_X_3763_Y_4838 MG2_X_4300_Y_4838 237.7m
R_MG2_seg_359 MG2_X_4300_Y_4838 MG2_X_4838_Y_4838 237.7m
R_MG2_seg_360 MG2_X_4838_Y_4838 MG2_X_5376_Y_4838 237.7m
R_MG2_seg_361 MG2_X_5376_Y_4838 MG2_X_5913_Y_4838 237.7m
R_MG2_seg_362 MG2_X_5913_Y_4838 MG2_X_6451_Y_4838 237.7m
R_MG2_seg_363 MG2_X_6451_Y_4838 MG2_X_6988_Y_4838 237.7m
R_MG2_seg_364 MG2_X_6988_Y_4838 MG2_X_7526_Y_4838 237.7m
R_MG2_seg_365 MG2_X_7526_Y_4838 MG2_X_8064_Y_4838 237.7m
R_MG2_seg_366 MG2_X_8064_Y_4838 MG2_X_8601_Y_4838 237.7m
R_MG2_seg_367 MG2_X_8601_Y_4838 MG2_X_9139_Y_4838 237.7m
R_MG2_seg_368 MG2_X_9139_Y_4838 MG2_X_9676_Y_4838 237.7m
R_MG2_seg_369 MG2_X_9676_Y_4838 MG2_X_10000_Y_4838 142.9m
R_MG2_seg_370 MG2_X_0_Y_5107 MG2_X_268_Y_5107 118.8m
R_MG2_seg_371 MG2_X_268_Y_5107 MG2_X_806_Y_5107 237.7m
R_MG2_seg_372 MG2_X_806_Y_5107 MG2_X_1344_Y_5107 237.7m
R_MG2_seg_373 MG2_X_1344_Y_5107 MG2_X_1881_Y_5107 237.7m
R_MG2_seg_374 MG2_X_1881_Y_5107 MG2_X_2419_Y_5107 237.7m
R_MG2_seg_375 MG2_X_2419_Y_5107 MG2_X_2956_Y_5107 237.7m
R_MG2_seg_376 MG2_X_2956_Y_5107 MG2_X_3494_Y_5107 237.7m
R_MG2_seg_377 MG2_X_3494_Y_5107 MG2_X_4032_Y_5107 237.7m
R_MG2_seg_378 MG2_X_4032_Y_5107 MG2_X_4569_Y_5107 237.7m
R_MG2_seg_379 MG2_X_4569_Y_5107 MG2_X_5107_Y_5107 237.7m
R_MG2_seg_380 MG2_X_5107_Y_5107 MG2_X_5644_Y_5107 237.7m
R_MG2_seg_381 MG2_X_5644_Y_5107 MG2_X_6182_Y_5107 237.7m
R_MG2_seg_382 MG2_X_6182_Y_5107 MG2_X_6720_Y_5107 237.7m
R_MG2_seg_383 MG2_X_6720_Y_5107 MG2_X_7257_Y_5107 237.7m
R_MG2_seg_384 MG2_X_7257_Y_5107 MG2_X_7795_Y_5107 237.7m
R_MG2_seg_385 MG2_X_7795_Y_5107 MG2_X_8332_Y_5107 237.7m
R_MG2_seg_386 MG2_X_8332_Y_5107 MG2_X_8870_Y_5107 237.7m
R_MG2_seg_387 MG2_X_8870_Y_5107 MG2_X_9408_Y_5107 237.7m
R_MG2_seg_388 MG2_X_9408_Y_5107 MG2_X_9945_Y_5107 237.7m
R_MG2_seg_389 MG2_X_9945_Y_5107 MG2_X_10000_Y_5107 24.05m
R_MG2_seg_390 MG2_X_0_Y_5376 MG2_X_537_Y_5376 237.7m
R_MG2_seg_391 MG2_X_537_Y_5376 MG2_X_1075_Y_5376 237.7m
R_MG2_seg_392 MG2_X_1075_Y_5376 MG2_X_1612_Y_5376 237.7m
R_MG2_seg_393 MG2_X_1612_Y_5376 MG2_X_2150_Y_5376 237.7m
R_MG2_seg_394 MG2_X_2150_Y_5376 MG2_X_2688_Y_5376 237.7m
R_MG2_seg_395 MG2_X_2688_Y_5376 MG2_X_3225_Y_5376 237.7m
R_MG2_seg_396 MG2_X_3225_Y_5376 MG2_X_3763_Y_5376 237.7m
R_MG2_seg_397 MG2_X_3763_Y_5376 MG2_X_4300_Y_5376 237.7m
R_MG2_seg_398 MG2_X_4300_Y_5376 MG2_X_4838_Y_5376 237.7m
R_MG2_seg_399 MG2_X_4838_Y_5376 MG2_X_5376_Y_5376 237.7m
R_MG2_seg_400 MG2_X_5376_Y_5376 MG2_X_5913_Y_5376 237.7m
R_MG2_seg_401 MG2_X_5913_Y_5376 MG2_X_6451_Y_5376 237.7m
R_MG2_seg_402 MG2_X_6451_Y_5376 MG2_X_6988_Y_5376 237.7m
R_MG2_seg_403 MG2_X_6988_Y_5376 MG2_X_7526_Y_5376 237.7m
R_MG2_seg_404 MG2_X_7526_Y_5376 MG2_X_8064_Y_5376 237.7m
R_MG2_seg_405 MG2_X_8064_Y_5376 MG2_X_8601_Y_5376 237.7m
R_MG2_seg_406 MG2_X_8601_Y_5376 MG2_X_9139_Y_5376 237.7m
R_MG2_seg_407 MG2_X_9139_Y_5376 MG2_X_9676_Y_5376 237.7m
R_MG2_seg_408 MG2_X_9676_Y_5376 MG2_X_10000_Y_5376 142.9m
R_MG2_seg_409 MG2_X_0_Y_5644 MG2_X_268_Y_5644 118.8m
R_MG2_seg_410 MG2_X_268_Y_5644 MG2_X_806_Y_5644 237.7m
R_MG2_seg_411 MG2_X_806_Y_5644 MG2_X_1344_Y_5644 237.7m
R_MG2_seg_412 MG2_X_1344_Y_5644 MG2_X_1881_Y_5644 237.7m
R_MG2_seg_413 MG2_X_1881_Y_5644 MG2_X_2419_Y_5644 237.7m
R_MG2_seg_414 MG2_X_2419_Y_5644 MG2_X_2956_Y_5644 237.7m
R_MG2_seg_415 MG2_X_2956_Y_5644 MG2_X_3494_Y_5644 237.7m
R_MG2_seg_416 MG2_X_3494_Y_5644 MG2_X_4032_Y_5644 237.7m
R_MG2_seg_417 MG2_X_4032_Y_5644 MG2_X_4569_Y_5644 237.7m
R_MG2_seg_418 MG2_X_4569_Y_5644 MG2_X_5107_Y_5644 237.7m
R_MG2_seg_419 MG2_X_5107_Y_5644 MG2_X_5644_Y_5644 237.7m
R_MG2_seg_420 MG2_X_5644_Y_5644 MG2_X_6182_Y_5644 237.7m
R_MG2_seg_421 MG2_X_6182_Y_5644 MG2_X_6720_Y_5644 237.7m
R_MG2_seg_422 MG2_X_6720_Y_5644 MG2_X_7257_Y_5644 237.7m
R_MG2_seg_423 MG2_X_7257_Y_5644 MG2_X_7795_Y_5644 237.7m
R_MG2_seg_424 MG2_X_7795_Y_5644 MG2_X_8332_Y_5644 237.7m
R_MG2_seg_425 MG2_X_8332_Y_5644 MG2_X_8870_Y_5644 237.7m
R_MG2_seg_426 MG2_X_8870_Y_5644 MG2_X_9408_Y_5644 237.7m
R_MG2_seg_427 MG2_X_9408_Y_5644 MG2_X_9945_Y_5644 237.7m
R_MG2_seg_428 MG2_X_9945_Y_5644 MG2_X_10000_Y_5644 24.05m
R_MG2_seg_429 MG2_X_0_Y_5913 MG2_X_537_Y_5913 237.7m
R_MG2_seg_430 MG2_X_537_Y_5913 MG2_X_1075_Y_5913 237.7m
R_MG2_seg_431 MG2_X_1075_Y_5913 MG2_X_1612_Y_5913 237.7m
R_MG2_seg_432 MG2_X_1612_Y_5913 MG2_X_2150_Y_5913 237.7m
R_MG2_seg_433 MG2_X_2150_Y_5913 MG2_X_2688_Y_5913 237.7m
R_MG2_seg_434 MG2_X_2688_Y_5913 MG2_X_3225_Y_5913 237.7m
R_MG2_seg_435 MG2_X_3225_Y_5913 MG2_X_3763_Y_5913 237.7m
R_MG2_seg_436 MG2_X_3763_Y_5913 MG2_X_4300_Y_5913 237.7m
R_MG2_seg_437 MG2_X_4300_Y_5913 MG2_X_4838_Y_5913 237.7m
R_MG2_seg_438 MG2_X_4838_Y_5913 MG2_X_5376_Y_5913 237.7m
R_MG2_seg_439 MG2_X_5376_Y_5913 MG2_X_5913_Y_5913 237.7m
R_MG2_seg_440 MG2_X_5913_Y_5913 MG2_X_6451_Y_5913 237.7m
R_MG2_seg_441 MG2_X_6451_Y_5913 MG2_X_6988_Y_5913 237.7m
R_MG2_seg_442 MG2_X_6988_Y_5913 MG2_X_7526_Y_5913 237.7m
R_MG2_seg_443 MG2_X_7526_Y_5913 MG2_X_8064_Y_5913 237.7m
R_MG2_seg_444 MG2_X_8064_Y_5913 MG2_X_8601_Y_5913 237.7m
R_MG2_seg_445 MG2_X_8601_Y_5913 MG2_X_9139_Y_5913 237.7m
R_MG2_seg_446 MG2_X_9139_Y_5913 MG2_X_9676_Y_5913 237.7m
R_MG2_seg_447 MG2_X_9676_Y_5913 MG2_X_10000_Y_5913 142.9m
R_MG2_seg_448 MG2_X_0_Y_6182 MG2_X_268_Y_6182 118.8m
R_MG2_seg_449 MG2_X_268_Y_6182 MG2_X_806_Y_6182 237.7m
R_MG2_seg_450 MG2_X_806_Y_6182 MG2_X_1344_Y_6182 237.7m
R_MG2_seg_451 MG2_X_1344_Y_6182 MG2_X_1881_Y_6182 237.7m
R_MG2_seg_452 MG2_X_1881_Y_6182 MG2_X_2419_Y_6182 237.7m
R_MG2_seg_453 MG2_X_2419_Y_6182 MG2_X_2956_Y_6182 237.7m
R_MG2_seg_454 MG2_X_2956_Y_6182 MG2_X_3494_Y_6182 237.7m
R_MG2_seg_455 MG2_X_3494_Y_6182 MG2_X_4032_Y_6182 237.7m
R_MG2_seg_456 MG2_X_4032_Y_6182 MG2_X_4569_Y_6182 237.7m
R_MG2_seg_457 MG2_X_4569_Y_6182 MG2_X_5107_Y_6182 237.7m
R_MG2_seg_458 MG2_X_5107_Y_6182 MG2_X_5644_Y_6182 237.7m
R_MG2_seg_459 MG2_X_5644_Y_6182 MG2_X_6182_Y_6182 237.7m
R_MG2_seg_460 MG2_X_6182_Y_6182 MG2_X_6720_Y_6182 237.7m
R_MG2_seg_461 MG2_X_6720_Y_6182 MG2_X_7257_Y_6182 237.7m
R_MG2_seg_462 MG2_X_7257_Y_6182 MG2_X_7795_Y_6182 237.7m
R_MG2_seg_463 MG2_X_7795_Y_6182 MG2_X_8332_Y_6182 237.7m
R_MG2_seg_464 MG2_X_8332_Y_6182 MG2_X_8870_Y_6182 237.7m
R_MG2_seg_465 MG2_X_8870_Y_6182 MG2_X_9408_Y_6182 237.7m
R_MG2_seg_466 MG2_X_9408_Y_6182 MG2_X_9945_Y_6182 237.7m
R_MG2_seg_467 MG2_X_9945_Y_6182 MG2_X_10000_Y_6182 24.05m
R_MG2_seg_468 MG2_X_0_Y_6451 MG2_X_537_Y_6451 237.7m
R_MG2_seg_469 MG2_X_537_Y_6451 MG2_X_1075_Y_6451 237.7m
R_MG2_seg_470 MG2_X_1075_Y_6451 MG2_X_1612_Y_6451 237.7m
R_MG2_seg_471 MG2_X_1612_Y_6451 MG2_X_2150_Y_6451 237.7m
R_MG2_seg_472 MG2_X_2150_Y_6451 MG2_X_2688_Y_6451 237.7m
R_MG2_seg_473 MG2_X_2688_Y_6451 MG2_X_3225_Y_6451 237.7m
R_MG2_seg_474 MG2_X_3225_Y_6451 MG2_X_3763_Y_6451 237.7m
R_MG2_seg_475 MG2_X_3763_Y_6451 MG2_X_4300_Y_6451 237.7m
R_MG2_seg_476 MG2_X_4300_Y_6451 MG2_X_4838_Y_6451 237.7m
R_MG2_seg_477 MG2_X_4838_Y_6451 MG2_X_5376_Y_6451 237.7m
R_MG2_seg_478 MG2_X_5376_Y_6451 MG2_X_5913_Y_6451 237.7m
R_MG2_seg_479 MG2_X_5913_Y_6451 MG2_X_6451_Y_6451 237.7m
R_MG2_seg_480 MG2_X_6451_Y_6451 MG2_X_6988_Y_6451 237.7m
R_MG2_seg_481 MG2_X_6988_Y_6451 MG2_X_7526_Y_6451 237.7m
R_MG2_seg_482 MG2_X_7526_Y_6451 MG2_X_8064_Y_6451 237.7m
R_MG2_seg_483 MG2_X_8064_Y_6451 MG2_X_8601_Y_6451 237.7m
R_MG2_seg_484 MG2_X_8601_Y_6451 MG2_X_9139_Y_6451 237.7m
R_MG2_seg_485 MG2_X_9139_Y_6451 MG2_X_9676_Y_6451 237.7m
R_MG2_seg_486 MG2_X_9676_Y_6451 MG2_X_10000_Y_6451 142.9m
R_MG2_seg_487 MG2_X_0_Y_6720 MG2_X_268_Y_6720 118.8m
R_MG2_seg_488 MG2_X_268_Y_6720 MG2_X_806_Y_6720 237.7m
R_MG2_seg_489 MG2_X_806_Y_6720 MG2_X_1344_Y_6720 237.7m
R_MG2_seg_490 MG2_X_1344_Y_6720 MG2_X_1881_Y_6720 237.7m
R_MG2_seg_491 MG2_X_1881_Y_6720 MG2_X_2419_Y_6720 237.7m
R_MG2_seg_492 MG2_X_2419_Y_6720 MG2_X_2956_Y_6720 237.7m
R_MG2_seg_493 MG2_X_2956_Y_6720 MG2_X_3494_Y_6720 237.7m
R_MG2_seg_494 MG2_X_3494_Y_6720 MG2_X_4032_Y_6720 237.7m
R_MG2_seg_495 MG2_X_4032_Y_6720 MG2_X_4569_Y_6720 237.7m
R_MG2_seg_496 MG2_X_4569_Y_6720 MG2_X_5107_Y_6720 237.7m
R_MG2_seg_497 MG2_X_5107_Y_6720 MG2_X_5644_Y_6720 237.7m
R_MG2_seg_498 MG2_X_5644_Y_6720 MG2_X_6182_Y_6720 237.7m
R_MG2_seg_499 MG2_X_6182_Y_6720 MG2_X_6720_Y_6720 237.7m
R_MG2_seg_500 MG2_X_6720_Y_6720 MG2_X_7257_Y_6720 237.7m
R_MG2_seg_501 MG2_X_7257_Y_6720 MG2_X_7795_Y_6720 237.7m
R_MG2_seg_502 MG2_X_7795_Y_6720 MG2_X_8332_Y_6720 237.7m
R_MG2_seg_503 MG2_X_8332_Y_6720 MG2_X_8870_Y_6720 237.7m
R_MG2_seg_504 MG2_X_8870_Y_6720 MG2_X_9408_Y_6720 237.7m
R_MG2_seg_505 MG2_X_9408_Y_6720 MG2_X_9945_Y_6720 237.7m
R_MG2_seg_506 MG2_X_9945_Y_6720 MG2_X_10000_Y_6720 24.05m
R_MG2_seg_507 MG2_X_0_Y_6988 MG2_X_537_Y_6988 237.7m
R_MG2_seg_508 MG2_X_537_Y_6988 MG2_X_1075_Y_6988 237.7m
R_MG2_seg_509 MG2_X_1075_Y_6988 MG2_X_1612_Y_6988 237.7m
R_MG2_seg_510 MG2_X_1612_Y_6988 MG2_X_2150_Y_6988 237.7m
R_MG2_seg_511 MG2_X_2150_Y_6988 MG2_X_2688_Y_6988 237.7m
R_MG2_seg_512 MG2_X_2688_Y_6988 MG2_X_3225_Y_6988 237.7m
R_MG2_seg_513 MG2_X_3225_Y_6988 MG2_X_3763_Y_6988 237.7m
R_MG2_seg_514 MG2_X_3763_Y_6988 MG2_X_4300_Y_6988 237.7m
R_MG2_seg_515 MG2_X_4300_Y_6988 MG2_X_4838_Y_6988 237.7m
R_MG2_seg_516 MG2_X_4838_Y_6988 MG2_X_5376_Y_6988 237.7m
R_MG2_seg_517 MG2_X_5376_Y_6988 MG2_X_5913_Y_6988 237.7m
R_MG2_seg_518 MG2_X_5913_Y_6988 MG2_X_6451_Y_6988 237.7m
R_MG2_seg_519 MG2_X_6451_Y_6988 MG2_X_6988_Y_6988 237.7m
R_MG2_seg_520 MG2_X_6988_Y_6988 MG2_X_7526_Y_6988 237.7m
R_MG2_seg_521 MG2_X_7526_Y_6988 MG2_X_8064_Y_6988 237.7m
R_MG2_seg_522 MG2_X_8064_Y_6988 MG2_X_8601_Y_6988 237.7m
R_MG2_seg_523 MG2_X_8601_Y_6988 MG2_X_9139_Y_6988 237.7m
R_MG2_seg_524 MG2_X_9139_Y_6988 MG2_X_9676_Y_6988 237.7m
R_MG2_seg_525 MG2_X_9676_Y_6988 MG2_X_10000_Y_6988 142.9m
R_MG2_seg_526 MG2_X_0_Y_7257 MG2_X_268_Y_7257 118.8m
R_MG2_seg_527 MG2_X_268_Y_7257 MG2_X_806_Y_7257 237.7m
R_MG2_seg_528 MG2_X_806_Y_7257 MG2_X_1344_Y_7257 237.7m
R_MG2_seg_529 MG2_X_1344_Y_7257 MG2_X_1881_Y_7257 237.7m
R_MG2_seg_530 MG2_X_1881_Y_7257 MG2_X_2419_Y_7257 237.7m
R_MG2_seg_531 MG2_X_2419_Y_7257 MG2_X_2956_Y_7257 237.7m
R_MG2_seg_532 MG2_X_2956_Y_7257 MG2_X_3494_Y_7257 237.7m
R_MG2_seg_533 MG2_X_3494_Y_7257 MG2_X_4032_Y_7257 237.7m
R_MG2_seg_534 MG2_X_4032_Y_7257 MG2_X_4569_Y_7257 237.7m
R_MG2_seg_535 MG2_X_4569_Y_7257 MG2_X_5107_Y_7257 237.7m
R_MG2_seg_536 MG2_X_5107_Y_7257 MG2_X_5644_Y_7257 237.7m
R_MG2_seg_537 MG2_X_5644_Y_7257 MG2_X_6182_Y_7257 237.7m
R_MG2_seg_538 MG2_X_6182_Y_7257 MG2_X_6720_Y_7257 237.7m
R_MG2_seg_539 MG2_X_6720_Y_7257 MG2_X_7257_Y_7257 237.7m
R_MG2_seg_540 MG2_X_7257_Y_7257 MG2_X_7795_Y_7257 237.7m
R_MG2_seg_541 MG2_X_7795_Y_7257 MG2_X_8332_Y_7257 237.7m
R_MG2_seg_542 MG2_X_8332_Y_7257 MG2_X_8870_Y_7257 237.7m
R_MG2_seg_543 MG2_X_8870_Y_7257 MG2_X_9408_Y_7257 237.7m
R_MG2_seg_544 MG2_X_9408_Y_7257 MG2_X_9945_Y_7257 237.7m
R_MG2_seg_545 MG2_X_9945_Y_7257 MG2_X_10000_Y_7257 24.05m
R_MG2_seg_546 MG2_X_0_Y_7526 MG2_X_537_Y_7526 237.7m
R_MG2_seg_547 MG2_X_537_Y_7526 MG2_X_1075_Y_7526 237.7m
R_MG2_seg_548 MG2_X_1075_Y_7526 MG2_X_1612_Y_7526 237.7m
R_MG2_seg_549 MG2_X_1612_Y_7526 MG2_X_2150_Y_7526 237.7m
R_MG2_seg_550 MG2_X_2150_Y_7526 MG2_X_2688_Y_7526 237.7m
R_MG2_seg_551 MG2_X_2688_Y_7526 MG2_X_3225_Y_7526 237.7m
R_MG2_seg_552 MG2_X_3225_Y_7526 MG2_X_3763_Y_7526 237.7m
R_MG2_seg_553 MG2_X_3763_Y_7526 MG2_X_4300_Y_7526 237.7m
R_MG2_seg_554 MG2_X_4300_Y_7526 MG2_X_4838_Y_7526 237.7m
R_MG2_seg_555 MG2_X_4838_Y_7526 MG2_X_5376_Y_7526 237.7m
R_MG2_seg_556 MG2_X_5376_Y_7526 MG2_X_5913_Y_7526 237.7m
R_MG2_seg_557 MG2_X_5913_Y_7526 MG2_X_6451_Y_7526 237.7m
R_MG2_seg_558 MG2_X_6451_Y_7526 MG2_X_6988_Y_7526 237.7m
R_MG2_seg_559 MG2_X_6988_Y_7526 MG2_X_7526_Y_7526 237.7m
R_MG2_seg_560 MG2_X_7526_Y_7526 MG2_X_8064_Y_7526 237.7m
R_MG2_seg_561 MG2_X_8064_Y_7526 MG2_X_8601_Y_7526 237.7m
R_MG2_seg_562 MG2_X_8601_Y_7526 MG2_X_9139_Y_7526 237.7m
R_MG2_seg_563 MG2_X_9139_Y_7526 MG2_X_9676_Y_7526 237.7m
R_MG2_seg_564 MG2_X_9676_Y_7526 MG2_X_10000_Y_7526 142.9m
R_MG2_seg_565 MG2_X_0_Y_7795 MG2_X_268_Y_7795 118.8m
R_MG2_seg_566 MG2_X_268_Y_7795 MG2_X_806_Y_7795 237.7m
R_MG2_seg_567 MG2_X_806_Y_7795 MG2_X_1344_Y_7795 237.7m
R_MG2_seg_568 MG2_X_1344_Y_7795 MG2_X_1881_Y_7795 237.7m
R_MG2_seg_569 MG2_X_1881_Y_7795 MG2_X_2419_Y_7795 237.7m
R_MG2_seg_570 MG2_X_2419_Y_7795 MG2_X_2956_Y_7795 237.7m
R_MG2_seg_571 MG2_X_2956_Y_7795 MG2_X_3494_Y_7795 237.7m
R_MG2_seg_572 MG2_X_3494_Y_7795 MG2_X_4032_Y_7795 237.7m
R_MG2_seg_573 MG2_X_4032_Y_7795 MG2_X_4569_Y_7795 237.7m
R_MG2_seg_574 MG2_X_4569_Y_7795 MG2_X_5107_Y_7795 237.7m
R_MG2_seg_575 MG2_X_5107_Y_7795 MG2_X_5644_Y_7795 237.7m
R_MG2_seg_576 MG2_X_5644_Y_7795 MG2_X_6182_Y_7795 237.7m
R_MG2_seg_577 MG2_X_6182_Y_7795 MG2_X_6720_Y_7795 237.7m
R_MG2_seg_578 MG2_X_6720_Y_7795 MG2_X_7257_Y_7795 237.7m
R_MG2_seg_579 MG2_X_7257_Y_7795 MG2_X_7795_Y_7795 237.7m
R_MG2_seg_580 MG2_X_7795_Y_7795 MG2_X_8332_Y_7795 237.7m
R_MG2_seg_581 MG2_X_8332_Y_7795 MG2_X_8870_Y_7795 237.7m
R_MG2_seg_582 MG2_X_8870_Y_7795 MG2_X_9408_Y_7795 237.7m
R_MG2_seg_583 MG2_X_9408_Y_7795 MG2_X_9945_Y_7795 237.7m
R_MG2_seg_584 MG2_X_9945_Y_7795 MG2_X_10000_Y_7795 24.05m
R_MG2_seg_585 MG2_X_0_Y_8064 MG2_X_537_Y_8064 237.7m
R_MG2_seg_586 MG2_X_537_Y_8064 MG2_X_1075_Y_8064 237.7m
R_MG2_seg_587 MG2_X_1075_Y_8064 MG2_X_1612_Y_8064 237.7m
R_MG2_seg_588 MG2_X_1612_Y_8064 MG2_X_2150_Y_8064 237.7m
R_MG2_seg_589 MG2_X_2150_Y_8064 MG2_X_2688_Y_8064 237.7m
R_MG2_seg_590 MG2_X_2688_Y_8064 MG2_X_3225_Y_8064 237.7m
R_MG2_seg_591 MG2_X_3225_Y_8064 MG2_X_3763_Y_8064 237.7m
R_MG2_seg_592 MG2_X_3763_Y_8064 MG2_X_4300_Y_8064 237.7m
R_MG2_seg_593 MG2_X_4300_Y_8064 MG2_X_4838_Y_8064 237.7m
R_MG2_seg_594 MG2_X_4838_Y_8064 MG2_X_5376_Y_8064 237.7m
R_MG2_seg_595 MG2_X_5376_Y_8064 MG2_X_5913_Y_8064 237.7m
R_MG2_seg_596 MG2_X_5913_Y_8064 MG2_X_6451_Y_8064 237.7m
R_MG2_seg_597 MG2_X_6451_Y_8064 MG2_X_6988_Y_8064 237.7m
R_MG2_seg_598 MG2_X_6988_Y_8064 MG2_X_7526_Y_8064 237.7m
R_MG2_seg_599 MG2_X_7526_Y_8064 MG2_X_8064_Y_8064 237.7m
R_MG2_seg_600 MG2_X_8064_Y_8064 MG2_X_8601_Y_8064 237.7m
R_MG2_seg_601 MG2_X_8601_Y_8064 MG2_X_9139_Y_8064 237.7m
R_MG2_seg_602 MG2_X_9139_Y_8064 MG2_X_9676_Y_8064 237.7m
R_MG2_seg_603 MG2_X_9676_Y_8064 MG2_X_10000_Y_8064 142.9m
R_MG2_seg_604 MG2_X_0_Y_8332 MG2_X_268_Y_8332 118.8m
R_MG2_seg_605 MG2_X_268_Y_8332 MG2_X_806_Y_8332 237.7m
R_MG2_seg_606 MG2_X_806_Y_8332 MG2_X_1344_Y_8332 237.7m
R_MG2_seg_607 MG2_X_1344_Y_8332 MG2_X_1881_Y_8332 237.7m
R_MG2_seg_608 MG2_X_1881_Y_8332 MG2_X_2419_Y_8332 237.7m
R_MG2_seg_609 MG2_X_2419_Y_8332 MG2_X_2956_Y_8332 237.7m
R_MG2_seg_610 MG2_X_2956_Y_8332 MG2_X_3494_Y_8332 237.7m
R_MG2_seg_611 MG2_X_3494_Y_8332 MG2_X_4032_Y_8332 237.7m
R_MG2_seg_612 MG2_X_4032_Y_8332 MG2_X_4569_Y_8332 237.7m
R_MG2_seg_613 MG2_X_4569_Y_8332 MG2_X_5107_Y_8332 237.7m
R_MG2_seg_614 MG2_X_5107_Y_8332 MG2_X_5644_Y_8332 237.7m
R_MG2_seg_615 MG2_X_5644_Y_8332 MG2_X_6182_Y_8332 237.7m
R_MG2_seg_616 MG2_X_6182_Y_8332 MG2_X_6720_Y_8332 237.7m
R_MG2_seg_617 MG2_X_6720_Y_8332 MG2_X_7257_Y_8332 237.7m
R_MG2_seg_618 MG2_X_7257_Y_8332 MG2_X_7795_Y_8332 237.7m
R_MG2_seg_619 MG2_X_7795_Y_8332 MG2_X_8332_Y_8332 237.7m
R_MG2_seg_620 MG2_X_8332_Y_8332 MG2_X_8870_Y_8332 237.7m
R_MG2_seg_621 MG2_X_8870_Y_8332 MG2_X_9408_Y_8332 237.7m
R_MG2_seg_622 MG2_X_9408_Y_8332 MG2_X_9945_Y_8332 237.7m
R_MG2_seg_623 MG2_X_9945_Y_8332 MG2_X_10000_Y_8332 24.05m
R_MG2_seg_624 MG2_X_0_Y_8601 MG2_X_537_Y_8601 237.7m
R_MG2_seg_625 MG2_X_537_Y_8601 MG2_X_1075_Y_8601 237.7m
R_MG2_seg_626 MG2_X_1075_Y_8601 MG2_X_1612_Y_8601 237.7m
R_MG2_seg_627 MG2_X_1612_Y_8601 MG2_X_2150_Y_8601 237.7m
R_MG2_seg_628 MG2_X_2150_Y_8601 MG2_X_2688_Y_8601 237.7m
R_MG2_seg_629 MG2_X_2688_Y_8601 MG2_X_3225_Y_8601 237.7m
R_MG2_seg_630 MG2_X_3225_Y_8601 MG2_X_3763_Y_8601 237.7m
R_MG2_seg_631 MG2_X_3763_Y_8601 MG2_X_4300_Y_8601 237.7m
R_MG2_seg_632 MG2_X_4300_Y_8601 MG2_X_4838_Y_8601 237.7m
R_MG2_seg_633 MG2_X_4838_Y_8601 MG2_X_5376_Y_8601 237.7m
R_MG2_seg_634 MG2_X_5376_Y_8601 MG2_X_5913_Y_8601 237.7m
R_MG2_seg_635 MG2_X_5913_Y_8601 MG2_X_6451_Y_8601 237.7m
R_MG2_seg_636 MG2_X_6451_Y_8601 MG2_X_6988_Y_8601 237.7m
R_MG2_seg_637 MG2_X_6988_Y_8601 MG2_X_7526_Y_8601 237.7m
R_MG2_seg_638 MG2_X_7526_Y_8601 MG2_X_8064_Y_8601 237.7m
R_MG2_seg_639 MG2_X_8064_Y_8601 MG2_X_8601_Y_8601 237.7m
R_MG2_seg_640 MG2_X_8601_Y_8601 MG2_X_9139_Y_8601 237.7m
R_MG2_seg_641 MG2_X_9139_Y_8601 MG2_X_9676_Y_8601 237.7m
R_MG2_seg_642 MG2_X_9676_Y_8601 MG2_X_10000_Y_8601 142.9m
R_MG2_seg_643 MG2_X_0_Y_8870 MG2_X_268_Y_8870 118.8m
R_MG2_seg_644 MG2_X_268_Y_8870 MG2_X_806_Y_8870 237.7m
R_MG2_seg_645 MG2_X_806_Y_8870 MG2_X_1344_Y_8870 237.7m
R_MG2_seg_646 MG2_X_1344_Y_8870 MG2_X_1881_Y_8870 237.7m
R_MG2_seg_647 MG2_X_1881_Y_8870 MG2_X_2419_Y_8870 237.7m
R_MG2_seg_648 MG2_X_2419_Y_8870 MG2_X_2956_Y_8870 237.7m
R_MG2_seg_649 MG2_X_2956_Y_8870 MG2_X_3494_Y_8870 237.7m
R_MG2_seg_650 MG2_X_3494_Y_8870 MG2_X_4032_Y_8870 237.7m
R_MG2_seg_651 MG2_X_4032_Y_8870 MG2_X_4569_Y_8870 237.7m
R_MG2_seg_652 MG2_X_4569_Y_8870 MG2_X_5107_Y_8870 237.7m
R_MG2_seg_653 MG2_X_5107_Y_8870 MG2_X_5644_Y_8870 237.7m
R_MG2_seg_654 MG2_X_5644_Y_8870 MG2_X_6182_Y_8870 237.7m
R_MG2_seg_655 MG2_X_6182_Y_8870 MG2_X_6720_Y_8870 237.7m
R_MG2_seg_656 MG2_X_6720_Y_8870 MG2_X_7257_Y_8870 237.7m
R_MG2_seg_657 MG2_X_7257_Y_8870 MG2_X_7795_Y_8870 237.7m
R_MG2_seg_658 MG2_X_7795_Y_8870 MG2_X_8332_Y_8870 237.7m
R_MG2_seg_659 MG2_X_8332_Y_8870 MG2_X_8870_Y_8870 237.7m
R_MG2_seg_660 MG2_X_8870_Y_8870 MG2_X_9408_Y_8870 237.7m
R_MG2_seg_661 MG2_X_9408_Y_8870 MG2_X_9945_Y_8870 237.7m
R_MG2_seg_662 MG2_X_9945_Y_8870 MG2_X_10000_Y_8870 24.05m
R_MG2_seg_663 MG2_X_0_Y_9139 MG2_X_537_Y_9139 237.7m
R_MG2_seg_664 MG2_X_537_Y_9139 MG2_X_1075_Y_9139 237.7m
R_MG2_seg_665 MG2_X_1075_Y_9139 MG2_X_1612_Y_9139 237.7m
R_MG2_seg_666 MG2_X_1612_Y_9139 MG2_X_2150_Y_9139 237.7m
R_MG2_seg_667 MG2_X_2150_Y_9139 MG2_X_2688_Y_9139 237.7m
R_MG2_seg_668 MG2_X_2688_Y_9139 MG2_X_3225_Y_9139 237.7m
R_MG2_seg_669 MG2_X_3225_Y_9139 MG2_X_3763_Y_9139 237.7m
R_MG2_seg_670 MG2_X_3763_Y_9139 MG2_X_4300_Y_9139 237.7m
R_MG2_seg_671 MG2_X_4300_Y_9139 MG2_X_4838_Y_9139 237.7m
R_MG2_seg_672 MG2_X_4838_Y_9139 MG2_X_5376_Y_9139 237.7m
R_MG2_seg_673 MG2_X_5376_Y_9139 MG2_X_5913_Y_9139 237.7m
R_MG2_seg_674 MG2_X_5913_Y_9139 MG2_X_6451_Y_9139 237.7m
R_MG2_seg_675 MG2_X_6451_Y_9139 MG2_X_6988_Y_9139 237.7m
R_MG2_seg_676 MG2_X_6988_Y_9139 MG2_X_7526_Y_9139 237.7m
R_MG2_seg_677 MG2_X_7526_Y_9139 MG2_X_8064_Y_9139 237.7m
R_MG2_seg_678 MG2_X_8064_Y_9139 MG2_X_8601_Y_9139 237.7m
R_MG2_seg_679 MG2_X_8601_Y_9139 MG2_X_9139_Y_9139 237.7m
R_MG2_seg_680 MG2_X_9139_Y_9139 MG2_X_9676_Y_9139 237.7m
R_MG2_seg_681 MG2_X_9676_Y_9139 MG2_X_10000_Y_9139 142.9m
R_MG2_seg_682 MG2_X_0_Y_9408 MG2_X_268_Y_9408 118.8m
R_MG2_seg_683 MG2_X_268_Y_9408 MG2_X_806_Y_9408 237.7m
R_MG2_seg_684 MG2_X_806_Y_9408 MG2_X_1344_Y_9408 237.7m
R_MG2_seg_685 MG2_X_1344_Y_9408 MG2_X_1881_Y_9408 237.7m
R_MG2_seg_686 MG2_X_1881_Y_9408 MG2_X_2419_Y_9408 237.7m
R_MG2_seg_687 MG2_X_2419_Y_9408 MG2_X_2956_Y_9408 237.7m
R_MG2_seg_688 MG2_X_2956_Y_9408 MG2_X_3494_Y_9408 237.7m
R_MG2_seg_689 MG2_X_3494_Y_9408 MG2_X_4032_Y_9408 237.7m
R_MG2_seg_690 MG2_X_4032_Y_9408 MG2_X_4569_Y_9408 237.7m
R_MG2_seg_691 MG2_X_4569_Y_9408 MG2_X_5107_Y_9408 237.7m
R_MG2_seg_692 MG2_X_5107_Y_9408 MG2_X_5644_Y_9408 237.7m
R_MG2_seg_693 MG2_X_5644_Y_9408 MG2_X_6182_Y_9408 237.7m
R_MG2_seg_694 MG2_X_6182_Y_9408 MG2_X_6720_Y_9408 237.7m
R_MG2_seg_695 MG2_X_6720_Y_9408 MG2_X_7257_Y_9408 237.7m
R_MG2_seg_696 MG2_X_7257_Y_9408 MG2_X_7795_Y_9408 237.7m
R_MG2_seg_697 MG2_X_7795_Y_9408 MG2_X_8332_Y_9408 237.7m
R_MG2_seg_698 MG2_X_8332_Y_9408 MG2_X_8870_Y_9408 237.7m
R_MG2_seg_699 MG2_X_8870_Y_9408 MG2_X_9408_Y_9408 237.7m
R_MG2_seg_700 MG2_X_9408_Y_9408 MG2_X_9945_Y_9408 237.7m
R_MG2_seg_701 MG2_X_9945_Y_9408 MG2_X_10000_Y_9408 24.05m
R_MG2_seg_702 MG2_X_0_Y_9676 MG2_X_537_Y_9676 237.7m
R_MG2_seg_703 MG2_X_537_Y_9676 MG2_X_1075_Y_9676 237.7m
R_MG2_seg_704 MG2_X_1075_Y_9676 MG2_X_1612_Y_9676 237.7m
R_MG2_seg_705 MG2_X_1612_Y_9676 MG2_X_2150_Y_9676 237.7m
R_MG2_seg_706 MG2_X_2150_Y_9676 MG2_X_2688_Y_9676 237.7m
R_MG2_seg_707 MG2_X_2688_Y_9676 MG2_X_3225_Y_9676 237.7m
R_MG2_seg_708 MG2_X_3225_Y_9676 MG2_X_3763_Y_9676 237.7m
R_MG2_seg_709 MG2_X_3763_Y_9676 MG2_X_4300_Y_9676 237.7m
R_MG2_seg_710 MG2_X_4300_Y_9676 MG2_X_4838_Y_9676 237.7m
R_MG2_seg_711 MG2_X_4838_Y_9676 MG2_X_5376_Y_9676 237.7m
R_MG2_seg_712 MG2_X_5376_Y_9676 MG2_X_5913_Y_9676 237.7m
R_MG2_seg_713 MG2_X_5913_Y_9676 MG2_X_6451_Y_9676 237.7m
R_MG2_seg_714 MG2_X_6451_Y_9676 MG2_X_6988_Y_9676 237.7m
R_MG2_seg_715 MG2_X_6988_Y_9676 MG2_X_7526_Y_9676 237.7m
R_MG2_seg_716 MG2_X_7526_Y_9676 MG2_X_8064_Y_9676 237.7m
R_MG2_seg_717 MG2_X_8064_Y_9676 MG2_X_8601_Y_9676 237.7m
R_MG2_seg_718 MG2_X_8601_Y_9676 MG2_X_9139_Y_9676 237.7m
R_MG2_seg_719 MG2_X_9139_Y_9676 MG2_X_9676_Y_9676 237.7m
R_MG2_seg_720 MG2_X_9676_Y_9676 MG2_X_10000_Y_9676 142.9m
R_MG2_seg_721 MG2_X_0_Y_9945 MG2_X_268_Y_9945 118.8m
R_MG2_seg_722 MG2_X_268_Y_9945 MG2_X_806_Y_9945 237.7m
R_MG2_seg_723 MG2_X_806_Y_9945 MG2_X_1344_Y_9945 237.7m
R_MG2_seg_724 MG2_X_1344_Y_9945 MG2_X_1881_Y_9945 237.7m
R_MG2_seg_725 MG2_X_1881_Y_9945 MG2_X_2419_Y_9945 237.7m
R_MG2_seg_726 MG2_X_2419_Y_9945 MG2_X_2956_Y_9945 237.7m
R_MG2_seg_727 MG2_X_2956_Y_9945 MG2_X_3494_Y_9945 237.7m
R_MG2_seg_728 MG2_X_3494_Y_9945 MG2_X_4032_Y_9945 237.7m
R_MG2_seg_729 MG2_X_4032_Y_9945 MG2_X_4569_Y_9945 237.7m
R_MG2_seg_730 MG2_X_4569_Y_9945 MG2_X_5107_Y_9945 237.7m
R_MG2_seg_731 MG2_X_5107_Y_9945 MG2_X_5644_Y_9945 237.7m
R_MG2_seg_732 MG2_X_5644_Y_9945 MG2_X_6182_Y_9945 237.7m
R_MG2_seg_733 MG2_X_6182_Y_9945 MG2_X_6720_Y_9945 237.7m
R_MG2_seg_734 MG2_X_6720_Y_9945 MG2_X_7257_Y_9945 237.7m
R_MG2_seg_735 MG2_X_7257_Y_9945 MG2_X_7795_Y_9945 237.7m
R_MG2_seg_736 MG2_X_7795_Y_9945 MG2_X_8332_Y_9945 237.7m
R_MG2_seg_737 MG2_X_8332_Y_9945 MG2_X_8870_Y_9945 237.7m
R_MG2_seg_738 MG2_X_8870_Y_9945 MG2_X_9408_Y_9945 237.7m
R_MG2_seg_739 MG2_X_9408_Y_9945 MG2_X_9945_Y_9945 237.7m
R_MG2_seg_740 MG2_X_9945_Y_9945 MG2_X_10000_Y_9945 24.05m
* Layer: MG1
R_MG1_seg_741 MG1_X_0_Y_0 MG1_X_0_Y_537 318.3m
R_MG1_seg_742 MG1_X_0_Y_537 MG1_X_0_Y_560 13.26m
R_MG1_seg_743 MG1_X_0_Y_560 MG1_X_0_Y_1075 305m
R_MG1_seg_744 MG1_X_0_Y_1075 MG1_X_0_Y_1120 26.53m
R_MG1_seg_745 MG1_X_0_Y_1120 MG1_X_0_Y_1612 291.8m
R_MG1_seg_746 MG1_X_0_Y_1612 MG1_X_0_Y_1680 39.79m
R_MG1_seg_747 MG1_X_0_Y_1680 MG1_X_0_Y_2150 278.5m
R_MG1_seg_748 MG1_X_0_Y_2150 MG1_X_0_Y_2240 53.05m
R_MG1_seg_749 MG1_X_0_Y_2240 MG1_X_0_Y_2688 265.3m
R_MG1_seg_750 MG1_X_0_Y_2688 MG1_X_0_Y_2800 66.31m
R_MG1_seg_751 MG1_X_0_Y_2800 MG1_X_0_Y_3225 252m
R_MG1_seg_752 MG1_X_0_Y_3225 MG1_X_0_Y_3360 79.58m
R_MG1_seg_753 MG1_X_0_Y_3360 MG1_X_0_Y_3763 238.7m
R_MG1_seg_754 MG1_X_0_Y_3763 MG1_X_0_Y_3920 92.84m
R_MG1_seg_755 MG1_X_0_Y_3920 MG1_X_0_Y_4300 225.5m
R_MG1_seg_756 MG1_X_0_Y_4300 MG1_X_0_Y_4480 106.1m
R_MG1_seg_757 MG1_X_0_Y_4480 MG1_X_0_Y_4838 212.2m
R_MG1_seg_758 MG1_X_0_Y_4838 MG1_X_0_Y_5040 119.4m
R_MG1_seg_759 MG1_X_0_Y_5040 MG1_X_0_Y_5376 198.9m
R_MG1_seg_760 MG1_X_0_Y_5376 MG1_X_0_Y_5600 132.6m
R_MG1_seg_761 MG1_X_0_Y_5600 MG1_X_0_Y_5913 185.7m
R_MG1_seg_762 MG1_X_0_Y_5913 MG1_X_0_Y_6160 145.9m
R_MG1_seg_763 MG1_X_0_Y_6160 MG1_X_0_Y_6451 172.4m
R_MG1_seg_764 MG1_X_0_Y_6451 MG1_X_0_Y_6720 159.2m
R_MG1_seg_765 MG1_X_0_Y_6720 MG1_X_0_Y_6988 159.2m
R_MG1_seg_766 MG1_X_0_Y_6988 MG1_X_0_Y_7280 172.4m
R_MG1_seg_767 MG1_X_0_Y_7280 MG1_X_0_Y_7526 145.9m
R_MG1_seg_768 MG1_X_0_Y_7526 MG1_X_0_Y_7840 185.7m
R_MG1_seg_769 MG1_X_0_Y_7840 MG1_X_0_Y_8064 132.6m
R_MG1_seg_770 MG1_X_0_Y_8064 MG1_X_0_Y_8400 198.9m
R_MG1_seg_771 MG1_X_0_Y_8400 MG1_X_0_Y_8601 119.4m
R_MG1_seg_772 MG1_X_0_Y_8601 MG1_X_0_Y_8960 212.2m
R_MG1_seg_773 MG1_X_0_Y_8960 MG1_X_0_Y_9139 106.1m
R_MG1_seg_774 MG1_X_0_Y_9139 MG1_X_0_Y_9520 225.5m
R_MG1_seg_775 MG1_X_0_Y_9520 MG1_X_0_Y_9676 92.84m
R_MG1_seg_776 MG1_X_0_Y_9676 MG1_X_0_Y_10000 191.4m
R_MG1_seg_777 MG1_X_268_Y_0 MG1_X_268_Y_268 159.2m
R_MG1_seg_778 MG1_X_268_Y_268 MG1_X_268_Y_560 172.4m
R_MG1_seg_779 MG1_X_268_Y_560 MG1_X_268_Y_806 145.9m
R_MG1_seg_780 MG1_X_268_Y_806 MG1_X_268_Y_1120 185.7m
R_MG1_seg_781 MG1_X_268_Y_1120 MG1_X_268_Y_1344 132.6m
R_MG1_seg_782 MG1_X_268_Y_1344 MG1_X_268_Y_1680 198.9m
R_MG1_seg_783 MG1_X_268_Y_1680 MG1_X_268_Y_1881 119.4m
R_MG1_seg_784 MG1_X_268_Y_1881 MG1_X_268_Y_2240 212.2m
R_MG1_seg_785 MG1_X_268_Y_2240 MG1_X_268_Y_2419 106.1m
R_MG1_seg_786 MG1_X_268_Y_2419 MG1_X_268_Y_2800 225.5m
R_MG1_seg_787 MG1_X_268_Y_2800 MG1_X_268_Y_2956 92.84m
R_MG1_seg_788 MG1_X_268_Y_2956 MG1_X_268_Y_3360 238.7m
R_MG1_seg_789 MG1_X_268_Y_3360 MG1_X_268_Y_3494 79.58m
R_MG1_seg_790 MG1_X_268_Y_3494 MG1_X_268_Y_3920 252m
R_MG1_seg_791 MG1_X_268_Y_3920 MG1_X_268_Y_4032 66.31m
R_MG1_seg_792 MG1_X_268_Y_4032 MG1_X_268_Y_4480 265.3m
R_MG1_seg_793 MG1_X_268_Y_4480 MG1_X_268_Y_4569 53.05m
R_MG1_seg_794 MG1_X_268_Y_4569 MG1_X_268_Y_5040 278.5m
R_MG1_seg_795 MG1_X_268_Y_5040 MG1_X_268_Y_5107 39.79m
R_MG1_seg_796 MG1_X_268_Y_5107 MG1_X_268_Y_5600 291.8m
R_MG1_seg_797 MG1_X_268_Y_5600 MG1_X_268_Y_5644 26.53m
R_MG1_seg_798 MG1_X_268_Y_5644 MG1_X_268_Y_6160 305m
R_MG1_seg_799 MG1_X_268_Y_6160 MG1_X_268_Y_6182 13.26m
R_MG1_seg_800 MG1_X_268_Y_6182 MG1_X_268_Y_6720 318.3m
R_MG1_seg_801 MG1_X_268_Y_6720 MG1_X_268_Y_7257 318.3m
R_MG1_seg_802 MG1_X_268_Y_7257 MG1_X_268_Y_7280 13.26m
R_MG1_seg_803 MG1_X_268_Y_7280 MG1_X_268_Y_7795 305m
R_MG1_seg_804 MG1_X_268_Y_7795 MG1_X_268_Y_7840 26.53m
R_MG1_seg_805 MG1_X_268_Y_7840 MG1_X_268_Y_8332 291.8m
R_MG1_seg_806 MG1_X_268_Y_8332 MG1_X_268_Y_8400 39.79m
R_MG1_seg_807 MG1_X_268_Y_8400 MG1_X_268_Y_8870 278.5m
R_MG1_seg_808 MG1_X_268_Y_8870 MG1_X_268_Y_8960 53.05m
R_MG1_seg_809 MG1_X_268_Y_8960 MG1_X_268_Y_9408 265.3m
R_MG1_seg_810 MG1_X_268_Y_9408 MG1_X_268_Y_9520 66.31m
R_MG1_seg_811 MG1_X_268_Y_9520 MG1_X_268_Y_9945 252m
R_MG1_seg_812 MG1_X_268_Y_9945 MG1_X_268_Y_10000 32.21m
R_MG1_seg_813 MG1_X_537_Y_0 MG1_X_537_Y_537 318.3m
R_MG1_seg_814 MG1_X_537_Y_537 MG1_X_537_Y_560 13.26m
R_MG1_seg_815 MG1_X_537_Y_560 MG1_X_537_Y_1075 305m
R_MG1_seg_816 MG1_X_537_Y_1075 MG1_X_537_Y_1120 26.53m
R_MG1_seg_817 MG1_X_537_Y_1120 MG1_X_537_Y_1612 291.8m
R_MG1_seg_818 MG1_X_537_Y_1612 MG1_X_537_Y_1680 39.79m
R_MG1_seg_819 MG1_X_537_Y_1680 MG1_X_537_Y_2150 278.5m
R_MG1_seg_820 MG1_X_537_Y_2150 MG1_X_537_Y_2240 53.05m
R_MG1_seg_821 MG1_X_537_Y_2240 MG1_X_537_Y_2688 265.3m
R_MG1_seg_822 MG1_X_537_Y_2688 MG1_X_537_Y_2800 66.31m
R_MG1_seg_823 MG1_X_537_Y_2800 MG1_X_537_Y_3225 252m
R_MG1_seg_824 MG1_X_537_Y_3225 MG1_X_537_Y_3360 79.58m
R_MG1_seg_825 MG1_X_537_Y_3360 MG1_X_537_Y_3763 238.7m
R_MG1_seg_826 MG1_X_537_Y_3763 MG1_X_537_Y_3920 92.84m
R_MG1_seg_827 MG1_X_537_Y_3920 MG1_X_537_Y_4300 225.5m
R_MG1_seg_828 MG1_X_537_Y_4300 MG1_X_537_Y_4480 106.1m
R_MG1_seg_829 MG1_X_537_Y_4480 MG1_X_537_Y_4838 212.2m
R_MG1_seg_830 MG1_X_537_Y_4838 MG1_X_537_Y_5040 119.4m
R_MG1_seg_831 MG1_X_537_Y_5040 MG1_X_537_Y_5376 198.9m
R_MG1_seg_832 MG1_X_537_Y_5376 MG1_X_537_Y_5600 132.6m
R_MG1_seg_833 MG1_X_537_Y_5600 MG1_X_537_Y_5913 185.7m
R_MG1_seg_834 MG1_X_537_Y_5913 MG1_X_537_Y_6160 145.9m
R_MG1_seg_835 MG1_X_537_Y_6160 MG1_X_537_Y_6451 172.4m
R_MG1_seg_836 MG1_X_537_Y_6451 MG1_X_537_Y_6720 159.2m
R_MG1_seg_837 MG1_X_537_Y_6720 MG1_X_537_Y_6988 159.2m
R_MG1_seg_838 MG1_X_537_Y_6988 MG1_X_537_Y_7280 172.4m
R_MG1_seg_839 MG1_X_537_Y_7280 MG1_X_537_Y_7526 145.9m
R_MG1_seg_840 MG1_X_537_Y_7526 MG1_X_537_Y_7840 185.7m
R_MG1_seg_841 MG1_X_537_Y_7840 MG1_X_537_Y_8064 132.6m
R_MG1_seg_842 MG1_X_537_Y_8064 MG1_X_537_Y_8400 198.9m
R_MG1_seg_843 MG1_X_537_Y_8400 MG1_X_537_Y_8601 119.4m
R_MG1_seg_844 MG1_X_537_Y_8601 MG1_X_537_Y_8960 212.2m
R_MG1_seg_845 MG1_X_537_Y_8960 MG1_X_537_Y_9139 106.1m
R_MG1_seg_846 MG1_X_537_Y_9139 MG1_X_537_Y_9520 225.5m
R_MG1_seg_847 MG1_X_537_Y_9520 MG1_X_537_Y_9676 92.84m
R_MG1_seg_848 MG1_X_537_Y_9676 MG1_X_537_Y_10000 191.4m
R_MG1_seg_849 MG1_X_806_Y_0 MG1_X_806_Y_268 159.2m
R_MG1_seg_850 MG1_X_806_Y_268 MG1_X_806_Y_560 172.4m
R_MG1_seg_851 MG1_X_806_Y_560 MG1_X_806_Y_806 145.9m
R_MG1_seg_852 MG1_X_806_Y_806 MG1_X_806_Y_1120 185.7m
R_MG1_seg_853 MG1_X_806_Y_1120 MG1_X_806_Y_1344 132.6m
R_MG1_seg_854 MG1_X_806_Y_1344 MG1_X_806_Y_1680 198.9m
R_MG1_seg_855 MG1_X_806_Y_1680 MG1_X_806_Y_1881 119.4m
R_MG1_seg_856 MG1_X_806_Y_1881 MG1_X_806_Y_2240 212.2m
R_MG1_seg_857 MG1_X_806_Y_2240 MG1_X_806_Y_2419 106.1m
R_MG1_seg_858 MG1_X_806_Y_2419 MG1_X_806_Y_2800 225.5m
R_MG1_seg_859 MG1_X_806_Y_2800 MG1_X_806_Y_2956 92.84m
R_MG1_seg_860 MG1_X_806_Y_2956 MG1_X_806_Y_3360 238.7m
R_MG1_seg_861 MG1_X_806_Y_3360 MG1_X_806_Y_3494 79.58m
R_MG1_seg_862 MG1_X_806_Y_3494 MG1_X_806_Y_3920 252m
R_MG1_seg_863 MG1_X_806_Y_3920 MG1_X_806_Y_4032 66.31m
R_MG1_seg_864 MG1_X_806_Y_4032 MG1_X_806_Y_4480 265.3m
R_MG1_seg_865 MG1_X_806_Y_4480 MG1_X_806_Y_4569 53.05m
R_MG1_seg_866 MG1_X_806_Y_4569 MG1_X_806_Y_5040 278.5m
R_MG1_seg_867 MG1_X_806_Y_5040 MG1_X_806_Y_5107 39.79m
R_MG1_seg_868 MG1_X_806_Y_5107 MG1_X_806_Y_5600 291.8m
R_MG1_seg_869 MG1_X_806_Y_5600 MG1_X_806_Y_5644 26.53m
R_MG1_seg_870 MG1_X_806_Y_5644 MG1_X_806_Y_6160 305m
R_MG1_seg_871 MG1_X_806_Y_6160 MG1_X_806_Y_6182 13.26m
R_MG1_seg_872 MG1_X_806_Y_6182 MG1_X_806_Y_6720 318.3m
R_MG1_seg_873 MG1_X_806_Y_6720 MG1_X_806_Y_7257 318.3m
R_MG1_seg_874 MG1_X_806_Y_7257 MG1_X_806_Y_7280 13.26m
R_MG1_seg_875 MG1_X_806_Y_7280 MG1_X_806_Y_7795 305m
R_MG1_seg_876 MG1_X_806_Y_7795 MG1_X_806_Y_7840 26.53m
R_MG1_seg_877 MG1_X_806_Y_7840 MG1_X_806_Y_8332 291.8m
R_MG1_seg_878 MG1_X_806_Y_8332 MG1_X_806_Y_8400 39.79m
R_MG1_seg_879 MG1_X_806_Y_8400 MG1_X_806_Y_8870 278.5m
R_MG1_seg_880 MG1_X_806_Y_8870 MG1_X_806_Y_8960 53.05m
R_MG1_seg_881 MG1_X_806_Y_8960 MG1_X_806_Y_9408 265.3m
R_MG1_seg_882 MG1_X_806_Y_9408 MG1_X_806_Y_9520 66.31m
R_MG1_seg_883 MG1_X_806_Y_9520 MG1_X_806_Y_9945 252m
R_MG1_seg_884 MG1_X_806_Y_9945 MG1_X_806_Y_10000 32.21m
R_MG1_seg_885 MG1_X_1075_Y_0 MG1_X_1075_Y_537 318.3m
R_MG1_seg_886 MG1_X_1075_Y_537 MG1_X_1075_Y_560 13.26m
R_MG1_seg_887 MG1_X_1075_Y_560 MG1_X_1075_Y_1075 305m
R_MG1_seg_888 MG1_X_1075_Y_1075 MG1_X_1075_Y_1120 26.53m
R_MG1_seg_889 MG1_X_1075_Y_1120 MG1_X_1075_Y_1612 291.8m
R_MG1_seg_890 MG1_X_1075_Y_1612 MG1_X_1075_Y_1680 39.79m
R_MG1_seg_891 MG1_X_1075_Y_1680 MG1_X_1075_Y_2150 278.5m
R_MG1_seg_892 MG1_X_1075_Y_2150 MG1_X_1075_Y_2240 53.05m
R_MG1_seg_893 MG1_X_1075_Y_2240 MG1_X_1075_Y_2688 265.3m
R_MG1_seg_894 MG1_X_1075_Y_2688 MG1_X_1075_Y_2800 66.31m
R_MG1_seg_895 MG1_X_1075_Y_2800 MG1_X_1075_Y_3225 252m
R_MG1_seg_896 MG1_X_1075_Y_3225 MG1_X_1075_Y_3360 79.58m
R_MG1_seg_897 MG1_X_1075_Y_3360 MG1_X_1075_Y_3763 238.7m
R_MG1_seg_898 MG1_X_1075_Y_3763 MG1_X_1075_Y_3920 92.84m
R_MG1_seg_899 MG1_X_1075_Y_3920 MG1_X_1075_Y_4300 225.5m
R_MG1_seg_900 MG1_X_1075_Y_4300 MG1_X_1075_Y_4480 106.1m
R_MG1_seg_901 MG1_X_1075_Y_4480 MG1_X_1075_Y_4838 212.2m
R_MG1_seg_902 MG1_X_1075_Y_4838 MG1_X_1075_Y_5040 119.4m
R_MG1_seg_903 MG1_X_1075_Y_5040 MG1_X_1075_Y_5376 198.9m
R_MG1_seg_904 MG1_X_1075_Y_5376 MG1_X_1075_Y_5600 132.6m
R_MG1_seg_905 MG1_X_1075_Y_5600 MG1_X_1075_Y_5913 185.7m
R_MG1_seg_906 MG1_X_1075_Y_5913 MG1_X_1075_Y_6160 145.9m
R_MG1_seg_907 MG1_X_1075_Y_6160 MG1_X_1075_Y_6451 172.4m
R_MG1_seg_908 MG1_X_1075_Y_6451 MG1_X_1075_Y_6720 159.2m
R_MG1_seg_909 MG1_X_1075_Y_6720 MG1_X_1075_Y_6988 159.2m
R_MG1_seg_910 MG1_X_1075_Y_6988 MG1_X_1075_Y_7280 172.4m
R_MG1_seg_911 MG1_X_1075_Y_7280 MG1_X_1075_Y_7526 145.9m
R_MG1_seg_912 MG1_X_1075_Y_7526 MG1_X_1075_Y_7840 185.7m
R_MG1_seg_913 MG1_X_1075_Y_7840 MG1_X_1075_Y_8064 132.6m
R_MG1_seg_914 MG1_X_1075_Y_8064 MG1_X_1075_Y_8400 198.9m
R_MG1_seg_915 MG1_X_1075_Y_8400 MG1_X_1075_Y_8601 119.4m
R_MG1_seg_916 MG1_X_1075_Y_8601 MG1_X_1075_Y_8960 212.2m
R_MG1_seg_917 MG1_X_1075_Y_8960 MG1_X_1075_Y_9139 106.1m
R_MG1_seg_918 MG1_X_1075_Y_9139 MG1_X_1075_Y_9520 225.5m
R_MG1_seg_919 MG1_X_1075_Y_9520 MG1_X_1075_Y_9676 92.84m
R_MG1_seg_920 MG1_X_1075_Y_9676 MG1_X_1075_Y_10000 191.4m
R_MG1_seg_921 MG1_X_1344_Y_0 MG1_X_1344_Y_268 159.2m
R_MG1_seg_922 MG1_X_1344_Y_268 MG1_X_1344_Y_560 172.4m
R_MG1_seg_923 MG1_X_1344_Y_560 MG1_X_1344_Y_806 145.9m
R_MG1_seg_924 MG1_X_1344_Y_806 MG1_X_1344_Y_1120 185.7m
R_MG1_seg_925 MG1_X_1344_Y_1120 MG1_X_1344_Y_1344 132.6m
R_MG1_seg_926 MG1_X_1344_Y_1344 MG1_X_1344_Y_1680 198.9m
R_MG1_seg_927 MG1_X_1344_Y_1680 MG1_X_1344_Y_1881 119.4m
R_MG1_seg_928 MG1_X_1344_Y_1881 MG1_X_1344_Y_2240 212.2m
R_MG1_seg_929 MG1_X_1344_Y_2240 MG1_X_1344_Y_2419 106.1m
R_MG1_seg_930 MG1_X_1344_Y_2419 MG1_X_1344_Y_2800 225.5m
R_MG1_seg_931 MG1_X_1344_Y_2800 MG1_X_1344_Y_2956 92.84m
R_MG1_seg_932 MG1_X_1344_Y_2956 MG1_X_1344_Y_3360 238.7m
R_MG1_seg_933 MG1_X_1344_Y_3360 MG1_X_1344_Y_3494 79.58m
R_MG1_seg_934 MG1_X_1344_Y_3494 MG1_X_1344_Y_3920 252m
R_MG1_seg_935 MG1_X_1344_Y_3920 MG1_X_1344_Y_4032 66.31m
R_MG1_seg_936 MG1_X_1344_Y_4032 MG1_X_1344_Y_4480 265.3m
R_MG1_seg_937 MG1_X_1344_Y_4480 MG1_X_1344_Y_4569 53.05m
R_MG1_seg_938 MG1_X_1344_Y_4569 MG1_X_1344_Y_5040 278.5m
R_MG1_seg_939 MG1_X_1344_Y_5040 MG1_X_1344_Y_5107 39.79m
R_MG1_seg_940 MG1_X_1344_Y_5107 MG1_X_1344_Y_5600 291.8m
R_MG1_seg_941 MG1_X_1344_Y_5600 MG1_X_1344_Y_5644 26.53m
R_MG1_seg_942 MG1_X_1344_Y_5644 MG1_X_1344_Y_6160 305m
R_MG1_seg_943 MG1_X_1344_Y_6160 MG1_X_1344_Y_6182 13.26m
R_MG1_seg_944 MG1_X_1344_Y_6182 MG1_X_1344_Y_6720 318.3m
R_MG1_seg_945 MG1_X_1344_Y_6720 MG1_X_1344_Y_7257 318.3m
R_MG1_seg_946 MG1_X_1344_Y_7257 MG1_X_1344_Y_7280 13.26m
R_MG1_seg_947 MG1_X_1344_Y_7280 MG1_X_1344_Y_7795 305m
R_MG1_seg_948 MG1_X_1344_Y_7795 MG1_X_1344_Y_7840 26.53m
R_MG1_seg_949 MG1_X_1344_Y_7840 MG1_X_1344_Y_8332 291.8m
R_MG1_seg_950 MG1_X_1344_Y_8332 MG1_X_1344_Y_8400 39.79m
R_MG1_seg_951 MG1_X_1344_Y_8400 MG1_X_1344_Y_8870 278.5m
R_MG1_seg_952 MG1_X_1344_Y_8870 MG1_X_1344_Y_8960 53.05m
R_MG1_seg_953 MG1_X_1344_Y_8960 MG1_X_1344_Y_9408 265.3m
R_MG1_seg_954 MG1_X_1344_Y_9408 MG1_X_1344_Y_9520 66.31m
R_MG1_seg_955 MG1_X_1344_Y_9520 MG1_X_1344_Y_9945 252m
R_MG1_seg_956 MG1_X_1344_Y_9945 MG1_X_1344_Y_10000 32.21m
R_MG1_seg_957 MG1_X_1612_Y_0 MG1_X_1612_Y_537 318.3m
R_MG1_seg_958 MG1_X_1612_Y_537 MG1_X_1612_Y_560 13.26m
R_MG1_seg_959 MG1_X_1612_Y_560 MG1_X_1612_Y_1075 305m
R_MG1_seg_960 MG1_X_1612_Y_1075 MG1_X_1612_Y_1120 26.53m
R_MG1_seg_961 MG1_X_1612_Y_1120 MG1_X_1612_Y_1612 291.8m
R_MG1_seg_962 MG1_X_1612_Y_1612 MG1_X_1612_Y_1680 39.79m
R_MG1_seg_963 MG1_X_1612_Y_1680 MG1_X_1612_Y_2150 278.5m
R_MG1_seg_964 MG1_X_1612_Y_2150 MG1_X_1612_Y_2240 53.05m
R_MG1_seg_965 MG1_X_1612_Y_2240 MG1_X_1612_Y_2688 265.3m
R_MG1_seg_966 MG1_X_1612_Y_2688 MG1_X_1612_Y_2800 66.31m
R_MG1_seg_967 MG1_X_1612_Y_2800 MG1_X_1612_Y_3225 252m
R_MG1_seg_968 MG1_X_1612_Y_3225 MG1_X_1612_Y_3360 79.58m
R_MG1_seg_969 MG1_X_1612_Y_3360 MG1_X_1612_Y_3763 238.7m
R_MG1_seg_970 MG1_X_1612_Y_3763 MG1_X_1612_Y_3920 92.84m
R_MG1_seg_971 MG1_X_1612_Y_3920 MG1_X_1612_Y_4300 225.5m
R_MG1_seg_972 MG1_X_1612_Y_4300 MG1_X_1612_Y_4480 106.1m
R_MG1_seg_973 MG1_X_1612_Y_4480 MG1_X_1612_Y_4838 212.2m
R_MG1_seg_974 MG1_X_1612_Y_4838 MG1_X_1612_Y_5040 119.4m
R_MG1_seg_975 MG1_X_1612_Y_5040 MG1_X_1612_Y_5376 198.9m
R_MG1_seg_976 MG1_X_1612_Y_5376 MG1_X_1612_Y_5600 132.6m
R_MG1_seg_977 MG1_X_1612_Y_5600 MG1_X_1612_Y_5913 185.7m
R_MG1_seg_978 MG1_X_1612_Y_5913 MG1_X_1612_Y_6160 145.9m
R_MG1_seg_979 MG1_X_1612_Y_6160 MG1_X_1612_Y_6451 172.4m
R_MG1_seg_980 MG1_X_1612_Y_6451 MG1_X_1612_Y_6720 159.2m
R_MG1_seg_981 MG1_X_1612_Y_6720 MG1_X_1612_Y_6988 159.2m
R_MG1_seg_982 MG1_X_1612_Y_6988 MG1_X_1612_Y_7280 172.4m
R_MG1_seg_983 MG1_X_1612_Y_7280 MG1_X_1612_Y_7526 145.9m
R_MG1_seg_984 MG1_X_1612_Y_7526 MG1_X_1612_Y_7840 185.7m
R_MG1_seg_985 MG1_X_1612_Y_7840 MG1_X_1612_Y_8064 132.6m
R_MG1_seg_986 MG1_X_1612_Y_8064 MG1_X_1612_Y_8400 198.9m
R_MG1_seg_987 MG1_X_1612_Y_8400 MG1_X_1612_Y_8601 119.4m
R_MG1_seg_988 MG1_X_1612_Y_8601 MG1_X_1612_Y_8960 212.2m
R_MG1_seg_989 MG1_X_1612_Y_8960 MG1_X_1612_Y_9139 106.1m
R_MG1_seg_990 MG1_X_1612_Y_9139 MG1_X_1612_Y_9520 225.5m
R_MG1_seg_991 MG1_X_1612_Y_9520 MG1_X_1612_Y_9676 92.84m
R_MG1_seg_992 MG1_X_1612_Y_9676 MG1_X_1612_Y_10000 191.4m
R_MG1_seg_993 MG1_X_1881_Y_0 MG1_X_1881_Y_268 159.2m
R_MG1_seg_994 MG1_X_1881_Y_268 MG1_X_1881_Y_560 172.4m
R_MG1_seg_995 MG1_X_1881_Y_560 MG1_X_1881_Y_806 145.9m
R_MG1_seg_996 MG1_X_1881_Y_806 MG1_X_1881_Y_1120 185.7m
R_MG1_seg_997 MG1_X_1881_Y_1120 MG1_X_1881_Y_1344 132.6m
R_MG1_seg_998 MG1_X_1881_Y_1344 MG1_X_1881_Y_1680 198.9m
R_MG1_seg_999 MG1_X_1881_Y_1680 MG1_X_1881_Y_1881 119.4m
R_MG1_seg_1000 MG1_X_1881_Y_1881 MG1_X_1881_Y_2240 212.2m
R_MG1_seg_1001 MG1_X_1881_Y_2240 MG1_X_1881_Y_2419 106.1m
R_MG1_seg_1002 MG1_X_1881_Y_2419 MG1_X_1881_Y_2800 225.5m
R_MG1_seg_1003 MG1_X_1881_Y_2800 MG1_X_1881_Y_2956 92.84m
R_MG1_seg_1004 MG1_X_1881_Y_2956 MG1_X_1881_Y_3360 238.7m
R_MG1_seg_1005 MG1_X_1881_Y_3360 MG1_X_1881_Y_3494 79.58m
R_MG1_seg_1006 MG1_X_1881_Y_3494 MG1_X_1881_Y_3920 252m
R_MG1_seg_1007 MG1_X_1881_Y_3920 MG1_X_1881_Y_4032 66.31m
R_MG1_seg_1008 MG1_X_1881_Y_4032 MG1_X_1881_Y_4480 265.3m
R_MG1_seg_1009 MG1_X_1881_Y_4480 MG1_X_1881_Y_4569 53.05m
R_MG1_seg_1010 MG1_X_1881_Y_4569 MG1_X_1881_Y_5040 278.5m
R_MG1_seg_1011 MG1_X_1881_Y_5040 MG1_X_1881_Y_5107 39.79m
R_MG1_seg_1012 MG1_X_1881_Y_5107 MG1_X_1881_Y_5600 291.8m
R_MG1_seg_1013 MG1_X_1881_Y_5600 MG1_X_1881_Y_5644 26.53m
R_MG1_seg_1014 MG1_X_1881_Y_5644 MG1_X_1881_Y_6160 305m
R_MG1_seg_1015 MG1_X_1881_Y_6160 MG1_X_1881_Y_6182 13.26m
R_MG1_seg_1016 MG1_X_1881_Y_6182 MG1_X_1881_Y_6720 318.3m
R_MG1_seg_1017 MG1_X_1881_Y_6720 MG1_X_1881_Y_7257 318.3m
R_MG1_seg_1018 MG1_X_1881_Y_7257 MG1_X_1881_Y_7280 13.26m
R_MG1_seg_1019 MG1_X_1881_Y_7280 MG1_X_1881_Y_7795 305m
R_MG1_seg_1020 MG1_X_1881_Y_7795 MG1_X_1881_Y_7840 26.53m
R_MG1_seg_1021 MG1_X_1881_Y_7840 MG1_X_1881_Y_8332 291.8m
R_MG1_seg_1022 MG1_X_1881_Y_8332 MG1_X_1881_Y_8400 39.79m
R_MG1_seg_1023 MG1_X_1881_Y_8400 MG1_X_1881_Y_8870 278.5m
R_MG1_seg_1024 MG1_X_1881_Y_8870 MG1_X_1881_Y_8960 53.05m
R_MG1_seg_1025 MG1_X_1881_Y_8960 MG1_X_1881_Y_9408 265.3m
R_MG1_seg_1026 MG1_X_1881_Y_9408 MG1_X_1881_Y_9520 66.31m
R_MG1_seg_1027 MG1_X_1881_Y_9520 MG1_X_1881_Y_9945 252m
R_MG1_seg_1028 MG1_X_1881_Y_9945 MG1_X_1881_Y_10000 32.21m
R_MG1_seg_1029 MG1_X_2150_Y_0 MG1_X_2150_Y_537 318.3m
R_MG1_seg_1030 MG1_X_2150_Y_537 MG1_X_2150_Y_560 13.26m
R_MG1_seg_1031 MG1_X_2150_Y_560 MG1_X_2150_Y_1075 305m
R_MG1_seg_1032 MG1_X_2150_Y_1075 MG1_X_2150_Y_1120 26.53m
R_MG1_seg_1033 MG1_X_2150_Y_1120 MG1_X_2150_Y_1612 291.8m
R_MG1_seg_1034 MG1_X_2150_Y_1612 MG1_X_2150_Y_1680 39.79m
R_MG1_seg_1035 MG1_X_2150_Y_1680 MG1_X_2150_Y_2150 278.5m
R_MG1_seg_1036 MG1_X_2150_Y_2150 MG1_X_2150_Y_2240 53.05m
R_MG1_seg_1037 MG1_X_2150_Y_2240 MG1_X_2150_Y_2688 265.3m
R_MG1_seg_1038 MG1_X_2150_Y_2688 MG1_X_2150_Y_2800 66.31m
R_MG1_seg_1039 MG1_X_2150_Y_2800 MG1_X_2150_Y_3225 252m
R_MG1_seg_1040 MG1_X_2150_Y_3225 MG1_X_2150_Y_3360 79.58m
R_MG1_seg_1041 MG1_X_2150_Y_3360 MG1_X_2150_Y_3763 238.7m
R_MG1_seg_1042 MG1_X_2150_Y_3763 MG1_X_2150_Y_3920 92.84m
R_MG1_seg_1043 MG1_X_2150_Y_3920 MG1_X_2150_Y_4300 225.5m
R_MG1_seg_1044 MG1_X_2150_Y_4300 MG1_X_2150_Y_4480 106.1m
R_MG1_seg_1045 MG1_X_2150_Y_4480 MG1_X_2150_Y_4838 212.2m
R_MG1_seg_1046 MG1_X_2150_Y_4838 MG1_X_2150_Y_5040 119.4m
R_MG1_seg_1047 MG1_X_2150_Y_5040 MG1_X_2150_Y_5376 198.9m
R_MG1_seg_1048 MG1_X_2150_Y_5376 MG1_X_2150_Y_5600 132.6m
R_MG1_seg_1049 MG1_X_2150_Y_5600 MG1_X_2150_Y_5913 185.7m
R_MG1_seg_1050 MG1_X_2150_Y_5913 MG1_X_2150_Y_6160 145.9m
R_MG1_seg_1051 MG1_X_2150_Y_6160 MG1_X_2150_Y_6451 172.4m
R_MG1_seg_1052 MG1_X_2150_Y_6451 MG1_X_2150_Y_6720 159.2m
R_MG1_seg_1053 MG1_X_2150_Y_6720 MG1_X_2150_Y_6988 159.2m
R_MG1_seg_1054 MG1_X_2150_Y_6988 MG1_X_2150_Y_7280 172.4m
R_MG1_seg_1055 MG1_X_2150_Y_7280 MG1_X_2150_Y_7526 145.9m
R_MG1_seg_1056 MG1_X_2150_Y_7526 MG1_X_2150_Y_7840 185.7m
R_MG1_seg_1057 MG1_X_2150_Y_7840 MG1_X_2150_Y_8064 132.6m
R_MG1_seg_1058 MG1_X_2150_Y_8064 MG1_X_2150_Y_8400 198.9m
R_MG1_seg_1059 MG1_X_2150_Y_8400 MG1_X_2150_Y_8601 119.4m
R_MG1_seg_1060 MG1_X_2150_Y_8601 MG1_X_2150_Y_8960 212.2m
R_MG1_seg_1061 MG1_X_2150_Y_8960 MG1_X_2150_Y_9139 106.1m
R_MG1_seg_1062 MG1_X_2150_Y_9139 MG1_X_2150_Y_9520 225.5m
R_MG1_seg_1063 MG1_X_2150_Y_9520 MG1_X_2150_Y_9676 92.84m
R_MG1_seg_1064 MG1_X_2150_Y_9676 MG1_X_2150_Y_10000 191.4m
R_MG1_seg_1065 MG1_X_2419_Y_0 MG1_X_2419_Y_268 159.2m
R_MG1_seg_1066 MG1_X_2419_Y_268 MG1_X_2419_Y_560 172.4m
R_MG1_seg_1067 MG1_X_2419_Y_560 MG1_X_2419_Y_806 145.9m
R_MG1_seg_1068 MG1_X_2419_Y_806 MG1_X_2419_Y_1120 185.7m
R_MG1_seg_1069 MG1_X_2419_Y_1120 MG1_X_2419_Y_1344 132.6m
R_MG1_seg_1070 MG1_X_2419_Y_1344 MG1_X_2419_Y_1680 198.9m
R_MG1_seg_1071 MG1_X_2419_Y_1680 MG1_X_2419_Y_1881 119.4m
R_MG1_seg_1072 MG1_X_2419_Y_1881 MG1_X_2419_Y_2240 212.2m
R_MG1_seg_1073 MG1_X_2419_Y_2240 MG1_X_2419_Y_2419 106.1m
R_MG1_seg_1074 MG1_X_2419_Y_2419 MG1_X_2419_Y_2800 225.5m
R_MG1_seg_1075 MG1_X_2419_Y_2800 MG1_X_2419_Y_2956 92.84m
R_MG1_seg_1076 MG1_X_2419_Y_2956 MG1_X_2419_Y_3360 238.7m
R_MG1_seg_1077 MG1_X_2419_Y_3360 MG1_X_2419_Y_3494 79.58m
R_MG1_seg_1078 MG1_X_2419_Y_3494 MG1_X_2419_Y_3920 252m
R_MG1_seg_1079 MG1_X_2419_Y_3920 MG1_X_2419_Y_4032 66.31m
R_MG1_seg_1080 MG1_X_2419_Y_4032 MG1_X_2419_Y_4480 265.3m
R_MG1_seg_1081 MG1_X_2419_Y_4480 MG1_X_2419_Y_4569 53.05m
R_MG1_seg_1082 MG1_X_2419_Y_4569 MG1_X_2419_Y_5040 278.5m
R_MG1_seg_1083 MG1_X_2419_Y_5040 MG1_X_2419_Y_5107 39.79m
R_MG1_seg_1084 MG1_X_2419_Y_5107 MG1_X_2419_Y_5600 291.8m
R_MG1_seg_1085 MG1_X_2419_Y_5600 MG1_X_2419_Y_5644 26.53m
R_MG1_seg_1086 MG1_X_2419_Y_5644 MG1_X_2419_Y_6160 305m
R_MG1_seg_1087 MG1_X_2419_Y_6160 MG1_X_2419_Y_6182 13.26m
R_MG1_seg_1088 MG1_X_2419_Y_6182 MG1_X_2419_Y_6720 318.3m
R_MG1_seg_1089 MG1_X_2419_Y_6720 MG1_X_2419_Y_7257 318.3m
R_MG1_seg_1090 MG1_X_2419_Y_7257 MG1_X_2419_Y_7280 13.26m
R_MG1_seg_1091 MG1_X_2419_Y_7280 MG1_X_2419_Y_7795 305m
R_MG1_seg_1092 MG1_X_2419_Y_7795 MG1_X_2419_Y_7840 26.53m
R_MG1_seg_1093 MG1_X_2419_Y_7840 MG1_X_2419_Y_8332 291.8m
R_MG1_seg_1094 MG1_X_2419_Y_8332 MG1_X_2419_Y_8400 39.79m
R_MG1_seg_1095 MG1_X_2419_Y_8400 MG1_X_2419_Y_8870 278.5m
R_MG1_seg_1096 MG1_X_2419_Y_8870 MG1_X_2419_Y_8960 53.05m
R_MG1_seg_1097 MG1_X_2419_Y_8960 MG1_X_2419_Y_9408 265.3m
R_MG1_seg_1098 MG1_X_2419_Y_9408 MG1_X_2419_Y_9520 66.31m
R_MG1_seg_1099 MG1_X_2419_Y_9520 MG1_X_2419_Y_9945 252m
R_MG1_seg_1100 MG1_X_2419_Y_9945 MG1_X_2419_Y_10000 32.21m
R_MG1_seg_1101 MG1_X_2688_Y_0 MG1_X_2688_Y_537 318.3m
R_MG1_seg_1102 MG1_X_2688_Y_537 MG1_X_2688_Y_560 13.26m
R_MG1_seg_1103 MG1_X_2688_Y_560 MG1_X_2688_Y_1075 305m
R_MG1_seg_1104 MG1_X_2688_Y_1075 MG1_X_2688_Y_1120 26.53m
R_MG1_seg_1105 MG1_X_2688_Y_1120 MG1_X_2688_Y_1612 291.8m
R_MG1_seg_1106 MG1_X_2688_Y_1612 MG1_X_2688_Y_1680 39.79m
R_MG1_seg_1107 MG1_X_2688_Y_1680 MG1_X_2688_Y_2150 278.5m
R_MG1_seg_1108 MG1_X_2688_Y_2150 MG1_X_2688_Y_2240 53.05m
R_MG1_seg_1109 MG1_X_2688_Y_2240 MG1_X_2688_Y_2688 265.3m
R_MG1_seg_1110 MG1_X_2688_Y_2688 MG1_X_2688_Y_2800 66.31m
R_MG1_seg_1111 MG1_X_2688_Y_2800 MG1_X_2688_Y_3225 252m
R_MG1_seg_1112 MG1_X_2688_Y_3225 MG1_X_2688_Y_3360 79.58m
R_MG1_seg_1113 MG1_X_2688_Y_3360 MG1_X_2688_Y_3763 238.7m
R_MG1_seg_1114 MG1_X_2688_Y_3763 MG1_X_2688_Y_3920 92.84m
R_MG1_seg_1115 MG1_X_2688_Y_3920 MG1_X_2688_Y_4300 225.5m
R_MG1_seg_1116 MG1_X_2688_Y_4300 MG1_X_2688_Y_4480 106.1m
R_MG1_seg_1117 MG1_X_2688_Y_4480 MG1_X_2688_Y_4838 212.2m
R_MG1_seg_1118 MG1_X_2688_Y_4838 MG1_X_2688_Y_5040 119.4m
R_MG1_seg_1119 MG1_X_2688_Y_5040 MG1_X_2688_Y_5376 198.9m
R_MG1_seg_1120 MG1_X_2688_Y_5376 MG1_X_2688_Y_5600 132.6m
R_MG1_seg_1121 MG1_X_2688_Y_5600 MG1_X_2688_Y_5913 185.7m
R_MG1_seg_1122 MG1_X_2688_Y_5913 MG1_X_2688_Y_6160 145.9m
R_MG1_seg_1123 MG1_X_2688_Y_6160 MG1_X_2688_Y_6451 172.4m
R_MG1_seg_1124 MG1_X_2688_Y_6451 MG1_X_2688_Y_6720 159.2m
R_MG1_seg_1125 MG1_X_2688_Y_6720 MG1_X_2688_Y_6988 159.2m
R_MG1_seg_1126 MG1_X_2688_Y_6988 MG1_X_2688_Y_7280 172.4m
R_MG1_seg_1127 MG1_X_2688_Y_7280 MG1_X_2688_Y_7526 145.9m
R_MG1_seg_1128 MG1_X_2688_Y_7526 MG1_X_2688_Y_7840 185.7m
R_MG1_seg_1129 MG1_X_2688_Y_7840 MG1_X_2688_Y_8064 132.6m
R_MG1_seg_1130 MG1_X_2688_Y_8064 MG1_X_2688_Y_8400 198.9m
R_MG1_seg_1131 MG1_X_2688_Y_8400 MG1_X_2688_Y_8601 119.4m
R_MG1_seg_1132 MG1_X_2688_Y_8601 MG1_X_2688_Y_8960 212.2m
R_MG1_seg_1133 MG1_X_2688_Y_8960 MG1_X_2688_Y_9139 106.1m
R_MG1_seg_1134 MG1_X_2688_Y_9139 MG1_X_2688_Y_9520 225.5m
R_MG1_seg_1135 MG1_X_2688_Y_9520 MG1_X_2688_Y_9676 92.84m
R_MG1_seg_1136 MG1_X_2688_Y_9676 MG1_X_2688_Y_10000 191.4m
R_MG1_seg_1137 MG1_X_2956_Y_0 MG1_X_2956_Y_268 159.2m
R_MG1_seg_1138 MG1_X_2956_Y_268 MG1_X_2956_Y_560 172.4m
R_MG1_seg_1139 MG1_X_2956_Y_560 MG1_X_2956_Y_806 145.9m
R_MG1_seg_1140 MG1_X_2956_Y_806 MG1_X_2956_Y_1120 185.7m
R_MG1_seg_1141 MG1_X_2956_Y_1120 MG1_X_2956_Y_1344 132.6m
R_MG1_seg_1142 MG1_X_2956_Y_1344 MG1_X_2956_Y_1680 198.9m
R_MG1_seg_1143 MG1_X_2956_Y_1680 MG1_X_2956_Y_1881 119.4m
R_MG1_seg_1144 MG1_X_2956_Y_1881 MG1_X_2956_Y_2240 212.2m
R_MG1_seg_1145 MG1_X_2956_Y_2240 MG1_X_2956_Y_2419 106.1m
R_MG1_seg_1146 MG1_X_2956_Y_2419 MG1_X_2956_Y_2800 225.5m
R_MG1_seg_1147 MG1_X_2956_Y_2800 MG1_X_2956_Y_2956 92.84m
R_MG1_seg_1148 MG1_X_2956_Y_2956 MG1_X_2956_Y_3360 238.7m
R_MG1_seg_1149 MG1_X_2956_Y_3360 MG1_X_2956_Y_3494 79.58m
R_MG1_seg_1150 MG1_X_2956_Y_3494 MG1_X_2956_Y_3920 252m
R_MG1_seg_1151 MG1_X_2956_Y_3920 MG1_X_2956_Y_4032 66.31m
R_MG1_seg_1152 MG1_X_2956_Y_4032 MG1_X_2956_Y_4480 265.3m
R_MG1_seg_1153 MG1_X_2956_Y_4480 MG1_X_2956_Y_4569 53.05m
R_MG1_seg_1154 MG1_X_2956_Y_4569 MG1_X_2956_Y_5040 278.5m
R_MG1_seg_1155 MG1_X_2956_Y_5040 MG1_X_2956_Y_5107 39.79m
R_MG1_seg_1156 MG1_X_2956_Y_5107 MG1_X_2956_Y_5600 291.8m
R_MG1_seg_1157 MG1_X_2956_Y_5600 MG1_X_2956_Y_5644 26.53m
R_MG1_seg_1158 MG1_X_2956_Y_5644 MG1_X_2956_Y_6160 305m
R_MG1_seg_1159 MG1_X_2956_Y_6160 MG1_X_2956_Y_6182 13.26m
R_MG1_seg_1160 MG1_X_2956_Y_6182 MG1_X_2956_Y_6720 318.3m
R_MG1_seg_1161 MG1_X_2956_Y_6720 MG1_X_2956_Y_7257 318.3m
R_MG1_seg_1162 MG1_X_2956_Y_7257 MG1_X_2956_Y_7280 13.26m
R_MG1_seg_1163 MG1_X_2956_Y_7280 MG1_X_2956_Y_7795 305m
R_MG1_seg_1164 MG1_X_2956_Y_7795 MG1_X_2956_Y_7840 26.53m
R_MG1_seg_1165 MG1_X_2956_Y_7840 MG1_X_2956_Y_8332 291.8m
R_MG1_seg_1166 MG1_X_2956_Y_8332 MG1_X_2956_Y_8400 39.79m
R_MG1_seg_1167 MG1_X_2956_Y_8400 MG1_X_2956_Y_8870 278.5m
R_MG1_seg_1168 MG1_X_2956_Y_8870 MG1_X_2956_Y_8960 53.05m
R_MG1_seg_1169 MG1_X_2956_Y_8960 MG1_X_2956_Y_9408 265.3m
R_MG1_seg_1170 MG1_X_2956_Y_9408 MG1_X_2956_Y_9520 66.31m
R_MG1_seg_1171 MG1_X_2956_Y_9520 MG1_X_2956_Y_9945 252m
R_MG1_seg_1172 MG1_X_2956_Y_9945 MG1_X_2956_Y_10000 32.21m
R_MG1_seg_1173 MG1_X_3225_Y_0 MG1_X_3225_Y_537 318.3m
R_MG1_seg_1174 MG1_X_3225_Y_537 MG1_X_3225_Y_560 13.26m
R_MG1_seg_1175 MG1_X_3225_Y_560 MG1_X_3225_Y_1075 305m
R_MG1_seg_1176 MG1_X_3225_Y_1075 MG1_X_3225_Y_1120 26.53m
R_MG1_seg_1177 MG1_X_3225_Y_1120 MG1_X_3225_Y_1612 291.8m
R_MG1_seg_1178 MG1_X_3225_Y_1612 MG1_X_3225_Y_1680 39.79m
R_MG1_seg_1179 MG1_X_3225_Y_1680 MG1_X_3225_Y_2150 278.5m
R_MG1_seg_1180 MG1_X_3225_Y_2150 MG1_X_3225_Y_2240 53.05m
R_MG1_seg_1181 MG1_X_3225_Y_2240 MG1_X_3225_Y_2688 265.3m
R_MG1_seg_1182 MG1_X_3225_Y_2688 MG1_X_3225_Y_2800 66.31m
R_MG1_seg_1183 MG1_X_3225_Y_2800 MG1_X_3225_Y_3225 252m
R_MG1_seg_1184 MG1_X_3225_Y_3225 MG1_X_3225_Y_3360 79.58m
R_MG1_seg_1185 MG1_X_3225_Y_3360 MG1_X_3225_Y_3763 238.7m
R_MG1_seg_1186 MG1_X_3225_Y_3763 MG1_X_3225_Y_3920 92.84m
R_MG1_seg_1187 MG1_X_3225_Y_3920 MG1_X_3225_Y_4300 225.5m
R_MG1_seg_1188 MG1_X_3225_Y_4300 MG1_X_3225_Y_4480 106.1m
R_MG1_seg_1189 MG1_X_3225_Y_4480 MG1_X_3225_Y_4838 212.2m
R_MG1_seg_1190 MG1_X_3225_Y_4838 MG1_X_3225_Y_5040 119.4m
R_MG1_seg_1191 MG1_X_3225_Y_5040 MG1_X_3225_Y_5376 198.9m
R_MG1_seg_1192 MG1_X_3225_Y_5376 MG1_X_3225_Y_5600 132.6m
R_MG1_seg_1193 MG1_X_3225_Y_5600 MG1_X_3225_Y_5913 185.7m
R_MG1_seg_1194 MG1_X_3225_Y_5913 MG1_X_3225_Y_6160 145.9m
R_MG1_seg_1195 MG1_X_3225_Y_6160 MG1_X_3225_Y_6451 172.4m
R_MG1_seg_1196 MG1_X_3225_Y_6451 MG1_X_3225_Y_6720 159.2m
R_MG1_seg_1197 MG1_X_3225_Y_6720 MG1_X_3225_Y_6988 159.2m
R_MG1_seg_1198 MG1_X_3225_Y_6988 MG1_X_3225_Y_7280 172.4m
R_MG1_seg_1199 MG1_X_3225_Y_7280 MG1_X_3225_Y_7526 145.9m
R_MG1_seg_1200 MG1_X_3225_Y_7526 MG1_X_3225_Y_7840 185.7m
R_MG1_seg_1201 MG1_X_3225_Y_7840 MG1_X_3225_Y_8064 132.6m
R_MG1_seg_1202 MG1_X_3225_Y_8064 MG1_X_3225_Y_8400 198.9m
R_MG1_seg_1203 MG1_X_3225_Y_8400 MG1_X_3225_Y_8601 119.4m
R_MG1_seg_1204 MG1_X_3225_Y_8601 MG1_X_3225_Y_8960 212.2m
R_MG1_seg_1205 MG1_X_3225_Y_8960 MG1_X_3225_Y_9139 106.1m
R_MG1_seg_1206 MG1_X_3225_Y_9139 MG1_X_3225_Y_9520 225.5m
R_MG1_seg_1207 MG1_X_3225_Y_9520 MG1_X_3225_Y_9676 92.84m
R_MG1_seg_1208 MG1_X_3225_Y_9676 MG1_X_3225_Y_10000 191.4m
R_MG1_seg_1209 MG1_X_3494_Y_0 MG1_X_3494_Y_268 159.2m
R_MG1_seg_1210 MG1_X_3494_Y_268 MG1_X_3494_Y_560 172.4m
R_MG1_seg_1211 MG1_X_3494_Y_560 MG1_X_3494_Y_806 145.9m
R_MG1_seg_1212 MG1_X_3494_Y_806 MG1_X_3494_Y_1120 185.7m
R_MG1_seg_1213 MG1_X_3494_Y_1120 MG1_X_3494_Y_1344 132.6m
R_MG1_seg_1214 MG1_X_3494_Y_1344 MG1_X_3494_Y_1680 198.9m
R_MG1_seg_1215 MG1_X_3494_Y_1680 MG1_X_3494_Y_1881 119.4m
R_MG1_seg_1216 MG1_X_3494_Y_1881 MG1_X_3494_Y_2240 212.2m
R_MG1_seg_1217 MG1_X_3494_Y_2240 MG1_X_3494_Y_2419 106.1m
R_MG1_seg_1218 MG1_X_3494_Y_2419 MG1_X_3494_Y_2800 225.5m
R_MG1_seg_1219 MG1_X_3494_Y_2800 MG1_X_3494_Y_2956 92.84m
R_MG1_seg_1220 MG1_X_3494_Y_2956 MG1_X_3494_Y_3360 238.7m
R_MG1_seg_1221 MG1_X_3494_Y_3360 MG1_X_3494_Y_3494 79.58m
R_MG1_seg_1222 MG1_X_3494_Y_3494 MG1_X_3494_Y_3920 252m
R_MG1_seg_1223 MG1_X_3494_Y_3920 MG1_X_3494_Y_4032 66.31m
R_MG1_seg_1224 MG1_X_3494_Y_4032 MG1_X_3494_Y_4480 265.3m
R_MG1_seg_1225 MG1_X_3494_Y_4480 MG1_X_3494_Y_4569 53.05m
R_MG1_seg_1226 MG1_X_3494_Y_4569 MG1_X_3494_Y_5040 278.5m
R_MG1_seg_1227 MG1_X_3494_Y_5040 MG1_X_3494_Y_5107 39.79m
R_MG1_seg_1228 MG1_X_3494_Y_5107 MG1_X_3494_Y_5600 291.8m
R_MG1_seg_1229 MG1_X_3494_Y_5600 MG1_X_3494_Y_5644 26.53m
R_MG1_seg_1230 MG1_X_3494_Y_5644 MG1_X_3494_Y_6160 305m
R_MG1_seg_1231 MG1_X_3494_Y_6160 MG1_X_3494_Y_6182 13.26m
R_MG1_seg_1232 MG1_X_3494_Y_6182 MG1_X_3494_Y_6720 318.3m
R_MG1_seg_1233 MG1_X_3494_Y_6720 MG1_X_3494_Y_7257 318.3m
R_MG1_seg_1234 MG1_X_3494_Y_7257 MG1_X_3494_Y_7280 13.26m
R_MG1_seg_1235 MG1_X_3494_Y_7280 MG1_X_3494_Y_7795 305m
R_MG1_seg_1236 MG1_X_3494_Y_7795 MG1_X_3494_Y_7840 26.53m
R_MG1_seg_1237 MG1_X_3494_Y_7840 MG1_X_3494_Y_8332 291.8m
R_MG1_seg_1238 MG1_X_3494_Y_8332 MG1_X_3494_Y_8400 39.79m
R_MG1_seg_1239 MG1_X_3494_Y_8400 MG1_X_3494_Y_8870 278.5m
R_MG1_seg_1240 MG1_X_3494_Y_8870 MG1_X_3494_Y_8960 53.05m
R_MG1_seg_1241 MG1_X_3494_Y_8960 MG1_X_3494_Y_9408 265.3m
R_MG1_seg_1242 MG1_X_3494_Y_9408 MG1_X_3494_Y_9520 66.31m
R_MG1_seg_1243 MG1_X_3494_Y_9520 MG1_X_3494_Y_9945 252m
R_MG1_seg_1244 MG1_X_3494_Y_9945 MG1_X_3494_Y_10000 32.21m
R_MG1_seg_1245 MG1_X_3763_Y_0 MG1_X_3763_Y_537 318.3m
R_MG1_seg_1246 MG1_X_3763_Y_537 MG1_X_3763_Y_560 13.26m
R_MG1_seg_1247 MG1_X_3763_Y_560 MG1_X_3763_Y_1075 305m
R_MG1_seg_1248 MG1_X_3763_Y_1075 MG1_X_3763_Y_1120 26.53m
R_MG1_seg_1249 MG1_X_3763_Y_1120 MG1_X_3763_Y_1612 291.8m
R_MG1_seg_1250 MG1_X_3763_Y_1612 MG1_X_3763_Y_1680 39.79m
R_MG1_seg_1251 MG1_X_3763_Y_1680 MG1_X_3763_Y_2150 278.5m
R_MG1_seg_1252 MG1_X_3763_Y_2150 MG1_X_3763_Y_2240 53.05m
R_MG1_seg_1253 MG1_X_3763_Y_2240 MG1_X_3763_Y_2688 265.3m
R_MG1_seg_1254 MG1_X_3763_Y_2688 MG1_X_3763_Y_2800 66.31m
R_MG1_seg_1255 MG1_X_3763_Y_2800 MG1_X_3763_Y_3225 252m
R_MG1_seg_1256 MG1_X_3763_Y_3225 MG1_X_3763_Y_3360 79.58m
R_MG1_seg_1257 MG1_X_3763_Y_3360 MG1_X_3763_Y_3763 238.7m
R_MG1_seg_1258 MG1_X_3763_Y_3763 MG1_X_3763_Y_3920 92.84m
R_MG1_seg_1259 MG1_X_3763_Y_3920 MG1_X_3763_Y_4300 225.5m
R_MG1_seg_1260 MG1_X_3763_Y_4300 MG1_X_3763_Y_4480 106.1m
R_MG1_seg_1261 MG1_X_3763_Y_4480 MG1_X_3763_Y_4838 212.2m
R_MG1_seg_1262 MG1_X_3763_Y_4838 MG1_X_3763_Y_5040 119.4m
R_MG1_seg_1263 MG1_X_3763_Y_5040 MG1_X_3763_Y_5376 198.9m
R_MG1_seg_1264 MG1_X_3763_Y_5376 MG1_X_3763_Y_5600 132.6m
R_MG1_seg_1265 MG1_X_3763_Y_5600 MG1_X_3763_Y_5913 185.7m
R_MG1_seg_1266 MG1_X_3763_Y_5913 MG1_X_3763_Y_6160 145.9m
R_MG1_seg_1267 MG1_X_3763_Y_6160 MG1_X_3763_Y_6451 172.4m
R_MG1_seg_1268 MG1_X_3763_Y_6451 MG1_X_3763_Y_6720 159.2m
R_MG1_seg_1269 MG1_X_3763_Y_6720 MG1_X_3763_Y_6988 159.2m
R_MG1_seg_1270 MG1_X_3763_Y_6988 MG1_X_3763_Y_7280 172.4m
R_MG1_seg_1271 MG1_X_3763_Y_7280 MG1_X_3763_Y_7526 145.9m
R_MG1_seg_1272 MG1_X_3763_Y_7526 MG1_X_3763_Y_7840 185.7m
R_MG1_seg_1273 MG1_X_3763_Y_7840 MG1_X_3763_Y_8064 132.6m
R_MG1_seg_1274 MG1_X_3763_Y_8064 MG1_X_3763_Y_8400 198.9m
R_MG1_seg_1275 MG1_X_3763_Y_8400 MG1_X_3763_Y_8601 119.4m
R_MG1_seg_1276 MG1_X_3763_Y_8601 MG1_X_3763_Y_8960 212.2m
R_MG1_seg_1277 MG1_X_3763_Y_8960 MG1_X_3763_Y_9139 106.1m
R_MG1_seg_1278 MG1_X_3763_Y_9139 MG1_X_3763_Y_9520 225.5m
R_MG1_seg_1279 MG1_X_3763_Y_9520 MG1_X_3763_Y_9676 92.84m
R_MG1_seg_1280 MG1_X_3763_Y_9676 MG1_X_3763_Y_10000 191.4m
R_MG1_seg_1281 MG1_X_4032_Y_0 MG1_X_4032_Y_268 159.2m
R_MG1_seg_1282 MG1_X_4032_Y_268 MG1_X_4032_Y_560 172.4m
R_MG1_seg_1283 MG1_X_4032_Y_560 MG1_X_4032_Y_806 145.9m
R_MG1_seg_1284 MG1_X_4032_Y_806 MG1_X_4032_Y_1120 185.7m
R_MG1_seg_1285 MG1_X_4032_Y_1120 MG1_X_4032_Y_1344 132.6m
R_MG1_seg_1286 MG1_X_4032_Y_1344 MG1_X_4032_Y_1680 198.9m
R_MG1_seg_1287 MG1_X_4032_Y_1680 MG1_X_4032_Y_1881 119.4m
R_MG1_seg_1288 MG1_X_4032_Y_1881 MG1_X_4032_Y_2240 212.2m
R_MG1_seg_1289 MG1_X_4032_Y_2240 MG1_X_4032_Y_2419 106.1m
R_MG1_seg_1290 MG1_X_4032_Y_2419 MG1_X_4032_Y_2800 225.5m
R_MG1_seg_1291 MG1_X_4032_Y_2800 MG1_X_4032_Y_2956 92.84m
R_MG1_seg_1292 MG1_X_4032_Y_2956 MG1_X_4032_Y_3360 238.7m
R_MG1_seg_1293 MG1_X_4032_Y_3360 MG1_X_4032_Y_3494 79.58m
R_MG1_seg_1294 MG1_X_4032_Y_3494 MG1_X_4032_Y_3920 252m
R_MG1_seg_1295 MG1_X_4032_Y_3920 MG1_X_4032_Y_4032 66.31m
R_MG1_seg_1296 MG1_X_4032_Y_4032 MG1_X_4032_Y_4480 265.3m
R_MG1_seg_1297 MG1_X_4032_Y_4480 MG1_X_4032_Y_4569 53.05m
R_MG1_seg_1298 MG1_X_4032_Y_4569 MG1_X_4032_Y_5040 278.5m
R_MG1_seg_1299 MG1_X_4032_Y_5040 MG1_X_4032_Y_5107 39.79m
R_MG1_seg_1300 MG1_X_4032_Y_5107 MG1_X_4032_Y_5600 291.8m
R_MG1_seg_1301 MG1_X_4032_Y_5600 MG1_X_4032_Y_5644 26.53m
R_MG1_seg_1302 MG1_X_4032_Y_5644 MG1_X_4032_Y_6160 305m
R_MG1_seg_1303 MG1_X_4032_Y_6160 MG1_X_4032_Y_6182 13.26m
R_MG1_seg_1304 MG1_X_4032_Y_6182 MG1_X_4032_Y_6720 318.3m
R_MG1_seg_1305 MG1_X_4032_Y_6720 MG1_X_4032_Y_7257 318.3m
R_MG1_seg_1306 MG1_X_4032_Y_7257 MG1_X_4032_Y_7280 13.26m
R_MG1_seg_1307 MG1_X_4032_Y_7280 MG1_X_4032_Y_7795 305m
R_MG1_seg_1308 MG1_X_4032_Y_7795 MG1_X_4032_Y_7840 26.53m
R_MG1_seg_1309 MG1_X_4032_Y_7840 MG1_X_4032_Y_8332 291.8m
R_MG1_seg_1310 MG1_X_4032_Y_8332 MG1_X_4032_Y_8400 39.79m
R_MG1_seg_1311 MG1_X_4032_Y_8400 MG1_X_4032_Y_8870 278.5m
R_MG1_seg_1312 MG1_X_4032_Y_8870 MG1_X_4032_Y_8960 53.05m
R_MG1_seg_1313 MG1_X_4032_Y_8960 MG1_X_4032_Y_9408 265.3m
R_MG1_seg_1314 MG1_X_4032_Y_9408 MG1_X_4032_Y_9520 66.31m
R_MG1_seg_1315 MG1_X_4032_Y_9520 MG1_X_4032_Y_9945 252m
R_MG1_seg_1316 MG1_X_4032_Y_9945 MG1_X_4032_Y_10000 32.21m
R_MG1_seg_1317 MG1_X_4300_Y_0 MG1_X_4300_Y_537 318.3m
R_MG1_seg_1318 MG1_X_4300_Y_537 MG1_X_4300_Y_560 13.26m
R_MG1_seg_1319 MG1_X_4300_Y_560 MG1_X_4300_Y_1075 305m
R_MG1_seg_1320 MG1_X_4300_Y_1075 MG1_X_4300_Y_1120 26.53m
R_MG1_seg_1321 MG1_X_4300_Y_1120 MG1_X_4300_Y_1612 291.8m
R_MG1_seg_1322 MG1_X_4300_Y_1612 MG1_X_4300_Y_1680 39.79m
R_MG1_seg_1323 MG1_X_4300_Y_1680 MG1_X_4300_Y_2150 278.5m
R_MG1_seg_1324 MG1_X_4300_Y_2150 MG1_X_4300_Y_2240 53.05m
R_MG1_seg_1325 MG1_X_4300_Y_2240 MG1_X_4300_Y_2688 265.3m
R_MG1_seg_1326 MG1_X_4300_Y_2688 MG1_X_4300_Y_2800 66.31m
R_MG1_seg_1327 MG1_X_4300_Y_2800 MG1_X_4300_Y_3225 252m
R_MG1_seg_1328 MG1_X_4300_Y_3225 MG1_X_4300_Y_3360 79.58m
R_MG1_seg_1329 MG1_X_4300_Y_3360 MG1_X_4300_Y_3763 238.7m
R_MG1_seg_1330 MG1_X_4300_Y_3763 MG1_X_4300_Y_3920 92.84m
R_MG1_seg_1331 MG1_X_4300_Y_3920 MG1_X_4300_Y_4300 225.5m
R_MG1_seg_1332 MG1_X_4300_Y_4300 MG1_X_4300_Y_4480 106.1m
R_MG1_seg_1333 MG1_X_4300_Y_4480 MG1_X_4300_Y_4838 212.2m
R_MG1_seg_1334 MG1_X_4300_Y_4838 MG1_X_4300_Y_5040 119.4m
R_MG1_seg_1335 MG1_X_4300_Y_5040 MG1_X_4300_Y_5376 198.9m
R_MG1_seg_1336 MG1_X_4300_Y_5376 MG1_X_4300_Y_5600 132.6m
R_MG1_seg_1337 MG1_X_4300_Y_5600 MG1_X_4300_Y_5913 185.7m
R_MG1_seg_1338 MG1_X_4300_Y_5913 MG1_X_4300_Y_6160 145.9m
R_MG1_seg_1339 MG1_X_4300_Y_6160 MG1_X_4300_Y_6451 172.4m
R_MG1_seg_1340 MG1_X_4300_Y_6451 MG1_X_4300_Y_6720 159.2m
R_MG1_seg_1341 MG1_X_4300_Y_6720 MG1_X_4300_Y_6988 159.2m
R_MG1_seg_1342 MG1_X_4300_Y_6988 MG1_X_4300_Y_7280 172.4m
R_MG1_seg_1343 MG1_X_4300_Y_7280 MG1_X_4300_Y_7526 145.9m
R_MG1_seg_1344 MG1_X_4300_Y_7526 MG1_X_4300_Y_7840 185.7m
R_MG1_seg_1345 MG1_X_4300_Y_7840 MG1_X_4300_Y_8064 132.6m
R_MG1_seg_1346 MG1_X_4300_Y_8064 MG1_X_4300_Y_8400 198.9m
R_MG1_seg_1347 MG1_X_4300_Y_8400 MG1_X_4300_Y_8601 119.4m
R_MG1_seg_1348 MG1_X_4300_Y_8601 MG1_X_4300_Y_8960 212.2m
R_MG1_seg_1349 MG1_X_4300_Y_8960 MG1_X_4300_Y_9139 106.1m
R_MG1_seg_1350 MG1_X_4300_Y_9139 MG1_X_4300_Y_9520 225.5m
R_MG1_seg_1351 MG1_X_4300_Y_9520 MG1_X_4300_Y_9676 92.84m
R_MG1_seg_1352 MG1_X_4300_Y_9676 MG1_X_4300_Y_10000 191.4m
R_MG1_seg_1353 MG1_X_4569_Y_0 MG1_X_4569_Y_268 159.2m
R_MG1_seg_1354 MG1_X_4569_Y_268 MG1_X_4569_Y_560 172.4m
R_MG1_seg_1355 MG1_X_4569_Y_560 MG1_X_4569_Y_806 145.9m
R_MG1_seg_1356 MG1_X_4569_Y_806 MG1_X_4569_Y_1120 185.7m
R_MG1_seg_1357 MG1_X_4569_Y_1120 MG1_X_4569_Y_1344 132.6m
R_MG1_seg_1358 MG1_X_4569_Y_1344 MG1_X_4569_Y_1680 198.9m
R_MG1_seg_1359 MG1_X_4569_Y_1680 MG1_X_4569_Y_1881 119.4m
R_MG1_seg_1360 MG1_X_4569_Y_1881 MG1_X_4569_Y_2240 212.2m
R_MG1_seg_1361 MG1_X_4569_Y_2240 MG1_X_4569_Y_2419 106.1m
R_MG1_seg_1362 MG1_X_4569_Y_2419 MG1_X_4569_Y_2800 225.5m
R_MG1_seg_1363 MG1_X_4569_Y_2800 MG1_X_4569_Y_2956 92.84m
R_MG1_seg_1364 MG1_X_4569_Y_2956 MG1_X_4569_Y_3360 238.7m
R_MG1_seg_1365 MG1_X_4569_Y_3360 MG1_X_4569_Y_3494 79.58m
R_MG1_seg_1366 MG1_X_4569_Y_3494 MG1_X_4569_Y_3920 252m
R_MG1_seg_1367 MG1_X_4569_Y_3920 MG1_X_4569_Y_4032 66.31m
R_MG1_seg_1368 MG1_X_4569_Y_4032 MG1_X_4569_Y_4480 265.3m
R_MG1_seg_1369 MG1_X_4569_Y_4480 MG1_X_4569_Y_4569 53.05m
R_MG1_seg_1370 MG1_X_4569_Y_4569 MG1_X_4569_Y_5040 278.5m
R_MG1_seg_1371 MG1_X_4569_Y_5040 MG1_X_4569_Y_5107 39.79m
R_MG1_seg_1372 MG1_X_4569_Y_5107 MG1_X_4569_Y_5600 291.8m
R_MG1_seg_1373 MG1_X_4569_Y_5600 MG1_X_4569_Y_5644 26.53m
R_MG1_seg_1374 MG1_X_4569_Y_5644 MG1_X_4569_Y_6160 305m
R_MG1_seg_1375 MG1_X_4569_Y_6160 MG1_X_4569_Y_6182 13.26m
R_MG1_seg_1376 MG1_X_4569_Y_6182 MG1_X_4569_Y_6720 318.3m
R_MG1_seg_1377 MG1_X_4569_Y_6720 MG1_X_4569_Y_7257 318.3m
R_MG1_seg_1378 MG1_X_4569_Y_7257 MG1_X_4569_Y_7280 13.26m
R_MG1_seg_1379 MG1_X_4569_Y_7280 MG1_X_4569_Y_7795 305m
R_MG1_seg_1380 MG1_X_4569_Y_7795 MG1_X_4569_Y_7840 26.53m
R_MG1_seg_1381 MG1_X_4569_Y_7840 MG1_X_4569_Y_8332 291.8m
R_MG1_seg_1382 MG1_X_4569_Y_8332 MG1_X_4569_Y_8400 39.79m
R_MG1_seg_1383 MG1_X_4569_Y_8400 MG1_X_4569_Y_8870 278.5m
R_MG1_seg_1384 MG1_X_4569_Y_8870 MG1_X_4569_Y_8960 53.05m
R_MG1_seg_1385 MG1_X_4569_Y_8960 MG1_X_4569_Y_9408 265.3m
R_MG1_seg_1386 MG1_X_4569_Y_9408 MG1_X_4569_Y_9520 66.31m
R_MG1_seg_1387 MG1_X_4569_Y_9520 MG1_X_4569_Y_9945 252m
R_MG1_seg_1388 MG1_X_4569_Y_9945 MG1_X_4569_Y_10000 32.21m
R_MG1_seg_1389 MG1_X_4838_Y_0 MG1_X_4838_Y_537 318.3m
R_MG1_seg_1390 MG1_X_4838_Y_537 MG1_X_4838_Y_560 13.26m
R_MG1_seg_1391 MG1_X_4838_Y_560 MG1_X_4838_Y_1075 305m
R_MG1_seg_1392 MG1_X_4838_Y_1075 MG1_X_4838_Y_1120 26.53m
R_MG1_seg_1393 MG1_X_4838_Y_1120 MG1_X_4838_Y_1612 291.8m
R_MG1_seg_1394 MG1_X_4838_Y_1612 MG1_X_4838_Y_1680 39.79m
R_MG1_seg_1395 MG1_X_4838_Y_1680 MG1_X_4838_Y_2150 278.5m
R_MG1_seg_1396 MG1_X_4838_Y_2150 MG1_X_4838_Y_2240 53.05m
R_MG1_seg_1397 MG1_X_4838_Y_2240 MG1_X_4838_Y_2688 265.3m
R_MG1_seg_1398 MG1_X_4838_Y_2688 MG1_X_4838_Y_2800 66.31m
R_MG1_seg_1399 MG1_X_4838_Y_2800 MG1_X_4838_Y_3225 252m
R_MG1_seg_1400 MG1_X_4838_Y_3225 MG1_X_4838_Y_3360 79.58m
R_MG1_seg_1401 MG1_X_4838_Y_3360 MG1_X_4838_Y_3763 238.7m
R_MG1_seg_1402 MG1_X_4838_Y_3763 MG1_X_4838_Y_3920 92.84m
R_MG1_seg_1403 MG1_X_4838_Y_3920 MG1_X_4838_Y_4300 225.5m
R_MG1_seg_1404 MG1_X_4838_Y_4300 MG1_X_4838_Y_4480 106.1m
R_MG1_seg_1405 MG1_X_4838_Y_4480 MG1_X_4838_Y_4838 212.2m
R_MG1_seg_1406 MG1_X_4838_Y_4838 MG1_X_4838_Y_5040 119.4m
R_MG1_seg_1407 MG1_X_4838_Y_5040 MG1_X_4838_Y_5376 198.9m
R_MG1_seg_1408 MG1_X_4838_Y_5376 MG1_X_4838_Y_5600 132.6m
R_MG1_seg_1409 MG1_X_4838_Y_5600 MG1_X_4838_Y_5913 185.7m
R_MG1_seg_1410 MG1_X_4838_Y_5913 MG1_X_4838_Y_6160 145.9m
R_MG1_seg_1411 MG1_X_4838_Y_6160 MG1_X_4838_Y_6451 172.4m
R_MG1_seg_1412 MG1_X_4838_Y_6451 MG1_X_4838_Y_6720 159.2m
R_MG1_seg_1413 MG1_X_4838_Y_6720 MG1_X_4838_Y_6988 159.2m
R_MG1_seg_1414 MG1_X_4838_Y_6988 MG1_X_4838_Y_7280 172.4m
R_MG1_seg_1415 MG1_X_4838_Y_7280 MG1_X_4838_Y_7526 145.9m
R_MG1_seg_1416 MG1_X_4838_Y_7526 MG1_X_4838_Y_7840 185.7m
R_MG1_seg_1417 MG1_X_4838_Y_7840 MG1_X_4838_Y_8064 132.6m
R_MG1_seg_1418 MG1_X_4838_Y_8064 MG1_X_4838_Y_8400 198.9m
R_MG1_seg_1419 MG1_X_4838_Y_8400 MG1_X_4838_Y_8601 119.4m
R_MG1_seg_1420 MG1_X_4838_Y_8601 MG1_X_4838_Y_8960 212.2m
R_MG1_seg_1421 MG1_X_4838_Y_8960 MG1_X_4838_Y_9139 106.1m
R_MG1_seg_1422 MG1_X_4838_Y_9139 MG1_X_4838_Y_9520 225.5m
R_MG1_seg_1423 MG1_X_4838_Y_9520 MG1_X_4838_Y_9676 92.84m
R_MG1_seg_1424 MG1_X_4838_Y_9676 MG1_X_4838_Y_10000 191.4m
R_MG1_seg_1425 MG1_X_5107_Y_0 MG1_X_5107_Y_268 159.2m
R_MG1_seg_1426 MG1_X_5107_Y_268 MG1_X_5107_Y_560 172.4m
R_MG1_seg_1427 MG1_X_5107_Y_560 MG1_X_5107_Y_806 145.9m
R_MG1_seg_1428 MG1_X_5107_Y_806 MG1_X_5107_Y_1120 185.7m
R_MG1_seg_1429 MG1_X_5107_Y_1120 MG1_X_5107_Y_1344 132.6m
R_MG1_seg_1430 MG1_X_5107_Y_1344 MG1_X_5107_Y_1680 198.9m
R_MG1_seg_1431 MG1_X_5107_Y_1680 MG1_X_5107_Y_1881 119.4m
R_MG1_seg_1432 MG1_X_5107_Y_1881 MG1_X_5107_Y_2240 212.2m
R_MG1_seg_1433 MG1_X_5107_Y_2240 MG1_X_5107_Y_2419 106.1m
R_MG1_seg_1434 MG1_X_5107_Y_2419 MG1_X_5107_Y_2800 225.5m
R_MG1_seg_1435 MG1_X_5107_Y_2800 MG1_X_5107_Y_2956 92.84m
R_MG1_seg_1436 MG1_X_5107_Y_2956 MG1_X_5107_Y_3360 238.7m
R_MG1_seg_1437 MG1_X_5107_Y_3360 MG1_X_5107_Y_3494 79.58m
R_MG1_seg_1438 MG1_X_5107_Y_3494 MG1_X_5107_Y_3920 252m
R_MG1_seg_1439 MG1_X_5107_Y_3920 MG1_X_5107_Y_4032 66.31m
R_MG1_seg_1440 MG1_X_5107_Y_4032 MG1_X_5107_Y_4480 265.3m
R_MG1_seg_1441 MG1_X_5107_Y_4480 MG1_X_5107_Y_4569 53.05m
R_MG1_seg_1442 MG1_X_5107_Y_4569 MG1_X_5107_Y_5040 278.5m
R_MG1_seg_1443 MG1_X_5107_Y_5040 MG1_X_5107_Y_5107 39.79m
R_MG1_seg_1444 MG1_X_5107_Y_5107 MG1_X_5107_Y_5600 291.8m
R_MG1_seg_1445 MG1_X_5107_Y_5600 MG1_X_5107_Y_5644 26.53m
R_MG1_seg_1446 MG1_X_5107_Y_5644 MG1_X_5107_Y_6160 305m
R_MG1_seg_1447 MG1_X_5107_Y_6160 MG1_X_5107_Y_6182 13.26m
R_MG1_seg_1448 MG1_X_5107_Y_6182 MG1_X_5107_Y_6720 318.3m
R_MG1_seg_1449 MG1_X_5107_Y_6720 MG1_X_5107_Y_7257 318.3m
R_MG1_seg_1450 MG1_X_5107_Y_7257 MG1_X_5107_Y_7280 13.26m
R_MG1_seg_1451 MG1_X_5107_Y_7280 MG1_X_5107_Y_7795 305m
R_MG1_seg_1452 MG1_X_5107_Y_7795 MG1_X_5107_Y_7840 26.53m
R_MG1_seg_1453 MG1_X_5107_Y_7840 MG1_X_5107_Y_8332 291.8m
R_MG1_seg_1454 MG1_X_5107_Y_8332 MG1_X_5107_Y_8400 39.79m
R_MG1_seg_1455 MG1_X_5107_Y_8400 MG1_X_5107_Y_8870 278.5m
R_MG1_seg_1456 MG1_X_5107_Y_8870 MG1_X_5107_Y_8960 53.05m
R_MG1_seg_1457 MG1_X_5107_Y_8960 MG1_X_5107_Y_9408 265.3m
R_MG1_seg_1458 MG1_X_5107_Y_9408 MG1_X_5107_Y_9520 66.31m
R_MG1_seg_1459 MG1_X_5107_Y_9520 MG1_X_5107_Y_9945 252m
R_MG1_seg_1460 MG1_X_5107_Y_9945 MG1_X_5107_Y_10000 32.21m
R_MG1_seg_1461 MG1_X_5376_Y_0 MG1_X_5376_Y_537 318.3m
R_MG1_seg_1462 MG1_X_5376_Y_537 MG1_X_5376_Y_560 13.26m
R_MG1_seg_1463 MG1_X_5376_Y_560 MG1_X_5376_Y_1075 305m
R_MG1_seg_1464 MG1_X_5376_Y_1075 MG1_X_5376_Y_1120 26.53m
R_MG1_seg_1465 MG1_X_5376_Y_1120 MG1_X_5376_Y_1612 291.8m
R_MG1_seg_1466 MG1_X_5376_Y_1612 MG1_X_5376_Y_1680 39.79m
R_MG1_seg_1467 MG1_X_5376_Y_1680 MG1_X_5376_Y_2150 278.5m
R_MG1_seg_1468 MG1_X_5376_Y_2150 MG1_X_5376_Y_2240 53.05m
R_MG1_seg_1469 MG1_X_5376_Y_2240 MG1_X_5376_Y_2688 265.3m
R_MG1_seg_1470 MG1_X_5376_Y_2688 MG1_X_5376_Y_2800 66.31m
R_MG1_seg_1471 MG1_X_5376_Y_2800 MG1_X_5376_Y_3225 252m
R_MG1_seg_1472 MG1_X_5376_Y_3225 MG1_X_5376_Y_3360 79.58m
R_MG1_seg_1473 MG1_X_5376_Y_3360 MG1_X_5376_Y_3763 238.7m
R_MG1_seg_1474 MG1_X_5376_Y_3763 MG1_X_5376_Y_3920 92.84m
R_MG1_seg_1475 MG1_X_5376_Y_3920 MG1_X_5376_Y_4300 225.5m
R_MG1_seg_1476 MG1_X_5376_Y_4300 MG1_X_5376_Y_4480 106.1m
R_MG1_seg_1477 MG1_X_5376_Y_4480 MG1_X_5376_Y_4838 212.2m
R_MG1_seg_1478 MG1_X_5376_Y_4838 MG1_X_5376_Y_5040 119.4m
R_MG1_seg_1479 MG1_X_5376_Y_5040 MG1_X_5376_Y_5376 198.9m
R_MG1_seg_1480 MG1_X_5376_Y_5376 MG1_X_5376_Y_5600 132.6m
R_MG1_seg_1481 MG1_X_5376_Y_5600 MG1_X_5376_Y_5913 185.7m
R_MG1_seg_1482 MG1_X_5376_Y_5913 MG1_X_5376_Y_6160 145.9m
R_MG1_seg_1483 MG1_X_5376_Y_6160 MG1_X_5376_Y_6451 172.4m
R_MG1_seg_1484 MG1_X_5376_Y_6451 MG1_X_5376_Y_6720 159.2m
R_MG1_seg_1485 MG1_X_5376_Y_6720 MG1_X_5376_Y_6988 159.2m
R_MG1_seg_1486 MG1_X_5376_Y_6988 MG1_X_5376_Y_7280 172.4m
R_MG1_seg_1487 MG1_X_5376_Y_7280 MG1_X_5376_Y_7526 145.9m
R_MG1_seg_1488 MG1_X_5376_Y_7526 MG1_X_5376_Y_7840 185.7m
R_MG1_seg_1489 MG1_X_5376_Y_7840 MG1_X_5376_Y_8064 132.6m
R_MG1_seg_1490 MG1_X_5376_Y_8064 MG1_X_5376_Y_8400 198.9m
R_MG1_seg_1491 MG1_X_5376_Y_8400 MG1_X_5376_Y_8601 119.4m
R_MG1_seg_1492 MG1_X_5376_Y_8601 MG1_X_5376_Y_8960 212.2m
R_MG1_seg_1493 MG1_X_5376_Y_8960 MG1_X_5376_Y_9139 106.1m
R_MG1_seg_1494 MG1_X_5376_Y_9139 MG1_X_5376_Y_9520 225.5m
R_MG1_seg_1495 MG1_X_5376_Y_9520 MG1_X_5376_Y_9676 92.84m
R_MG1_seg_1496 MG1_X_5376_Y_9676 MG1_X_5376_Y_10000 191.4m
R_MG1_seg_1497 MG1_X_5644_Y_0 MG1_X_5644_Y_268 159.2m
R_MG1_seg_1498 MG1_X_5644_Y_268 MG1_X_5644_Y_560 172.4m
R_MG1_seg_1499 MG1_X_5644_Y_560 MG1_X_5644_Y_806 145.9m
R_MG1_seg_1500 MG1_X_5644_Y_806 MG1_X_5644_Y_1120 185.7m
R_MG1_seg_1501 MG1_X_5644_Y_1120 MG1_X_5644_Y_1344 132.6m
R_MG1_seg_1502 MG1_X_5644_Y_1344 MG1_X_5644_Y_1680 198.9m
R_MG1_seg_1503 MG1_X_5644_Y_1680 MG1_X_5644_Y_1881 119.4m
R_MG1_seg_1504 MG1_X_5644_Y_1881 MG1_X_5644_Y_2240 212.2m
R_MG1_seg_1505 MG1_X_5644_Y_2240 MG1_X_5644_Y_2419 106.1m
R_MG1_seg_1506 MG1_X_5644_Y_2419 MG1_X_5644_Y_2800 225.5m
R_MG1_seg_1507 MG1_X_5644_Y_2800 MG1_X_5644_Y_2956 92.84m
R_MG1_seg_1508 MG1_X_5644_Y_2956 MG1_X_5644_Y_3360 238.7m
R_MG1_seg_1509 MG1_X_5644_Y_3360 MG1_X_5644_Y_3494 79.58m
R_MG1_seg_1510 MG1_X_5644_Y_3494 MG1_X_5644_Y_3920 252m
R_MG1_seg_1511 MG1_X_5644_Y_3920 MG1_X_5644_Y_4032 66.31m
R_MG1_seg_1512 MG1_X_5644_Y_4032 MG1_X_5644_Y_4480 265.3m
R_MG1_seg_1513 MG1_X_5644_Y_4480 MG1_X_5644_Y_4569 53.05m
R_MG1_seg_1514 MG1_X_5644_Y_4569 MG1_X_5644_Y_5040 278.5m
R_MG1_seg_1515 MG1_X_5644_Y_5040 MG1_X_5644_Y_5107 39.79m
R_MG1_seg_1516 MG1_X_5644_Y_5107 MG1_X_5644_Y_5600 291.8m
R_MG1_seg_1517 MG1_X_5644_Y_5600 MG1_X_5644_Y_5644 26.53m
R_MG1_seg_1518 MG1_X_5644_Y_5644 MG1_X_5644_Y_6160 305m
R_MG1_seg_1519 MG1_X_5644_Y_6160 MG1_X_5644_Y_6182 13.26m
R_MG1_seg_1520 MG1_X_5644_Y_6182 MG1_X_5644_Y_6720 318.3m
R_MG1_seg_1521 MG1_X_5644_Y_6720 MG1_X_5644_Y_7257 318.3m
R_MG1_seg_1522 MG1_X_5644_Y_7257 MG1_X_5644_Y_7280 13.26m
R_MG1_seg_1523 MG1_X_5644_Y_7280 MG1_X_5644_Y_7795 305m
R_MG1_seg_1524 MG1_X_5644_Y_7795 MG1_X_5644_Y_7840 26.53m
R_MG1_seg_1525 MG1_X_5644_Y_7840 MG1_X_5644_Y_8332 291.8m
R_MG1_seg_1526 MG1_X_5644_Y_8332 MG1_X_5644_Y_8400 39.79m
R_MG1_seg_1527 MG1_X_5644_Y_8400 MG1_X_5644_Y_8870 278.5m
R_MG1_seg_1528 MG1_X_5644_Y_8870 MG1_X_5644_Y_8960 53.05m
R_MG1_seg_1529 MG1_X_5644_Y_8960 MG1_X_5644_Y_9408 265.3m
R_MG1_seg_1530 MG1_X_5644_Y_9408 MG1_X_5644_Y_9520 66.31m
R_MG1_seg_1531 MG1_X_5644_Y_9520 MG1_X_5644_Y_9945 252m
R_MG1_seg_1532 MG1_X_5644_Y_9945 MG1_X_5644_Y_10000 32.21m
R_MG1_seg_1533 MG1_X_5913_Y_0 MG1_X_5913_Y_537 318.3m
R_MG1_seg_1534 MG1_X_5913_Y_537 MG1_X_5913_Y_560 13.26m
R_MG1_seg_1535 MG1_X_5913_Y_560 MG1_X_5913_Y_1075 305m
R_MG1_seg_1536 MG1_X_5913_Y_1075 MG1_X_5913_Y_1120 26.53m
R_MG1_seg_1537 MG1_X_5913_Y_1120 MG1_X_5913_Y_1612 291.8m
R_MG1_seg_1538 MG1_X_5913_Y_1612 MG1_X_5913_Y_1680 39.79m
R_MG1_seg_1539 MG1_X_5913_Y_1680 MG1_X_5913_Y_2150 278.5m
R_MG1_seg_1540 MG1_X_5913_Y_2150 MG1_X_5913_Y_2240 53.05m
R_MG1_seg_1541 MG1_X_5913_Y_2240 MG1_X_5913_Y_2688 265.3m
R_MG1_seg_1542 MG1_X_5913_Y_2688 MG1_X_5913_Y_2800 66.31m
R_MG1_seg_1543 MG1_X_5913_Y_2800 MG1_X_5913_Y_3225 252m
R_MG1_seg_1544 MG1_X_5913_Y_3225 MG1_X_5913_Y_3360 79.58m
R_MG1_seg_1545 MG1_X_5913_Y_3360 MG1_X_5913_Y_3763 238.7m
R_MG1_seg_1546 MG1_X_5913_Y_3763 MG1_X_5913_Y_3920 92.84m
R_MG1_seg_1547 MG1_X_5913_Y_3920 MG1_X_5913_Y_4300 225.5m
R_MG1_seg_1548 MG1_X_5913_Y_4300 MG1_X_5913_Y_4480 106.1m
R_MG1_seg_1549 MG1_X_5913_Y_4480 MG1_X_5913_Y_4838 212.2m
R_MG1_seg_1550 MG1_X_5913_Y_4838 MG1_X_5913_Y_5040 119.4m
R_MG1_seg_1551 MG1_X_5913_Y_5040 MG1_X_5913_Y_5376 198.9m
R_MG1_seg_1552 MG1_X_5913_Y_5376 MG1_X_5913_Y_5600 132.6m
R_MG1_seg_1553 MG1_X_5913_Y_5600 MG1_X_5913_Y_5913 185.7m
R_MG1_seg_1554 MG1_X_5913_Y_5913 MG1_X_5913_Y_6160 145.9m
R_MG1_seg_1555 MG1_X_5913_Y_6160 MG1_X_5913_Y_6451 172.4m
R_MG1_seg_1556 MG1_X_5913_Y_6451 MG1_X_5913_Y_6720 159.2m
R_MG1_seg_1557 MG1_X_5913_Y_6720 MG1_X_5913_Y_6988 159.2m
R_MG1_seg_1558 MG1_X_5913_Y_6988 MG1_X_5913_Y_7280 172.4m
R_MG1_seg_1559 MG1_X_5913_Y_7280 MG1_X_5913_Y_7526 145.9m
R_MG1_seg_1560 MG1_X_5913_Y_7526 MG1_X_5913_Y_7840 185.7m
R_MG1_seg_1561 MG1_X_5913_Y_7840 MG1_X_5913_Y_8064 132.6m
R_MG1_seg_1562 MG1_X_5913_Y_8064 MG1_X_5913_Y_8400 198.9m
R_MG1_seg_1563 MG1_X_5913_Y_8400 MG1_X_5913_Y_8601 119.4m
R_MG1_seg_1564 MG1_X_5913_Y_8601 MG1_X_5913_Y_8960 212.2m
R_MG1_seg_1565 MG1_X_5913_Y_8960 MG1_X_5913_Y_9139 106.1m
R_MG1_seg_1566 MG1_X_5913_Y_9139 MG1_X_5913_Y_9520 225.5m
R_MG1_seg_1567 MG1_X_5913_Y_9520 MG1_X_5913_Y_9676 92.84m
R_MG1_seg_1568 MG1_X_5913_Y_9676 MG1_X_5913_Y_10000 191.4m
R_MG1_seg_1569 MG1_X_6182_Y_0 MG1_X_6182_Y_268 159.2m
R_MG1_seg_1570 MG1_X_6182_Y_268 MG1_X_6182_Y_560 172.4m
R_MG1_seg_1571 MG1_X_6182_Y_560 MG1_X_6182_Y_806 145.9m
R_MG1_seg_1572 MG1_X_6182_Y_806 MG1_X_6182_Y_1120 185.7m
R_MG1_seg_1573 MG1_X_6182_Y_1120 MG1_X_6182_Y_1344 132.6m
R_MG1_seg_1574 MG1_X_6182_Y_1344 MG1_X_6182_Y_1680 198.9m
R_MG1_seg_1575 MG1_X_6182_Y_1680 MG1_X_6182_Y_1881 119.4m
R_MG1_seg_1576 MG1_X_6182_Y_1881 MG1_X_6182_Y_2240 212.2m
R_MG1_seg_1577 MG1_X_6182_Y_2240 MG1_X_6182_Y_2419 106.1m
R_MG1_seg_1578 MG1_X_6182_Y_2419 MG1_X_6182_Y_2800 225.5m
R_MG1_seg_1579 MG1_X_6182_Y_2800 MG1_X_6182_Y_2956 92.84m
R_MG1_seg_1580 MG1_X_6182_Y_2956 MG1_X_6182_Y_3360 238.7m
R_MG1_seg_1581 MG1_X_6182_Y_3360 MG1_X_6182_Y_3494 79.58m
R_MG1_seg_1582 MG1_X_6182_Y_3494 MG1_X_6182_Y_3920 252m
R_MG1_seg_1583 MG1_X_6182_Y_3920 MG1_X_6182_Y_4032 66.31m
R_MG1_seg_1584 MG1_X_6182_Y_4032 MG1_X_6182_Y_4480 265.3m
R_MG1_seg_1585 MG1_X_6182_Y_4480 MG1_X_6182_Y_4569 53.05m
R_MG1_seg_1586 MG1_X_6182_Y_4569 MG1_X_6182_Y_5040 278.5m
R_MG1_seg_1587 MG1_X_6182_Y_5040 MG1_X_6182_Y_5107 39.79m
R_MG1_seg_1588 MG1_X_6182_Y_5107 MG1_X_6182_Y_5600 291.8m
R_MG1_seg_1589 MG1_X_6182_Y_5600 MG1_X_6182_Y_5644 26.53m
R_MG1_seg_1590 MG1_X_6182_Y_5644 MG1_X_6182_Y_6160 305m
R_MG1_seg_1591 MG1_X_6182_Y_6160 MG1_X_6182_Y_6182 13.26m
R_MG1_seg_1592 MG1_X_6182_Y_6182 MG1_X_6182_Y_6720 318.3m
R_MG1_seg_1593 MG1_X_6182_Y_6720 MG1_X_6182_Y_7257 318.3m
R_MG1_seg_1594 MG1_X_6182_Y_7257 MG1_X_6182_Y_7280 13.26m
R_MG1_seg_1595 MG1_X_6182_Y_7280 MG1_X_6182_Y_7795 305m
R_MG1_seg_1596 MG1_X_6182_Y_7795 MG1_X_6182_Y_7840 26.53m
R_MG1_seg_1597 MG1_X_6182_Y_7840 MG1_X_6182_Y_8332 291.8m
R_MG1_seg_1598 MG1_X_6182_Y_8332 MG1_X_6182_Y_8400 39.79m
R_MG1_seg_1599 MG1_X_6182_Y_8400 MG1_X_6182_Y_8870 278.5m
R_MG1_seg_1600 MG1_X_6182_Y_8870 MG1_X_6182_Y_8960 53.05m
R_MG1_seg_1601 MG1_X_6182_Y_8960 MG1_X_6182_Y_9408 265.3m
R_MG1_seg_1602 MG1_X_6182_Y_9408 MG1_X_6182_Y_9520 66.31m
R_MG1_seg_1603 MG1_X_6182_Y_9520 MG1_X_6182_Y_9945 252m
R_MG1_seg_1604 MG1_X_6182_Y_9945 MG1_X_6182_Y_10000 32.21m
R_MG1_seg_1605 MG1_X_6451_Y_0 MG1_X_6451_Y_537 318.3m
R_MG1_seg_1606 MG1_X_6451_Y_537 MG1_X_6451_Y_560 13.26m
R_MG1_seg_1607 MG1_X_6451_Y_560 MG1_X_6451_Y_1075 305m
R_MG1_seg_1608 MG1_X_6451_Y_1075 MG1_X_6451_Y_1120 26.53m
R_MG1_seg_1609 MG1_X_6451_Y_1120 MG1_X_6451_Y_1612 291.8m
R_MG1_seg_1610 MG1_X_6451_Y_1612 MG1_X_6451_Y_1680 39.79m
R_MG1_seg_1611 MG1_X_6451_Y_1680 MG1_X_6451_Y_2150 278.5m
R_MG1_seg_1612 MG1_X_6451_Y_2150 MG1_X_6451_Y_2240 53.05m
R_MG1_seg_1613 MG1_X_6451_Y_2240 MG1_X_6451_Y_2688 265.3m
R_MG1_seg_1614 MG1_X_6451_Y_2688 MG1_X_6451_Y_2800 66.31m
R_MG1_seg_1615 MG1_X_6451_Y_2800 MG1_X_6451_Y_3225 252m
R_MG1_seg_1616 MG1_X_6451_Y_3225 MG1_X_6451_Y_3360 79.58m
R_MG1_seg_1617 MG1_X_6451_Y_3360 MG1_X_6451_Y_3763 238.7m
R_MG1_seg_1618 MG1_X_6451_Y_3763 MG1_X_6451_Y_3920 92.84m
R_MG1_seg_1619 MG1_X_6451_Y_3920 MG1_X_6451_Y_4300 225.5m
R_MG1_seg_1620 MG1_X_6451_Y_4300 MG1_X_6451_Y_4480 106.1m
R_MG1_seg_1621 MG1_X_6451_Y_4480 MG1_X_6451_Y_4838 212.2m
R_MG1_seg_1622 MG1_X_6451_Y_4838 MG1_X_6451_Y_5040 119.4m
R_MG1_seg_1623 MG1_X_6451_Y_5040 MG1_X_6451_Y_5376 198.9m
R_MG1_seg_1624 MG1_X_6451_Y_5376 MG1_X_6451_Y_5600 132.6m
R_MG1_seg_1625 MG1_X_6451_Y_5600 MG1_X_6451_Y_5913 185.7m
R_MG1_seg_1626 MG1_X_6451_Y_5913 MG1_X_6451_Y_6160 145.9m
R_MG1_seg_1627 MG1_X_6451_Y_6160 MG1_X_6451_Y_6451 172.4m
R_MG1_seg_1628 MG1_X_6451_Y_6451 MG1_X_6451_Y_6720 159.2m
R_MG1_seg_1629 MG1_X_6451_Y_6720 MG1_X_6451_Y_6988 159.2m
R_MG1_seg_1630 MG1_X_6451_Y_6988 MG1_X_6451_Y_7280 172.4m
R_MG1_seg_1631 MG1_X_6451_Y_7280 MG1_X_6451_Y_7526 145.9m
R_MG1_seg_1632 MG1_X_6451_Y_7526 MG1_X_6451_Y_7840 185.7m
R_MG1_seg_1633 MG1_X_6451_Y_7840 MG1_X_6451_Y_8064 132.6m
R_MG1_seg_1634 MG1_X_6451_Y_8064 MG1_X_6451_Y_8400 198.9m
R_MG1_seg_1635 MG1_X_6451_Y_8400 MG1_X_6451_Y_8601 119.4m
R_MG1_seg_1636 MG1_X_6451_Y_8601 MG1_X_6451_Y_8960 212.2m
R_MG1_seg_1637 MG1_X_6451_Y_8960 MG1_X_6451_Y_9139 106.1m
R_MG1_seg_1638 MG1_X_6451_Y_9139 MG1_X_6451_Y_9520 225.5m
R_MG1_seg_1639 MG1_X_6451_Y_9520 MG1_X_6451_Y_9676 92.84m
R_MG1_seg_1640 MG1_X_6451_Y_9676 MG1_X_6451_Y_10000 191.4m
R_MG1_seg_1641 MG1_X_6720_Y_0 MG1_X_6720_Y_268 159.2m
R_MG1_seg_1642 MG1_X_6720_Y_268 MG1_X_6720_Y_560 172.4m
R_MG1_seg_1643 MG1_X_6720_Y_560 MG1_X_6720_Y_806 145.9m
R_MG1_seg_1644 MG1_X_6720_Y_806 MG1_X_6720_Y_1120 185.7m
R_MG1_seg_1645 MG1_X_6720_Y_1120 MG1_X_6720_Y_1344 132.6m
R_MG1_seg_1646 MG1_X_6720_Y_1344 MG1_X_6720_Y_1680 198.9m
R_MG1_seg_1647 MG1_X_6720_Y_1680 MG1_X_6720_Y_1881 119.4m
R_MG1_seg_1648 MG1_X_6720_Y_1881 MG1_X_6720_Y_2240 212.2m
R_MG1_seg_1649 MG1_X_6720_Y_2240 MG1_X_6720_Y_2419 106.1m
R_MG1_seg_1650 MG1_X_6720_Y_2419 MG1_X_6720_Y_2800 225.5m
R_MG1_seg_1651 MG1_X_6720_Y_2800 MG1_X_6720_Y_2956 92.84m
R_MG1_seg_1652 MG1_X_6720_Y_2956 MG1_X_6720_Y_3360 238.7m
R_MG1_seg_1653 MG1_X_6720_Y_3360 MG1_X_6720_Y_3494 79.58m
R_MG1_seg_1654 MG1_X_6720_Y_3494 MG1_X_6720_Y_3920 252m
R_MG1_seg_1655 MG1_X_6720_Y_3920 MG1_X_6720_Y_4032 66.31m
R_MG1_seg_1656 MG1_X_6720_Y_4032 MG1_X_6720_Y_4480 265.3m
R_MG1_seg_1657 MG1_X_6720_Y_4480 MG1_X_6720_Y_4569 53.05m
R_MG1_seg_1658 MG1_X_6720_Y_4569 MG1_X_6720_Y_5040 278.5m
R_MG1_seg_1659 MG1_X_6720_Y_5040 MG1_X_6720_Y_5107 39.79m
R_MG1_seg_1660 MG1_X_6720_Y_5107 MG1_X_6720_Y_5600 291.8m
R_MG1_seg_1661 MG1_X_6720_Y_5600 MG1_X_6720_Y_5644 26.53m
R_MG1_seg_1662 MG1_X_6720_Y_5644 MG1_X_6720_Y_6160 305m
R_MG1_seg_1663 MG1_X_6720_Y_6160 MG1_X_6720_Y_6182 13.26m
R_MG1_seg_1664 MG1_X_6720_Y_6182 MG1_X_6720_Y_6720 318.3m
R_MG1_seg_1665 MG1_X_6720_Y_6720 MG1_X_6720_Y_7257 318.3m
R_MG1_seg_1666 MG1_X_6720_Y_7257 MG1_X_6720_Y_7280 13.26m
R_MG1_seg_1667 MG1_X_6720_Y_7280 MG1_X_6720_Y_7795 305m
R_MG1_seg_1668 MG1_X_6720_Y_7795 MG1_X_6720_Y_7840 26.53m
R_MG1_seg_1669 MG1_X_6720_Y_7840 MG1_X_6720_Y_8332 291.8m
R_MG1_seg_1670 MG1_X_6720_Y_8332 MG1_X_6720_Y_8400 39.79m
R_MG1_seg_1671 MG1_X_6720_Y_8400 MG1_X_6720_Y_8870 278.5m
R_MG1_seg_1672 MG1_X_6720_Y_8870 MG1_X_6720_Y_8960 53.05m
R_MG1_seg_1673 MG1_X_6720_Y_8960 MG1_X_6720_Y_9408 265.3m
R_MG1_seg_1674 MG1_X_6720_Y_9408 MG1_X_6720_Y_9520 66.31m
R_MG1_seg_1675 MG1_X_6720_Y_9520 MG1_X_6720_Y_9945 252m
R_MG1_seg_1676 MG1_X_6720_Y_9945 MG1_X_6720_Y_10000 32.21m
R_MG1_seg_1677 MG1_X_6988_Y_0 MG1_X_6988_Y_537 318.3m
R_MG1_seg_1678 MG1_X_6988_Y_537 MG1_X_6988_Y_560 13.26m
R_MG1_seg_1679 MG1_X_6988_Y_560 MG1_X_6988_Y_1075 305m
R_MG1_seg_1680 MG1_X_6988_Y_1075 MG1_X_6988_Y_1120 26.53m
R_MG1_seg_1681 MG1_X_6988_Y_1120 MG1_X_6988_Y_1612 291.8m
R_MG1_seg_1682 MG1_X_6988_Y_1612 MG1_X_6988_Y_1680 39.79m
R_MG1_seg_1683 MG1_X_6988_Y_1680 MG1_X_6988_Y_2150 278.5m
R_MG1_seg_1684 MG1_X_6988_Y_2150 MG1_X_6988_Y_2240 53.05m
R_MG1_seg_1685 MG1_X_6988_Y_2240 MG1_X_6988_Y_2688 265.3m
R_MG1_seg_1686 MG1_X_6988_Y_2688 MG1_X_6988_Y_2800 66.31m
R_MG1_seg_1687 MG1_X_6988_Y_2800 MG1_X_6988_Y_3225 252m
R_MG1_seg_1688 MG1_X_6988_Y_3225 MG1_X_6988_Y_3360 79.58m
R_MG1_seg_1689 MG1_X_6988_Y_3360 MG1_X_6988_Y_3763 238.7m
R_MG1_seg_1690 MG1_X_6988_Y_3763 MG1_X_6988_Y_3920 92.84m
R_MG1_seg_1691 MG1_X_6988_Y_3920 MG1_X_6988_Y_4300 225.5m
R_MG1_seg_1692 MG1_X_6988_Y_4300 MG1_X_6988_Y_4480 106.1m
R_MG1_seg_1693 MG1_X_6988_Y_4480 MG1_X_6988_Y_4838 212.2m
R_MG1_seg_1694 MG1_X_6988_Y_4838 MG1_X_6988_Y_5040 119.4m
R_MG1_seg_1695 MG1_X_6988_Y_5040 MG1_X_6988_Y_5376 198.9m
R_MG1_seg_1696 MG1_X_6988_Y_5376 MG1_X_6988_Y_5600 132.6m
R_MG1_seg_1697 MG1_X_6988_Y_5600 MG1_X_6988_Y_5913 185.7m
R_MG1_seg_1698 MG1_X_6988_Y_5913 MG1_X_6988_Y_6160 145.9m
R_MG1_seg_1699 MG1_X_6988_Y_6160 MG1_X_6988_Y_6451 172.4m
R_MG1_seg_1700 MG1_X_6988_Y_6451 MG1_X_6988_Y_6720 159.2m
R_MG1_seg_1701 MG1_X_6988_Y_6720 MG1_X_6988_Y_6988 159.2m
R_MG1_seg_1702 MG1_X_6988_Y_6988 MG1_X_6988_Y_7280 172.4m
R_MG1_seg_1703 MG1_X_6988_Y_7280 MG1_X_6988_Y_7526 145.9m
R_MG1_seg_1704 MG1_X_6988_Y_7526 MG1_X_6988_Y_7840 185.7m
R_MG1_seg_1705 MG1_X_6988_Y_7840 MG1_X_6988_Y_8064 132.6m
R_MG1_seg_1706 MG1_X_6988_Y_8064 MG1_X_6988_Y_8400 198.9m
R_MG1_seg_1707 MG1_X_6988_Y_8400 MG1_X_6988_Y_8601 119.4m
R_MG1_seg_1708 MG1_X_6988_Y_8601 MG1_X_6988_Y_8960 212.2m
R_MG1_seg_1709 MG1_X_6988_Y_8960 MG1_X_6988_Y_9139 106.1m
R_MG1_seg_1710 MG1_X_6988_Y_9139 MG1_X_6988_Y_9520 225.5m
R_MG1_seg_1711 MG1_X_6988_Y_9520 MG1_X_6988_Y_9676 92.84m
R_MG1_seg_1712 MG1_X_6988_Y_9676 MG1_X_6988_Y_10000 191.4m
R_MG1_seg_1713 MG1_X_7257_Y_0 MG1_X_7257_Y_268 159.2m
R_MG1_seg_1714 MG1_X_7257_Y_268 MG1_X_7257_Y_560 172.4m
R_MG1_seg_1715 MG1_X_7257_Y_560 MG1_X_7257_Y_806 145.9m
R_MG1_seg_1716 MG1_X_7257_Y_806 MG1_X_7257_Y_1120 185.7m
R_MG1_seg_1717 MG1_X_7257_Y_1120 MG1_X_7257_Y_1344 132.6m
R_MG1_seg_1718 MG1_X_7257_Y_1344 MG1_X_7257_Y_1680 198.9m
R_MG1_seg_1719 MG1_X_7257_Y_1680 MG1_X_7257_Y_1881 119.4m
R_MG1_seg_1720 MG1_X_7257_Y_1881 MG1_X_7257_Y_2240 212.2m
R_MG1_seg_1721 MG1_X_7257_Y_2240 MG1_X_7257_Y_2419 106.1m
R_MG1_seg_1722 MG1_X_7257_Y_2419 MG1_X_7257_Y_2800 225.5m
R_MG1_seg_1723 MG1_X_7257_Y_2800 MG1_X_7257_Y_2956 92.84m
R_MG1_seg_1724 MG1_X_7257_Y_2956 MG1_X_7257_Y_3360 238.7m
R_MG1_seg_1725 MG1_X_7257_Y_3360 MG1_X_7257_Y_3494 79.58m
R_MG1_seg_1726 MG1_X_7257_Y_3494 MG1_X_7257_Y_3920 252m
R_MG1_seg_1727 MG1_X_7257_Y_3920 MG1_X_7257_Y_4032 66.31m
R_MG1_seg_1728 MG1_X_7257_Y_4032 MG1_X_7257_Y_4480 265.3m
R_MG1_seg_1729 MG1_X_7257_Y_4480 MG1_X_7257_Y_4569 53.05m
R_MG1_seg_1730 MG1_X_7257_Y_4569 MG1_X_7257_Y_5040 278.5m
R_MG1_seg_1731 MG1_X_7257_Y_5040 MG1_X_7257_Y_5107 39.79m
R_MG1_seg_1732 MG1_X_7257_Y_5107 MG1_X_7257_Y_5600 291.8m
R_MG1_seg_1733 MG1_X_7257_Y_5600 MG1_X_7257_Y_5644 26.53m
R_MG1_seg_1734 MG1_X_7257_Y_5644 MG1_X_7257_Y_6160 305m
R_MG1_seg_1735 MG1_X_7257_Y_6160 MG1_X_7257_Y_6182 13.26m
R_MG1_seg_1736 MG1_X_7257_Y_6182 MG1_X_7257_Y_6720 318.3m
R_MG1_seg_1737 MG1_X_7257_Y_6720 MG1_X_7257_Y_7257 318.3m
R_MG1_seg_1738 MG1_X_7257_Y_7257 MG1_X_7257_Y_7280 13.26m
R_MG1_seg_1739 MG1_X_7257_Y_7280 MG1_X_7257_Y_7795 305m
R_MG1_seg_1740 MG1_X_7257_Y_7795 MG1_X_7257_Y_7840 26.53m
R_MG1_seg_1741 MG1_X_7257_Y_7840 MG1_X_7257_Y_8332 291.8m
R_MG1_seg_1742 MG1_X_7257_Y_8332 MG1_X_7257_Y_8400 39.79m
R_MG1_seg_1743 MG1_X_7257_Y_8400 MG1_X_7257_Y_8870 278.5m
R_MG1_seg_1744 MG1_X_7257_Y_8870 MG1_X_7257_Y_8960 53.05m
R_MG1_seg_1745 MG1_X_7257_Y_8960 MG1_X_7257_Y_9408 265.3m
R_MG1_seg_1746 MG1_X_7257_Y_9408 MG1_X_7257_Y_9520 66.31m
R_MG1_seg_1747 MG1_X_7257_Y_9520 MG1_X_7257_Y_9945 252m
R_MG1_seg_1748 MG1_X_7257_Y_9945 MG1_X_7257_Y_10000 32.21m
R_MG1_seg_1749 MG1_X_7526_Y_0 MG1_X_7526_Y_537 318.3m
R_MG1_seg_1750 MG1_X_7526_Y_537 MG1_X_7526_Y_560 13.26m
R_MG1_seg_1751 MG1_X_7526_Y_560 MG1_X_7526_Y_1075 305m
R_MG1_seg_1752 MG1_X_7526_Y_1075 MG1_X_7526_Y_1120 26.53m
R_MG1_seg_1753 MG1_X_7526_Y_1120 MG1_X_7526_Y_1612 291.8m
R_MG1_seg_1754 MG1_X_7526_Y_1612 MG1_X_7526_Y_1680 39.79m
R_MG1_seg_1755 MG1_X_7526_Y_1680 MG1_X_7526_Y_2150 278.5m
R_MG1_seg_1756 MG1_X_7526_Y_2150 MG1_X_7526_Y_2240 53.05m
R_MG1_seg_1757 MG1_X_7526_Y_2240 MG1_X_7526_Y_2688 265.3m
R_MG1_seg_1758 MG1_X_7526_Y_2688 MG1_X_7526_Y_2800 66.31m
R_MG1_seg_1759 MG1_X_7526_Y_2800 MG1_X_7526_Y_3225 252m
R_MG1_seg_1760 MG1_X_7526_Y_3225 MG1_X_7526_Y_3360 79.58m
R_MG1_seg_1761 MG1_X_7526_Y_3360 MG1_X_7526_Y_3763 238.7m
R_MG1_seg_1762 MG1_X_7526_Y_3763 MG1_X_7526_Y_3920 92.84m
R_MG1_seg_1763 MG1_X_7526_Y_3920 MG1_X_7526_Y_4300 225.5m
R_MG1_seg_1764 MG1_X_7526_Y_4300 MG1_X_7526_Y_4480 106.1m
R_MG1_seg_1765 MG1_X_7526_Y_4480 MG1_X_7526_Y_4838 212.2m
R_MG1_seg_1766 MG1_X_7526_Y_4838 MG1_X_7526_Y_5040 119.4m
R_MG1_seg_1767 MG1_X_7526_Y_5040 MG1_X_7526_Y_5376 198.9m
R_MG1_seg_1768 MG1_X_7526_Y_5376 MG1_X_7526_Y_5600 132.6m
R_MG1_seg_1769 MG1_X_7526_Y_5600 MG1_X_7526_Y_5913 185.7m
R_MG1_seg_1770 MG1_X_7526_Y_5913 MG1_X_7526_Y_6160 145.9m
R_MG1_seg_1771 MG1_X_7526_Y_6160 MG1_X_7526_Y_6451 172.4m
R_MG1_seg_1772 MG1_X_7526_Y_6451 MG1_X_7526_Y_6720 159.2m
R_MG1_seg_1773 MG1_X_7526_Y_6720 MG1_X_7526_Y_6988 159.2m
R_MG1_seg_1774 MG1_X_7526_Y_6988 MG1_X_7526_Y_7280 172.4m
R_MG1_seg_1775 MG1_X_7526_Y_7280 MG1_X_7526_Y_7526 145.9m
R_MG1_seg_1776 MG1_X_7526_Y_7526 MG1_X_7526_Y_7840 185.7m
R_MG1_seg_1777 MG1_X_7526_Y_7840 MG1_X_7526_Y_8064 132.6m
R_MG1_seg_1778 MG1_X_7526_Y_8064 MG1_X_7526_Y_8400 198.9m
R_MG1_seg_1779 MG1_X_7526_Y_8400 MG1_X_7526_Y_8601 119.4m
R_MG1_seg_1780 MG1_X_7526_Y_8601 MG1_X_7526_Y_8960 212.2m
R_MG1_seg_1781 MG1_X_7526_Y_8960 MG1_X_7526_Y_9139 106.1m
R_MG1_seg_1782 MG1_X_7526_Y_9139 MG1_X_7526_Y_9520 225.5m
R_MG1_seg_1783 MG1_X_7526_Y_9520 MG1_X_7526_Y_9676 92.84m
R_MG1_seg_1784 MG1_X_7526_Y_9676 MG1_X_7526_Y_10000 191.4m
R_MG1_seg_1785 MG1_X_7795_Y_0 MG1_X_7795_Y_268 159.2m
R_MG1_seg_1786 MG1_X_7795_Y_268 MG1_X_7795_Y_560 172.4m
R_MG1_seg_1787 MG1_X_7795_Y_560 MG1_X_7795_Y_806 145.9m
R_MG1_seg_1788 MG1_X_7795_Y_806 MG1_X_7795_Y_1120 185.7m
R_MG1_seg_1789 MG1_X_7795_Y_1120 MG1_X_7795_Y_1344 132.6m
R_MG1_seg_1790 MG1_X_7795_Y_1344 MG1_X_7795_Y_1680 198.9m
R_MG1_seg_1791 MG1_X_7795_Y_1680 MG1_X_7795_Y_1881 119.4m
R_MG1_seg_1792 MG1_X_7795_Y_1881 MG1_X_7795_Y_2240 212.2m
R_MG1_seg_1793 MG1_X_7795_Y_2240 MG1_X_7795_Y_2419 106.1m
R_MG1_seg_1794 MG1_X_7795_Y_2419 MG1_X_7795_Y_2800 225.5m
R_MG1_seg_1795 MG1_X_7795_Y_2800 MG1_X_7795_Y_2956 92.84m
R_MG1_seg_1796 MG1_X_7795_Y_2956 MG1_X_7795_Y_3360 238.7m
R_MG1_seg_1797 MG1_X_7795_Y_3360 MG1_X_7795_Y_3494 79.58m
R_MG1_seg_1798 MG1_X_7795_Y_3494 MG1_X_7795_Y_3920 252m
R_MG1_seg_1799 MG1_X_7795_Y_3920 MG1_X_7795_Y_4032 66.31m
R_MG1_seg_1800 MG1_X_7795_Y_4032 MG1_X_7795_Y_4480 265.3m
R_MG1_seg_1801 MG1_X_7795_Y_4480 MG1_X_7795_Y_4569 53.05m
R_MG1_seg_1802 MG1_X_7795_Y_4569 MG1_X_7795_Y_5040 278.5m
R_MG1_seg_1803 MG1_X_7795_Y_5040 MG1_X_7795_Y_5107 39.79m
R_MG1_seg_1804 MG1_X_7795_Y_5107 MG1_X_7795_Y_5600 291.8m
R_MG1_seg_1805 MG1_X_7795_Y_5600 MG1_X_7795_Y_5644 26.53m
R_MG1_seg_1806 MG1_X_7795_Y_5644 MG1_X_7795_Y_6160 305m
R_MG1_seg_1807 MG1_X_7795_Y_6160 MG1_X_7795_Y_6182 13.26m
R_MG1_seg_1808 MG1_X_7795_Y_6182 MG1_X_7795_Y_6720 318.3m
R_MG1_seg_1809 MG1_X_7795_Y_6720 MG1_X_7795_Y_7257 318.3m
R_MG1_seg_1810 MG1_X_7795_Y_7257 MG1_X_7795_Y_7280 13.26m
R_MG1_seg_1811 MG1_X_7795_Y_7280 MG1_X_7795_Y_7795 305m
R_MG1_seg_1812 MG1_X_7795_Y_7795 MG1_X_7795_Y_7840 26.53m
R_MG1_seg_1813 MG1_X_7795_Y_7840 MG1_X_7795_Y_8332 291.8m
R_MG1_seg_1814 MG1_X_7795_Y_8332 MG1_X_7795_Y_8400 39.79m
R_MG1_seg_1815 MG1_X_7795_Y_8400 MG1_X_7795_Y_8870 278.5m
R_MG1_seg_1816 MG1_X_7795_Y_8870 MG1_X_7795_Y_8960 53.05m
R_MG1_seg_1817 MG1_X_7795_Y_8960 MG1_X_7795_Y_9408 265.3m
R_MG1_seg_1818 MG1_X_7795_Y_9408 MG1_X_7795_Y_9520 66.31m
R_MG1_seg_1819 MG1_X_7795_Y_9520 MG1_X_7795_Y_9945 252m
R_MG1_seg_1820 MG1_X_7795_Y_9945 MG1_X_7795_Y_10000 32.21m
R_MG1_seg_1821 MG1_X_8064_Y_0 MG1_X_8064_Y_537 318.3m
R_MG1_seg_1822 MG1_X_8064_Y_537 MG1_X_8064_Y_560 13.26m
R_MG1_seg_1823 MG1_X_8064_Y_560 MG1_X_8064_Y_1075 305m
R_MG1_seg_1824 MG1_X_8064_Y_1075 MG1_X_8064_Y_1120 26.53m
R_MG1_seg_1825 MG1_X_8064_Y_1120 MG1_X_8064_Y_1612 291.8m
R_MG1_seg_1826 MG1_X_8064_Y_1612 MG1_X_8064_Y_1680 39.79m
R_MG1_seg_1827 MG1_X_8064_Y_1680 MG1_X_8064_Y_2150 278.5m
R_MG1_seg_1828 MG1_X_8064_Y_2150 MG1_X_8064_Y_2240 53.05m
R_MG1_seg_1829 MG1_X_8064_Y_2240 MG1_X_8064_Y_2688 265.3m
R_MG1_seg_1830 MG1_X_8064_Y_2688 MG1_X_8064_Y_2800 66.31m
R_MG1_seg_1831 MG1_X_8064_Y_2800 MG1_X_8064_Y_3225 252m
R_MG1_seg_1832 MG1_X_8064_Y_3225 MG1_X_8064_Y_3360 79.58m
R_MG1_seg_1833 MG1_X_8064_Y_3360 MG1_X_8064_Y_3763 238.7m
R_MG1_seg_1834 MG1_X_8064_Y_3763 MG1_X_8064_Y_3920 92.84m
R_MG1_seg_1835 MG1_X_8064_Y_3920 MG1_X_8064_Y_4300 225.5m
R_MG1_seg_1836 MG1_X_8064_Y_4300 MG1_X_8064_Y_4480 106.1m
R_MG1_seg_1837 MG1_X_8064_Y_4480 MG1_X_8064_Y_4838 212.2m
R_MG1_seg_1838 MG1_X_8064_Y_4838 MG1_X_8064_Y_5040 119.4m
R_MG1_seg_1839 MG1_X_8064_Y_5040 MG1_X_8064_Y_5376 198.9m
R_MG1_seg_1840 MG1_X_8064_Y_5376 MG1_X_8064_Y_5600 132.6m
R_MG1_seg_1841 MG1_X_8064_Y_5600 MG1_X_8064_Y_5913 185.7m
R_MG1_seg_1842 MG1_X_8064_Y_5913 MG1_X_8064_Y_6160 145.9m
R_MG1_seg_1843 MG1_X_8064_Y_6160 MG1_X_8064_Y_6451 172.4m
R_MG1_seg_1844 MG1_X_8064_Y_6451 MG1_X_8064_Y_6720 159.2m
R_MG1_seg_1845 MG1_X_8064_Y_6720 MG1_X_8064_Y_6988 159.2m
R_MG1_seg_1846 MG1_X_8064_Y_6988 MG1_X_8064_Y_7280 172.4m
R_MG1_seg_1847 MG1_X_8064_Y_7280 MG1_X_8064_Y_7526 145.9m
R_MG1_seg_1848 MG1_X_8064_Y_7526 MG1_X_8064_Y_7840 185.7m
R_MG1_seg_1849 MG1_X_8064_Y_7840 MG1_X_8064_Y_8064 132.6m
R_MG1_seg_1850 MG1_X_8064_Y_8064 MG1_X_8064_Y_8400 198.9m
R_MG1_seg_1851 MG1_X_8064_Y_8400 MG1_X_8064_Y_8601 119.4m
R_MG1_seg_1852 MG1_X_8064_Y_8601 MG1_X_8064_Y_8960 212.2m
R_MG1_seg_1853 MG1_X_8064_Y_8960 MG1_X_8064_Y_9139 106.1m
R_MG1_seg_1854 MG1_X_8064_Y_9139 MG1_X_8064_Y_9520 225.5m
R_MG1_seg_1855 MG1_X_8064_Y_9520 MG1_X_8064_Y_9676 92.84m
R_MG1_seg_1856 MG1_X_8064_Y_9676 MG1_X_8064_Y_10000 191.4m
R_MG1_seg_1857 MG1_X_8332_Y_0 MG1_X_8332_Y_268 159.2m
R_MG1_seg_1858 MG1_X_8332_Y_268 MG1_X_8332_Y_560 172.4m
R_MG1_seg_1859 MG1_X_8332_Y_560 MG1_X_8332_Y_806 145.9m
R_MG1_seg_1860 MG1_X_8332_Y_806 MG1_X_8332_Y_1120 185.7m
R_MG1_seg_1861 MG1_X_8332_Y_1120 MG1_X_8332_Y_1344 132.6m
R_MG1_seg_1862 MG1_X_8332_Y_1344 MG1_X_8332_Y_1680 198.9m
R_MG1_seg_1863 MG1_X_8332_Y_1680 MG1_X_8332_Y_1881 119.4m
R_MG1_seg_1864 MG1_X_8332_Y_1881 MG1_X_8332_Y_2240 212.2m
R_MG1_seg_1865 MG1_X_8332_Y_2240 MG1_X_8332_Y_2419 106.1m
R_MG1_seg_1866 MG1_X_8332_Y_2419 MG1_X_8332_Y_2800 225.5m
R_MG1_seg_1867 MG1_X_8332_Y_2800 MG1_X_8332_Y_2956 92.84m
R_MG1_seg_1868 MG1_X_8332_Y_2956 MG1_X_8332_Y_3360 238.7m
R_MG1_seg_1869 MG1_X_8332_Y_3360 MG1_X_8332_Y_3494 79.58m
R_MG1_seg_1870 MG1_X_8332_Y_3494 MG1_X_8332_Y_3920 252m
R_MG1_seg_1871 MG1_X_8332_Y_3920 MG1_X_8332_Y_4032 66.31m
R_MG1_seg_1872 MG1_X_8332_Y_4032 MG1_X_8332_Y_4480 265.3m
R_MG1_seg_1873 MG1_X_8332_Y_4480 MG1_X_8332_Y_4569 53.05m
R_MG1_seg_1874 MG1_X_8332_Y_4569 MG1_X_8332_Y_5040 278.5m
R_MG1_seg_1875 MG1_X_8332_Y_5040 MG1_X_8332_Y_5107 39.79m
R_MG1_seg_1876 MG1_X_8332_Y_5107 MG1_X_8332_Y_5600 291.8m
R_MG1_seg_1877 MG1_X_8332_Y_5600 MG1_X_8332_Y_5644 26.53m
R_MG1_seg_1878 MG1_X_8332_Y_5644 MG1_X_8332_Y_6160 305m
R_MG1_seg_1879 MG1_X_8332_Y_6160 MG1_X_8332_Y_6182 13.26m
R_MG1_seg_1880 MG1_X_8332_Y_6182 MG1_X_8332_Y_6720 318.3m
R_MG1_seg_1881 MG1_X_8332_Y_6720 MG1_X_8332_Y_7257 318.3m
R_MG1_seg_1882 MG1_X_8332_Y_7257 MG1_X_8332_Y_7280 13.26m
R_MG1_seg_1883 MG1_X_8332_Y_7280 MG1_X_8332_Y_7795 305m
R_MG1_seg_1884 MG1_X_8332_Y_7795 MG1_X_8332_Y_7840 26.53m
R_MG1_seg_1885 MG1_X_8332_Y_7840 MG1_X_8332_Y_8332 291.8m
R_MG1_seg_1886 MG1_X_8332_Y_8332 MG1_X_8332_Y_8400 39.79m
R_MG1_seg_1887 MG1_X_8332_Y_8400 MG1_X_8332_Y_8870 278.5m
R_MG1_seg_1888 MG1_X_8332_Y_8870 MG1_X_8332_Y_8960 53.05m
R_MG1_seg_1889 MG1_X_8332_Y_8960 MG1_X_8332_Y_9408 265.3m
R_MG1_seg_1890 MG1_X_8332_Y_9408 MG1_X_8332_Y_9520 66.31m
R_MG1_seg_1891 MG1_X_8332_Y_9520 MG1_X_8332_Y_9945 252m
R_MG1_seg_1892 MG1_X_8332_Y_9945 MG1_X_8332_Y_10000 32.21m
R_MG1_seg_1893 MG1_X_8601_Y_0 MG1_X_8601_Y_537 318.3m
R_MG1_seg_1894 MG1_X_8601_Y_537 MG1_X_8601_Y_560 13.26m
R_MG1_seg_1895 MG1_X_8601_Y_560 MG1_X_8601_Y_1075 305m
R_MG1_seg_1896 MG1_X_8601_Y_1075 MG1_X_8601_Y_1120 26.53m
R_MG1_seg_1897 MG1_X_8601_Y_1120 MG1_X_8601_Y_1612 291.8m
R_MG1_seg_1898 MG1_X_8601_Y_1612 MG1_X_8601_Y_1680 39.79m
R_MG1_seg_1899 MG1_X_8601_Y_1680 MG1_X_8601_Y_2150 278.5m
R_MG1_seg_1900 MG1_X_8601_Y_2150 MG1_X_8601_Y_2240 53.05m
R_MG1_seg_1901 MG1_X_8601_Y_2240 MG1_X_8601_Y_2688 265.3m
R_MG1_seg_1902 MG1_X_8601_Y_2688 MG1_X_8601_Y_2800 66.31m
R_MG1_seg_1903 MG1_X_8601_Y_2800 MG1_X_8601_Y_3225 252m
R_MG1_seg_1904 MG1_X_8601_Y_3225 MG1_X_8601_Y_3360 79.58m
R_MG1_seg_1905 MG1_X_8601_Y_3360 MG1_X_8601_Y_3763 238.7m
R_MG1_seg_1906 MG1_X_8601_Y_3763 MG1_X_8601_Y_3920 92.84m
R_MG1_seg_1907 MG1_X_8601_Y_3920 MG1_X_8601_Y_4300 225.5m
R_MG1_seg_1908 MG1_X_8601_Y_4300 MG1_X_8601_Y_4480 106.1m
R_MG1_seg_1909 MG1_X_8601_Y_4480 MG1_X_8601_Y_4838 212.2m
R_MG1_seg_1910 MG1_X_8601_Y_4838 MG1_X_8601_Y_5040 119.4m
R_MG1_seg_1911 MG1_X_8601_Y_5040 MG1_X_8601_Y_5376 198.9m
R_MG1_seg_1912 MG1_X_8601_Y_5376 MG1_X_8601_Y_5600 132.6m
R_MG1_seg_1913 MG1_X_8601_Y_5600 MG1_X_8601_Y_5913 185.7m
R_MG1_seg_1914 MG1_X_8601_Y_5913 MG1_X_8601_Y_6160 145.9m
R_MG1_seg_1915 MG1_X_8601_Y_6160 MG1_X_8601_Y_6451 172.4m
R_MG1_seg_1916 MG1_X_8601_Y_6451 MG1_X_8601_Y_6720 159.2m
R_MG1_seg_1917 MG1_X_8601_Y_6720 MG1_X_8601_Y_6988 159.2m
R_MG1_seg_1918 MG1_X_8601_Y_6988 MG1_X_8601_Y_7280 172.4m
R_MG1_seg_1919 MG1_X_8601_Y_7280 MG1_X_8601_Y_7526 145.9m
R_MG1_seg_1920 MG1_X_8601_Y_7526 MG1_X_8601_Y_7840 185.7m
R_MG1_seg_1921 MG1_X_8601_Y_7840 MG1_X_8601_Y_8064 132.6m
R_MG1_seg_1922 MG1_X_8601_Y_8064 MG1_X_8601_Y_8400 198.9m
R_MG1_seg_1923 MG1_X_8601_Y_8400 MG1_X_8601_Y_8601 119.4m
R_MG1_seg_1924 MG1_X_8601_Y_8601 MG1_X_8601_Y_8960 212.2m
R_MG1_seg_1925 MG1_X_8601_Y_8960 MG1_X_8601_Y_9139 106.1m
R_MG1_seg_1926 MG1_X_8601_Y_9139 MG1_X_8601_Y_9520 225.5m
R_MG1_seg_1927 MG1_X_8601_Y_9520 MG1_X_8601_Y_9676 92.84m
R_MG1_seg_1928 MG1_X_8601_Y_9676 MG1_X_8601_Y_10000 191.4m
R_MG1_seg_1929 MG1_X_8870_Y_0 MG1_X_8870_Y_268 159.2m
R_MG1_seg_1930 MG1_X_8870_Y_268 MG1_X_8870_Y_560 172.4m
R_MG1_seg_1931 MG1_X_8870_Y_560 MG1_X_8870_Y_806 145.9m
R_MG1_seg_1932 MG1_X_8870_Y_806 MG1_X_8870_Y_1120 185.7m
R_MG1_seg_1933 MG1_X_8870_Y_1120 MG1_X_8870_Y_1344 132.6m
R_MG1_seg_1934 MG1_X_8870_Y_1344 MG1_X_8870_Y_1680 198.9m
R_MG1_seg_1935 MG1_X_8870_Y_1680 MG1_X_8870_Y_1881 119.4m
R_MG1_seg_1936 MG1_X_8870_Y_1881 MG1_X_8870_Y_2240 212.2m
R_MG1_seg_1937 MG1_X_8870_Y_2240 MG1_X_8870_Y_2419 106.1m
R_MG1_seg_1938 MG1_X_8870_Y_2419 MG1_X_8870_Y_2800 225.5m
R_MG1_seg_1939 MG1_X_8870_Y_2800 MG1_X_8870_Y_2956 92.84m
R_MG1_seg_1940 MG1_X_8870_Y_2956 MG1_X_8870_Y_3360 238.7m
R_MG1_seg_1941 MG1_X_8870_Y_3360 MG1_X_8870_Y_3494 79.58m
R_MG1_seg_1942 MG1_X_8870_Y_3494 MG1_X_8870_Y_3920 252m
R_MG1_seg_1943 MG1_X_8870_Y_3920 MG1_X_8870_Y_4032 66.31m
R_MG1_seg_1944 MG1_X_8870_Y_4032 MG1_X_8870_Y_4480 265.3m
R_MG1_seg_1945 MG1_X_8870_Y_4480 MG1_X_8870_Y_4569 53.05m
R_MG1_seg_1946 MG1_X_8870_Y_4569 MG1_X_8870_Y_5040 278.5m
R_MG1_seg_1947 MG1_X_8870_Y_5040 MG1_X_8870_Y_5107 39.79m
R_MG1_seg_1948 MG1_X_8870_Y_5107 MG1_X_8870_Y_5600 291.8m
R_MG1_seg_1949 MG1_X_8870_Y_5600 MG1_X_8870_Y_5644 26.53m
R_MG1_seg_1950 MG1_X_8870_Y_5644 MG1_X_8870_Y_6160 305m
R_MG1_seg_1951 MG1_X_8870_Y_6160 MG1_X_8870_Y_6182 13.26m
R_MG1_seg_1952 MG1_X_8870_Y_6182 MG1_X_8870_Y_6720 318.3m
R_MG1_seg_1953 MG1_X_8870_Y_6720 MG1_X_8870_Y_7257 318.3m
R_MG1_seg_1954 MG1_X_8870_Y_7257 MG1_X_8870_Y_7280 13.26m
R_MG1_seg_1955 MG1_X_8870_Y_7280 MG1_X_8870_Y_7795 305m
R_MG1_seg_1956 MG1_X_8870_Y_7795 MG1_X_8870_Y_7840 26.53m
R_MG1_seg_1957 MG1_X_8870_Y_7840 MG1_X_8870_Y_8332 291.8m
R_MG1_seg_1958 MG1_X_8870_Y_8332 MG1_X_8870_Y_8400 39.79m
R_MG1_seg_1959 MG1_X_8870_Y_8400 MG1_X_8870_Y_8870 278.5m
R_MG1_seg_1960 MG1_X_8870_Y_8870 MG1_X_8870_Y_8960 53.05m
R_MG1_seg_1961 MG1_X_8870_Y_8960 MG1_X_8870_Y_9408 265.3m
R_MG1_seg_1962 MG1_X_8870_Y_9408 MG1_X_8870_Y_9520 66.31m
R_MG1_seg_1963 MG1_X_8870_Y_9520 MG1_X_8870_Y_9945 252m
R_MG1_seg_1964 MG1_X_8870_Y_9945 MG1_X_8870_Y_10000 32.21m
R_MG1_seg_1965 MG1_X_9139_Y_0 MG1_X_9139_Y_537 318.3m
R_MG1_seg_1966 MG1_X_9139_Y_537 MG1_X_9139_Y_560 13.26m
R_MG1_seg_1967 MG1_X_9139_Y_560 MG1_X_9139_Y_1075 305m
R_MG1_seg_1968 MG1_X_9139_Y_1075 MG1_X_9139_Y_1120 26.53m
R_MG1_seg_1969 MG1_X_9139_Y_1120 MG1_X_9139_Y_1612 291.8m
R_MG1_seg_1970 MG1_X_9139_Y_1612 MG1_X_9139_Y_1680 39.79m
R_MG1_seg_1971 MG1_X_9139_Y_1680 MG1_X_9139_Y_2150 278.5m
R_MG1_seg_1972 MG1_X_9139_Y_2150 MG1_X_9139_Y_2240 53.05m
R_MG1_seg_1973 MG1_X_9139_Y_2240 MG1_X_9139_Y_2688 265.3m
R_MG1_seg_1974 MG1_X_9139_Y_2688 MG1_X_9139_Y_2800 66.31m
R_MG1_seg_1975 MG1_X_9139_Y_2800 MG1_X_9139_Y_3225 252m
R_MG1_seg_1976 MG1_X_9139_Y_3225 MG1_X_9139_Y_3360 79.58m
R_MG1_seg_1977 MG1_X_9139_Y_3360 MG1_X_9139_Y_3763 238.7m
R_MG1_seg_1978 MG1_X_9139_Y_3763 MG1_X_9139_Y_3920 92.84m
R_MG1_seg_1979 MG1_X_9139_Y_3920 MG1_X_9139_Y_4300 225.5m
R_MG1_seg_1980 MG1_X_9139_Y_4300 MG1_X_9139_Y_4480 106.1m
R_MG1_seg_1981 MG1_X_9139_Y_4480 MG1_X_9139_Y_4838 212.2m
R_MG1_seg_1982 MG1_X_9139_Y_4838 MG1_X_9139_Y_5040 119.4m
R_MG1_seg_1983 MG1_X_9139_Y_5040 MG1_X_9139_Y_5376 198.9m
R_MG1_seg_1984 MG1_X_9139_Y_5376 MG1_X_9139_Y_5600 132.6m
R_MG1_seg_1985 MG1_X_9139_Y_5600 MG1_X_9139_Y_5913 185.7m
R_MG1_seg_1986 MG1_X_9139_Y_5913 MG1_X_9139_Y_6160 145.9m
R_MG1_seg_1987 MG1_X_9139_Y_6160 MG1_X_9139_Y_6451 172.4m
R_MG1_seg_1988 MG1_X_9139_Y_6451 MG1_X_9139_Y_6720 159.2m
R_MG1_seg_1989 MG1_X_9139_Y_6720 MG1_X_9139_Y_6988 159.2m
R_MG1_seg_1990 MG1_X_9139_Y_6988 MG1_X_9139_Y_7280 172.4m
R_MG1_seg_1991 MG1_X_9139_Y_7280 MG1_X_9139_Y_7526 145.9m
R_MG1_seg_1992 MG1_X_9139_Y_7526 MG1_X_9139_Y_7840 185.7m
R_MG1_seg_1993 MG1_X_9139_Y_7840 MG1_X_9139_Y_8064 132.6m
R_MG1_seg_1994 MG1_X_9139_Y_8064 MG1_X_9139_Y_8400 198.9m
R_MG1_seg_1995 MG1_X_9139_Y_8400 MG1_X_9139_Y_8601 119.4m
R_MG1_seg_1996 MG1_X_9139_Y_8601 MG1_X_9139_Y_8960 212.2m
R_MG1_seg_1997 MG1_X_9139_Y_8960 MG1_X_9139_Y_9139 106.1m
R_MG1_seg_1998 MG1_X_9139_Y_9139 MG1_X_9139_Y_9520 225.5m
R_MG1_seg_1999 MG1_X_9139_Y_9520 MG1_X_9139_Y_9676 92.84m
R_MG1_seg_2000 MG1_X_9139_Y_9676 MG1_X_9139_Y_10000 191.4m
R_MG1_seg_2001 MG1_X_9408_Y_0 MG1_X_9408_Y_268 159.2m
R_MG1_seg_2002 MG1_X_9408_Y_268 MG1_X_9408_Y_560 172.4m
R_MG1_seg_2003 MG1_X_9408_Y_560 MG1_X_9408_Y_806 145.9m
R_MG1_seg_2004 MG1_X_9408_Y_806 MG1_X_9408_Y_1120 185.7m
R_MG1_seg_2005 MG1_X_9408_Y_1120 MG1_X_9408_Y_1344 132.6m
R_MG1_seg_2006 MG1_X_9408_Y_1344 MG1_X_9408_Y_1680 198.9m
R_MG1_seg_2007 MG1_X_9408_Y_1680 MG1_X_9408_Y_1881 119.4m
R_MG1_seg_2008 MG1_X_9408_Y_1881 MG1_X_9408_Y_2240 212.2m
R_MG1_seg_2009 MG1_X_9408_Y_2240 MG1_X_9408_Y_2419 106.1m
R_MG1_seg_2010 MG1_X_9408_Y_2419 MG1_X_9408_Y_2800 225.5m
R_MG1_seg_2011 MG1_X_9408_Y_2800 MG1_X_9408_Y_2956 92.84m
R_MG1_seg_2012 MG1_X_9408_Y_2956 MG1_X_9408_Y_3360 238.7m
R_MG1_seg_2013 MG1_X_9408_Y_3360 MG1_X_9408_Y_3494 79.58m
R_MG1_seg_2014 MG1_X_9408_Y_3494 MG1_X_9408_Y_3920 252m
R_MG1_seg_2015 MG1_X_9408_Y_3920 MG1_X_9408_Y_4032 66.31m
R_MG1_seg_2016 MG1_X_9408_Y_4032 MG1_X_9408_Y_4480 265.3m
R_MG1_seg_2017 MG1_X_9408_Y_4480 MG1_X_9408_Y_4569 53.05m
R_MG1_seg_2018 MG1_X_9408_Y_4569 MG1_X_9408_Y_5040 278.5m
R_MG1_seg_2019 MG1_X_9408_Y_5040 MG1_X_9408_Y_5107 39.79m
R_MG1_seg_2020 MG1_X_9408_Y_5107 MG1_X_9408_Y_5600 291.8m
R_MG1_seg_2021 MG1_X_9408_Y_5600 MG1_X_9408_Y_5644 26.53m
R_MG1_seg_2022 MG1_X_9408_Y_5644 MG1_X_9408_Y_6160 305m
R_MG1_seg_2023 MG1_X_9408_Y_6160 MG1_X_9408_Y_6182 13.26m
R_MG1_seg_2024 MG1_X_9408_Y_6182 MG1_X_9408_Y_6720 318.3m
R_MG1_seg_2025 MG1_X_9408_Y_6720 MG1_X_9408_Y_7257 318.3m
R_MG1_seg_2026 MG1_X_9408_Y_7257 MG1_X_9408_Y_7280 13.26m
R_MG1_seg_2027 MG1_X_9408_Y_7280 MG1_X_9408_Y_7795 305m
R_MG1_seg_2028 MG1_X_9408_Y_7795 MG1_X_9408_Y_7840 26.53m
R_MG1_seg_2029 MG1_X_9408_Y_7840 MG1_X_9408_Y_8332 291.8m
R_MG1_seg_2030 MG1_X_9408_Y_8332 MG1_X_9408_Y_8400 39.79m
R_MG1_seg_2031 MG1_X_9408_Y_8400 MG1_X_9408_Y_8870 278.5m
R_MG1_seg_2032 MG1_X_9408_Y_8870 MG1_X_9408_Y_8960 53.05m
R_MG1_seg_2033 MG1_X_9408_Y_8960 MG1_X_9408_Y_9408 265.3m
R_MG1_seg_2034 MG1_X_9408_Y_9408 MG1_X_9408_Y_9520 66.31m
R_MG1_seg_2035 MG1_X_9408_Y_9520 MG1_X_9408_Y_9945 252m
R_MG1_seg_2036 MG1_X_9408_Y_9945 MG1_X_9408_Y_10000 32.21m
R_MG1_seg_2037 MG1_X_9676_Y_0 MG1_X_9676_Y_537 318.3m
R_MG1_seg_2038 MG1_X_9676_Y_537 MG1_X_9676_Y_560 13.26m
R_MG1_seg_2039 MG1_X_9676_Y_560 MG1_X_9676_Y_1075 305m
R_MG1_seg_2040 MG1_X_9676_Y_1075 MG1_X_9676_Y_1120 26.53m
R_MG1_seg_2041 MG1_X_9676_Y_1120 MG1_X_9676_Y_1612 291.8m
R_MG1_seg_2042 MG1_X_9676_Y_1612 MG1_X_9676_Y_1680 39.79m
R_MG1_seg_2043 MG1_X_9676_Y_1680 MG1_X_9676_Y_2150 278.5m
R_MG1_seg_2044 MG1_X_9676_Y_2150 MG1_X_9676_Y_2240 53.05m
R_MG1_seg_2045 MG1_X_9676_Y_2240 MG1_X_9676_Y_2688 265.3m
R_MG1_seg_2046 MG1_X_9676_Y_2688 MG1_X_9676_Y_2800 66.31m
R_MG1_seg_2047 MG1_X_9676_Y_2800 MG1_X_9676_Y_3225 252m
R_MG1_seg_2048 MG1_X_9676_Y_3225 MG1_X_9676_Y_3360 79.58m
R_MG1_seg_2049 MG1_X_9676_Y_3360 MG1_X_9676_Y_3763 238.7m
R_MG1_seg_2050 MG1_X_9676_Y_3763 MG1_X_9676_Y_3920 92.84m
R_MG1_seg_2051 MG1_X_9676_Y_3920 MG1_X_9676_Y_4300 225.5m
R_MG1_seg_2052 MG1_X_9676_Y_4300 MG1_X_9676_Y_4480 106.1m
R_MG1_seg_2053 MG1_X_9676_Y_4480 MG1_X_9676_Y_4838 212.2m
R_MG1_seg_2054 MG1_X_9676_Y_4838 MG1_X_9676_Y_5040 119.4m
R_MG1_seg_2055 MG1_X_9676_Y_5040 MG1_X_9676_Y_5376 198.9m
R_MG1_seg_2056 MG1_X_9676_Y_5376 MG1_X_9676_Y_5600 132.6m
R_MG1_seg_2057 MG1_X_9676_Y_5600 MG1_X_9676_Y_5913 185.7m
R_MG1_seg_2058 MG1_X_9676_Y_5913 MG1_X_9676_Y_6160 145.9m
R_MG1_seg_2059 MG1_X_9676_Y_6160 MG1_X_9676_Y_6451 172.4m
R_MG1_seg_2060 MG1_X_9676_Y_6451 MG1_X_9676_Y_6720 159.2m
R_MG1_seg_2061 MG1_X_9676_Y_6720 MG1_X_9676_Y_6988 159.2m
R_MG1_seg_2062 MG1_X_9676_Y_6988 MG1_X_9676_Y_7280 172.4m
R_MG1_seg_2063 MG1_X_9676_Y_7280 MG1_X_9676_Y_7526 145.9m
R_MG1_seg_2064 MG1_X_9676_Y_7526 MG1_X_9676_Y_7840 185.7m
R_MG1_seg_2065 MG1_X_9676_Y_7840 MG1_X_9676_Y_8064 132.6m
R_MG1_seg_2066 MG1_X_9676_Y_8064 MG1_X_9676_Y_8400 198.9m
R_MG1_seg_2067 MG1_X_9676_Y_8400 MG1_X_9676_Y_8601 119.4m
R_MG1_seg_2068 MG1_X_9676_Y_8601 MG1_X_9676_Y_8960 212.2m
R_MG1_seg_2069 MG1_X_9676_Y_8960 MG1_X_9676_Y_9139 106.1m
R_MG1_seg_2070 MG1_X_9676_Y_9139 MG1_X_9676_Y_9520 225.5m
R_MG1_seg_2071 MG1_X_9676_Y_9520 MG1_X_9676_Y_9676 92.84m
R_MG1_seg_2072 MG1_X_9676_Y_9676 MG1_X_9676_Y_10000 191.4m
R_MG1_seg_2073 MG1_X_9945_Y_0 MG1_X_9945_Y_268 159.2m
R_MG1_seg_2074 MG1_X_9945_Y_268 MG1_X_9945_Y_560 172.4m
R_MG1_seg_2075 MG1_X_9945_Y_560 MG1_X_9945_Y_806 145.9m
R_MG1_seg_2076 MG1_X_9945_Y_806 MG1_X_9945_Y_1120 185.7m
R_MG1_seg_2077 MG1_X_9945_Y_1120 MG1_X_9945_Y_1344 132.6m
R_MG1_seg_2078 MG1_X_9945_Y_1344 MG1_X_9945_Y_1680 198.9m
R_MG1_seg_2079 MG1_X_9945_Y_1680 MG1_X_9945_Y_1881 119.4m
R_MG1_seg_2080 MG1_X_9945_Y_1881 MG1_X_9945_Y_2240 212.2m
R_MG1_seg_2081 MG1_X_9945_Y_2240 MG1_X_9945_Y_2419 106.1m
R_MG1_seg_2082 MG1_X_9945_Y_2419 MG1_X_9945_Y_2800 225.5m
R_MG1_seg_2083 MG1_X_9945_Y_2800 MG1_X_9945_Y_2956 92.84m
R_MG1_seg_2084 MG1_X_9945_Y_2956 MG1_X_9945_Y_3360 238.7m
R_MG1_seg_2085 MG1_X_9945_Y_3360 MG1_X_9945_Y_3494 79.58m
R_MG1_seg_2086 MG1_X_9945_Y_3494 MG1_X_9945_Y_3920 252m
R_MG1_seg_2087 MG1_X_9945_Y_3920 MG1_X_9945_Y_4032 66.31m
R_MG1_seg_2088 MG1_X_9945_Y_4032 MG1_X_9945_Y_4480 265.3m
R_MG1_seg_2089 MG1_X_9945_Y_4480 MG1_X_9945_Y_4569 53.05m
R_MG1_seg_2090 MG1_X_9945_Y_4569 MG1_X_9945_Y_5040 278.5m
R_MG1_seg_2091 MG1_X_9945_Y_5040 MG1_X_9945_Y_5107 39.79m
R_MG1_seg_2092 MG1_X_9945_Y_5107 MG1_X_9945_Y_5600 291.8m
R_MG1_seg_2093 MG1_X_9945_Y_5600 MG1_X_9945_Y_5644 26.53m
R_MG1_seg_2094 MG1_X_9945_Y_5644 MG1_X_9945_Y_6160 305m
R_MG1_seg_2095 MG1_X_9945_Y_6160 MG1_X_9945_Y_6182 13.26m
R_MG1_seg_2096 MG1_X_9945_Y_6182 MG1_X_9945_Y_6720 318.3m
R_MG1_seg_2097 MG1_X_9945_Y_6720 MG1_X_9945_Y_7257 318.3m
R_MG1_seg_2098 MG1_X_9945_Y_7257 MG1_X_9945_Y_7280 13.26m
R_MG1_seg_2099 MG1_X_9945_Y_7280 MG1_X_9945_Y_7795 305m
R_MG1_seg_2100 MG1_X_9945_Y_7795 MG1_X_9945_Y_7840 26.53m
R_MG1_seg_2101 MG1_X_9945_Y_7840 MG1_X_9945_Y_8332 291.8m
R_MG1_seg_2102 MG1_X_9945_Y_8332 MG1_X_9945_Y_8400 39.79m
R_MG1_seg_2103 MG1_X_9945_Y_8400 MG1_X_9945_Y_8870 278.5m
R_MG1_seg_2104 MG1_X_9945_Y_8870 MG1_X_9945_Y_8960 53.05m
R_MG1_seg_2105 MG1_X_9945_Y_8960 MG1_X_9945_Y_9408 265.3m
R_MG1_seg_2106 MG1_X_9945_Y_9408 MG1_X_9945_Y_9520 66.31m
R_MG1_seg_2107 MG1_X_9945_Y_9520 MG1_X_9945_Y_9945 252m
R_MG1_seg_2108 MG1_X_9945_Y_9945 MG1_X_9945_Y_10000 32.21m
* Layer: MSMG1
R_MSMG1_seg_2109 MSMG1_X_0_Y_0 MSMG1_X_560_Y_0 1.326
R_MSMG1_seg_2110 MSMG1_X_560_Y_0 MSMG1_X_640_Y_0 189.5m
R_MSMG1_seg_2111 MSMG1_X_640_Y_0 MSMG1_X_1120_Y_0 1.137
R_MSMG1_seg_2112 MSMG1_X_1120_Y_0 MSMG1_X_1280_Y_0 378.9m
R_MSMG1_seg_2113 MSMG1_X_1280_Y_0 MSMG1_X_1680_Y_0 947.3m
R_MSMG1_seg_2114 MSMG1_X_1680_Y_0 MSMG1_X_1920_Y_0 568.4m
R_MSMG1_seg_2115 MSMG1_X_1920_Y_0 MSMG1_X_2240_Y_0 757.9m
R_MSMG1_seg_2116 MSMG1_X_2240_Y_0 MSMG1_X_2560_Y_0 757.9m
R_MSMG1_seg_2117 MSMG1_X_2560_Y_0 MSMG1_X_2800_Y_0 568.4m
R_MSMG1_seg_2118 MSMG1_X_2800_Y_0 MSMG1_X_3200_Y_0 947.3m
R_MSMG1_seg_2119 MSMG1_X_3200_Y_0 MSMG1_X_3360_Y_0 378.9m
R_MSMG1_seg_2120 MSMG1_X_3360_Y_0 MSMG1_X_3840_Y_0 1.137
R_MSMG1_seg_2121 MSMG1_X_3840_Y_0 MSMG1_X_3920_Y_0 189.5m
R_MSMG1_seg_2122 MSMG1_X_3920_Y_0 MSMG1_X_4480_Y_0 1.326
R_MSMG1_seg_2123 MSMG1_X_4480_Y_0 MSMG1_X_5040_Y_0 1.326
R_MSMG1_seg_2124 MSMG1_X_5040_Y_0 MSMG1_X_5120_Y_0 189.5m
R_MSMG1_seg_2125 MSMG1_X_5120_Y_0 MSMG1_X_5600_Y_0 1.137
R_MSMG1_seg_2126 MSMG1_X_5600_Y_0 MSMG1_X_5760_Y_0 378.9m
R_MSMG1_seg_2127 MSMG1_X_5760_Y_0 MSMG1_X_6160_Y_0 947.3m
R_MSMG1_seg_2128 MSMG1_X_6160_Y_0 MSMG1_X_6400_Y_0 568.4m
R_MSMG1_seg_2129 MSMG1_X_6400_Y_0 MSMG1_X_6720_Y_0 757.9m
R_MSMG1_seg_2130 MSMG1_X_6720_Y_0 MSMG1_X_7040_Y_0 757.9m
R_MSMG1_seg_2131 MSMG1_X_7040_Y_0 MSMG1_X_7280_Y_0 568.4m
R_MSMG1_seg_2132 MSMG1_X_7280_Y_0 MSMG1_X_7680_Y_0 947.3m
R_MSMG1_seg_2133 MSMG1_X_7680_Y_0 MSMG1_X_7840_Y_0 378.9m
R_MSMG1_seg_2134 MSMG1_X_7840_Y_0 MSMG1_X_8320_Y_0 1.137
R_MSMG1_seg_2135 MSMG1_X_8320_Y_0 MSMG1_X_8400_Y_0 189.5m
R_MSMG1_seg_2136 MSMG1_X_8400_Y_0 MSMG1_X_8960_Y_0 1.326
R_MSMG1_seg_2137 MSMG1_X_8960_Y_0 MSMG1_X_9520_Y_0 1.326
R_MSMG1_seg_2138 MSMG1_X_9520_Y_0 MSMG1_X_9600_Y_0 189.5m
R_MSMG1_seg_2139 MSMG1_X_9600_Y_0 MSMG1_X_10000_Y_0 947.3m
R_MSMG1_seg_2140 MSMG1_X_0_Y_560 MSMG1_X_320_Y_560 757.9m
R_MSMG1_seg_2141 MSMG1_X_320_Y_560 MSMG1_X_560_Y_560 568.4m
R_MSMG1_seg_2142 MSMG1_X_560_Y_560 MSMG1_X_960_Y_560 947.3m
R_MSMG1_seg_2143 MSMG1_X_960_Y_560 MSMG1_X_1120_Y_560 378.9m
R_MSMG1_seg_2144 MSMG1_X_1120_Y_560 MSMG1_X_1600_Y_560 1.137
R_MSMG1_seg_2145 MSMG1_X_1600_Y_560 MSMG1_X_1680_Y_560 189.5m
R_MSMG1_seg_2146 MSMG1_X_1680_Y_560 MSMG1_X_2240_Y_560 1.326
R_MSMG1_seg_2147 MSMG1_X_2240_Y_560 MSMG1_X_2800_Y_560 1.326
R_MSMG1_seg_2148 MSMG1_X_2800_Y_560 MSMG1_X_2880_Y_560 189.5m
R_MSMG1_seg_2149 MSMG1_X_2880_Y_560 MSMG1_X_3360_Y_560 1.137
R_MSMG1_seg_2150 MSMG1_X_3360_Y_560 MSMG1_X_3520_Y_560 378.9m
R_MSMG1_seg_2151 MSMG1_X_3520_Y_560 MSMG1_X_3920_Y_560 947.3m
R_MSMG1_seg_2152 MSMG1_X_3920_Y_560 MSMG1_X_4160_Y_560 568.4m
R_MSMG1_seg_2153 MSMG1_X_4160_Y_560 MSMG1_X_4480_Y_560 757.9m
R_MSMG1_seg_2154 MSMG1_X_4480_Y_560 MSMG1_X_4800_Y_560 757.9m
R_MSMG1_seg_2155 MSMG1_X_4800_Y_560 MSMG1_X_5040_Y_560 568.4m
R_MSMG1_seg_2156 MSMG1_X_5040_Y_560 MSMG1_X_5440_Y_560 947.3m
R_MSMG1_seg_2157 MSMG1_X_5440_Y_560 MSMG1_X_5600_Y_560 378.9m
R_MSMG1_seg_2158 MSMG1_X_5600_Y_560 MSMG1_X_6080_Y_560 1.137
R_MSMG1_seg_2159 MSMG1_X_6080_Y_560 MSMG1_X_6160_Y_560 189.5m
R_MSMG1_seg_2160 MSMG1_X_6160_Y_560 MSMG1_X_6720_Y_560 1.326
R_MSMG1_seg_2161 MSMG1_X_6720_Y_560 MSMG1_X_7280_Y_560 1.326
R_MSMG1_seg_2162 MSMG1_X_7280_Y_560 MSMG1_X_7360_Y_560 189.5m
R_MSMG1_seg_2163 MSMG1_X_7360_Y_560 MSMG1_X_7840_Y_560 1.137
R_MSMG1_seg_2164 MSMG1_X_7840_Y_560 MSMG1_X_8000_Y_560 378.9m
R_MSMG1_seg_2165 MSMG1_X_8000_Y_560 MSMG1_X_8400_Y_560 947.3m
R_MSMG1_seg_2166 MSMG1_X_8400_Y_560 MSMG1_X_8640_Y_560 568.4m
R_MSMG1_seg_2167 MSMG1_X_8640_Y_560 MSMG1_X_8960_Y_560 757.9m
R_MSMG1_seg_2168 MSMG1_X_8960_Y_560 MSMG1_X_9280_Y_560 757.9m
R_MSMG1_seg_2169 MSMG1_X_9280_Y_560 MSMG1_X_9520_Y_560 568.4m
R_MSMG1_seg_2170 MSMG1_X_9520_Y_560 MSMG1_X_9920_Y_560 947.3m
R_MSMG1_seg_2171 MSMG1_X_9920_Y_560 MSMG1_X_10000_Y_560 189.5m
R_MSMG1_seg_2172 MSMG1_X_0_Y_1120 MSMG1_X_560_Y_1120 1.326
R_MSMG1_seg_2173 MSMG1_X_560_Y_1120 MSMG1_X_640_Y_1120 189.5m
R_MSMG1_seg_2174 MSMG1_X_640_Y_1120 MSMG1_X_1120_Y_1120 1.137
R_MSMG1_seg_2175 MSMG1_X_1120_Y_1120 MSMG1_X_1280_Y_1120 378.9m
R_MSMG1_seg_2176 MSMG1_X_1280_Y_1120 MSMG1_X_1680_Y_1120 947.3m
R_MSMG1_seg_2177 MSMG1_X_1680_Y_1120 MSMG1_X_1920_Y_1120 568.4m
R_MSMG1_seg_2178 MSMG1_X_1920_Y_1120 MSMG1_X_2240_Y_1120 757.9m
R_MSMG1_seg_2179 MSMG1_X_2240_Y_1120 MSMG1_X_2560_Y_1120 757.9m
R_MSMG1_seg_2180 MSMG1_X_2560_Y_1120 MSMG1_X_2800_Y_1120 568.4m
R_MSMG1_seg_2181 MSMG1_X_2800_Y_1120 MSMG1_X_3200_Y_1120 947.3m
R_MSMG1_seg_2182 MSMG1_X_3200_Y_1120 MSMG1_X_3360_Y_1120 378.9m
R_MSMG1_seg_2183 MSMG1_X_3360_Y_1120 MSMG1_X_3840_Y_1120 1.137
R_MSMG1_seg_2184 MSMG1_X_3840_Y_1120 MSMG1_X_3920_Y_1120 189.5m
R_MSMG1_seg_2185 MSMG1_X_3920_Y_1120 MSMG1_X_4480_Y_1120 1.326
R_MSMG1_seg_2186 MSMG1_X_4480_Y_1120 MSMG1_X_5040_Y_1120 1.326
R_MSMG1_seg_2187 MSMG1_X_5040_Y_1120 MSMG1_X_5120_Y_1120 189.5m
R_MSMG1_seg_2188 MSMG1_X_5120_Y_1120 MSMG1_X_5600_Y_1120 1.137
R_MSMG1_seg_2189 MSMG1_X_5600_Y_1120 MSMG1_X_5760_Y_1120 378.9m
R_MSMG1_seg_2190 MSMG1_X_5760_Y_1120 MSMG1_X_6160_Y_1120 947.3m
R_MSMG1_seg_2191 MSMG1_X_6160_Y_1120 MSMG1_X_6400_Y_1120 568.4m
R_MSMG1_seg_2192 MSMG1_X_6400_Y_1120 MSMG1_X_6720_Y_1120 757.9m
R_MSMG1_seg_2193 MSMG1_X_6720_Y_1120 MSMG1_X_7040_Y_1120 757.9m
R_MSMG1_seg_2194 MSMG1_X_7040_Y_1120 MSMG1_X_7280_Y_1120 568.4m
R_MSMG1_seg_2195 MSMG1_X_7280_Y_1120 MSMG1_X_7680_Y_1120 947.3m
R_MSMG1_seg_2196 MSMG1_X_7680_Y_1120 MSMG1_X_7840_Y_1120 378.9m
R_MSMG1_seg_2197 MSMG1_X_7840_Y_1120 MSMG1_X_8320_Y_1120 1.137
R_MSMG1_seg_2198 MSMG1_X_8320_Y_1120 MSMG1_X_8400_Y_1120 189.5m
R_MSMG1_seg_2199 MSMG1_X_8400_Y_1120 MSMG1_X_8960_Y_1120 1.326
R_MSMG1_seg_2200 MSMG1_X_8960_Y_1120 MSMG1_X_9520_Y_1120 1.326
R_MSMG1_seg_2201 MSMG1_X_9520_Y_1120 MSMG1_X_9600_Y_1120 189.5m
R_MSMG1_seg_2202 MSMG1_X_9600_Y_1120 MSMG1_X_10000_Y_1120 947.3m
R_MSMG1_seg_2203 MSMG1_X_0_Y_1680 MSMG1_X_320_Y_1680 757.9m
R_MSMG1_seg_2204 MSMG1_X_320_Y_1680 MSMG1_X_560_Y_1680 568.4m
R_MSMG1_seg_2205 MSMG1_X_560_Y_1680 MSMG1_X_960_Y_1680 947.3m
R_MSMG1_seg_2206 MSMG1_X_960_Y_1680 MSMG1_X_1120_Y_1680 378.9m
R_MSMG1_seg_2207 MSMG1_X_1120_Y_1680 MSMG1_X_1600_Y_1680 1.137
R_MSMG1_seg_2208 MSMG1_X_1600_Y_1680 MSMG1_X_1680_Y_1680 189.5m
R_MSMG1_seg_2209 MSMG1_X_1680_Y_1680 MSMG1_X_2240_Y_1680 1.326
R_MSMG1_seg_2210 MSMG1_X_2240_Y_1680 MSMG1_X_2800_Y_1680 1.326
R_MSMG1_seg_2211 MSMG1_X_2800_Y_1680 MSMG1_X_2880_Y_1680 189.5m
R_MSMG1_seg_2212 MSMG1_X_2880_Y_1680 MSMG1_X_3360_Y_1680 1.137
R_MSMG1_seg_2213 MSMG1_X_3360_Y_1680 MSMG1_X_3520_Y_1680 378.9m
R_MSMG1_seg_2214 MSMG1_X_3520_Y_1680 MSMG1_X_3920_Y_1680 947.3m
R_MSMG1_seg_2215 MSMG1_X_3920_Y_1680 MSMG1_X_4160_Y_1680 568.4m
R_MSMG1_seg_2216 MSMG1_X_4160_Y_1680 MSMG1_X_4480_Y_1680 757.9m
R_MSMG1_seg_2217 MSMG1_X_4480_Y_1680 MSMG1_X_4800_Y_1680 757.9m
R_MSMG1_seg_2218 MSMG1_X_4800_Y_1680 MSMG1_X_5040_Y_1680 568.4m
R_MSMG1_seg_2219 MSMG1_X_5040_Y_1680 MSMG1_X_5440_Y_1680 947.3m
R_MSMG1_seg_2220 MSMG1_X_5440_Y_1680 MSMG1_X_5600_Y_1680 378.9m
R_MSMG1_seg_2221 MSMG1_X_5600_Y_1680 MSMG1_X_6080_Y_1680 1.137
R_MSMG1_seg_2222 MSMG1_X_6080_Y_1680 MSMG1_X_6160_Y_1680 189.5m
R_MSMG1_seg_2223 MSMG1_X_6160_Y_1680 MSMG1_X_6720_Y_1680 1.326
R_MSMG1_seg_2224 MSMG1_X_6720_Y_1680 MSMG1_X_7280_Y_1680 1.326
R_MSMG1_seg_2225 MSMG1_X_7280_Y_1680 MSMG1_X_7360_Y_1680 189.5m
R_MSMG1_seg_2226 MSMG1_X_7360_Y_1680 MSMG1_X_7840_Y_1680 1.137
R_MSMG1_seg_2227 MSMG1_X_7840_Y_1680 MSMG1_X_8000_Y_1680 378.9m
R_MSMG1_seg_2228 MSMG1_X_8000_Y_1680 MSMG1_X_8400_Y_1680 947.3m
R_MSMG1_seg_2229 MSMG1_X_8400_Y_1680 MSMG1_X_8640_Y_1680 568.4m
R_MSMG1_seg_2230 MSMG1_X_8640_Y_1680 MSMG1_X_8960_Y_1680 757.9m
R_MSMG1_seg_2231 MSMG1_X_8960_Y_1680 MSMG1_X_9280_Y_1680 757.9m
R_MSMG1_seg_2232 MSMG1_X_9280_Y_1680 MSMG1_X_9520_Y_1680 568.4m
R_MSMG1_seg_2233 MSMG1_X_9520_Y_1680 MSMG1_X_9920_Y_1680 947.3m
R_MSMG1_seg_2234 MSMG1_X_9920_Y_1680 MSMG1_X_10000_Y_1680 189.5m
R_MSMG1_seg_2235 MSMG1_X_0_Y_2240 MSMG1_X_560_Y_2240 1.326
R_MSMG1_seg_2236 MSMG1_X_560_Y_2240 MSMG1_X_640_Y_2240 189.5m
R_MSMG1_seg_2237 MSMG1_X_640_Y_2240 MSMG1_X_1120_Y_2240 1.137
R_MSMG1_seg_2238 MSMG1_X_1120_Y_2240 MSMG1_X_1280_Y_2240 378.9m
R_MSMG1_seg_2239 MSMG1_X_1280_Y_2240 MSMG1_X_1680_Y_2240 947.3m
R_MSMG1_seg_2240 MSMG1_X_1680_Y_2240 MSMG1_X_1920_Y_2240 568.4m
R_MSMG1_seg_2241 MSMG1_X_1920_Y_2240 MSMG1_X_2240_Y_2240 757.9m
R_MSMG1_seg_2242 MSMG1_X_2240_Y_2240 MSMG1_X_2560_Y_2240 757.9m
R_MSMG1_seg_2243 MSMG1_X_2560_Y_2240 MSMG1_X_2800_Y_2240 568.4m
R_MSMG1_seg_2244 MSMG1_X_2800_Y_2240 MSMG1_X_3200_Y_2240 947.3m
R_MSMG1_seg_2245 MSMG1_X_3200_Y_2240 MSMG1_X_3360_Y_2240 378.9m
R_MSMG1_seg_2246 MSMG1_X_3360_Y_2240 MSMG1_X_3840_Y_2240 1.137
R_MSMG1_seg_2247 MSMG1_X_3840_Y_2240 MSMG1_X_3920_Y_2240 189.5m
R_MSMG1_seg_2248 MSMG1_X_3920_Y_2240 MSMG1_X_4480_Y_2240 1.326
R_MSMG1_seg_2249 MSMG1_X_4480_Y_2240 MSMG1_X_5040_Y_2240 1.326
R_MSMG1_seg_2250 MSMG1_X_5040_Y_2240 MSMG1_X_5120_Y_2240 189.5m
R_MSMG1_seg_2251 MSMG1_X_5120_Y_2240 MSMG1_X_5600_Y_2240 1.137
R_MSMG1_seg_2252 MSMG1_X_5600_Y_2240 MSMG1_X_5760_Y_2240 378.9m
R_MSMG1_seg_2253 MSMG1_X_5760_Y_2240 MSMG1_X_6160_Y_2240 947.3m
R_MSMG1_seg_2254 MSMG1_X_6160_Y_2240 MSMG1_X_6400_Y_2240 568.4m
R_MSMG1_seg_2255 MSMG1_X_6400_Y_2240 MSMG1_X_6720_Y_2240 757.9m
R_MSMG1_seg_2256 MSMG1_X_6720_Y_2240 MSMG1_X_7040_Y_2240 757.9m
R_MSMG1_seg_2257 MSMG1_X_7040_Y_2240 MSMG1_X_7280_Y_2240 568.4m
R_MSMG1_seg_2258 MSMG1_X_7280_Y_2240 MSMG1_X_7680_Y_2240 947.3m
R_MSMG1_seg_2259 MSMG1_X_7680_Y_2240 MSMG1_X_7840_Y_2240 378.9m
R_MSMG1_seg_2260 MSMG1_X_7840_Y_2240 MSMG1_X_8320_Y_2240 1.137
R_MSMG1_seg_2261 MSMG1_X_8320_Y_2240 MSMG1_X_8400_Y_2240 189.5m
R_MSMG1_seg_2262 MSMG1_X_8400_Y_2240 MSMG1_X_8960_Y_2240 1.326
R_MSMG1_seg_2263 MSMG1_X_8960_Y_2240 MSMG1_X_9520_Y_2240 1.326
R_MSMG1_seg_2264 MSMG1_X_9520_Y_2240 MSMG1_X_9600_Y_2240 189.5m
R_MSMG1_seg_2265 MSMG1_X_9600_Y_2240 MSMG1_X_10000_Y_2240 947.3m
R_MSMG1_seg_2266 MSMG1_X_0_Y_2800 MSMG1_X_320_Y_2800 757.9m
R_MSMG1_seg_2267 MSMG1_X_320_Y_2800 MSMG1_X_560_Y_2800 568.4m
R_MSMG1_seg_2268 MSMG1_X_560_Y_2800 MSMG1_X_960_Y_2800 947.3m
R_MSMG1_seg_2269 MSMG1_X_960_Y_2800 MSMG1_X_1120_Y_2800 378.9m
R_MSMG1_seg_2270 MSMG1_X_1120_Y_2800 MSMG1_X_1600_Y_2800 1.137
R_MSMG1_seg_2271 MSMG1_X_1600_Y_2800 MSMG1_X_1680_Y_2800 189.5m
R_MSMG1_seg_2272 MSMG1_X_1680_Y_2800 MSMG1_X_2240_Y_2800 1.326
R_MSMG1_seg_2273 MSMG1_X_2240_Y_2800 MSMG1_X_2800_Y_2800 1.326
R_MSMG1_seg_2274 MSMG1_X_2800_Y_2800 MSMG1_X_2880_Y_2800 189.5m
R_MSMG1_seg_2275 MSMG1_X_2880_Y_2800 MSMG1_X_3360_Y_2800 1.137
R_MSMG1_seg_2276 MSMG1_X_3360_Y_2800 MSMG1_X_3520_Y_2800 378.9m
R_MSMG1_seg_2277 MSMG1_X_3520_Y_2800 MSMG1_X_3920_Y_2800 947.3m
R_MSMG1_seg_2278 MSMG1_X_3920_Y_2800 MSMG1_X_4160_Y_2800 568.4m
R_MSMG1_seg_2279 MSMG1_X_4160_Y_2800 MSMG1_X_4480_Y_2800 757.9m
R_MSMG1_seg_2280 MSMG1_X_4480_Y_2800 MSMG1_X_4800_Y_2800 757.9m
R_MSMG1_seg_2281 MSMG1_X_4800_Y_2800 MSMG1_X_5040_Y_2800 568.4m
R_MSMG1_seg_2282 MSMG1_X_5040_Y_2800 MSMG1_X_5440_Y_2800 947.3m
R_MSMG1_seg_2283 MSMG1_X_5440_Y_2800 MSMG1_X_5600_Y_2800 378.9m
R_MSMG1_seg_2284 MSMG1_X_5600_Y_2800 MSMG1_X_6080_Y_2800 1.137
R_MSMG1_seg_2285 MSMG1_X_6080_Y_2800 MSMG1_X_6160_Y_2800 189.5m
R_MSMG1_seg_2286 MSMG1_X_6160_Y_2800 MSMG1_X_6720_Y_2800 1.326
R_MSMG1_seg_2287 MSMG1_X_6720_Y_2800 MSMG1_X_7280_Y_2800 1.326
R_MSMG1_seg_2288 MSMG1_X_7280_Y_2800 MSMG1_X_7360_Y_2800 189.5m
R_MSMG1_seg_2289 MSMG1_X_7360_Y_2800 MSMG1_X_7840_Y_2800 1.137
R_MSMG1_seg_2290 MSMG1_X_7840_Y_2800 MSMG1_X_8000_Y_2800 378.9m
R_MSMG1_seg_2291 MSMG1_X_8000_Y_2800 MSMG1_X_8400_Y_2800 947.3m
R_MSMG1_seg_2292 MSMG1_X_8400_Y_2800 MSMG1_X_8640_Y_2800 568.4m
R_MSMG1_seg_2293 MSMG1_X_8640_Y_2800 MSMG1_X_8960_Y_2800 757.9m
R_MSMG1_seg_2294 MSMG1_X_8960_Y_2800 MSMG1_X_9280_Y_2800 757.9m
R_MSMG1_seg_2295 MSMG1_X_9280_Y_2800 MSMG1_X_9520_Y_2800 568.4m
R_MSMG1_seg_2296 MSMG1_X_9520_Y_2800 MSMG1_X_9920_Y_2800 947.3m
R_MSMG1_seg_2297 MSMG1_X_9920_Y_2800 MSMG1_X_10000_Y_2800 189.5m
R_MSMG1_seg_2298 MSMG1_X_0_Y_3360 MSMG1_X_560_Y_3360 1.326
R_MSMG1_seg_2299 MSMG1_X_560_Y_3360 MSMG1_X_640_Y_3360 189.5m
R_MSMG1_seg_2300 MSMG1_X_640_Y_3360 MSMG1_X_1120_Y_3360 1.137
R_MSMG1_seg_2301 MSMG1_X_1120_Y_3360 MSMG1_X_1280_Y_3360 378.9m
R_MSMG1_seg_2302 MSMG1_X_1280_Y_3360 MSMG1_X_1680_Y_3360 947.3m
R_MSMG1_seg_2303 MSMG1_X_1680_Y_3360 MSMG1_X_1920_Y_3360 568.4m
R_MSMG1_seg_2304 MSMG1_X_1920_Y_3360 MSMG1_X_2240_Y_3360 757.9m
R_MSMG1_seg_2305 MSMG1_X_2240_Y_3360 MSMG1_X_2560_Y_3360 757.9m
R_MSMG1_seg_2306 MSMG1_X_2560_Y_3360 MSMG1_X_2800_Y_3360 568.4m
R_MSMG1_seg_2307 MSMG1_X_2800_Y_3360 MSMG1_X_3200_Y_3360 947.3m
R_MSMG1_seg_2308 MSMG1_X_3200_Y_3360 MSMG1_X_3360_Y_3360 378.9m
R_MSMG1_seg_2309 MSMG1_X_3360_Y_3360 MSMG1_X_3840_Y_3360 1.137
R_MSMG1_seg_2310 MSMG1_X_3840_Y_3360 MSMG1_X_3920_Y_3360 189.5m
R_MSMG1_seg_2311 MSMG1_X_3920_Y_3360 MSMG1_X_4480_Y_3360 1.326
R_MSMG1_seg_2312 MSMG1_X_4480_Y_3360 MSMG1_X_5040_Y_3360 1.326
R_MSMG1_seg_2313 MSMG1_X_5040_Y_3360 MSMG1_X_5120_Y_3360 189.5m
R_MSMG1_seg_2314 MSMG1_X_5120_Y_3360 MSMG1_X_5600_Y_3360 1.137
R_MSMG1_seg_2315 MSMG1_X_5600_Y_3360 MSMG1_X_5760_Y_3360 378.9m
R_MSMG1_seg_2316 MSMG1_X_5760_Y_3360 MSMG1_X_6160_Y_3360 947.3m
R_MSMG1_seg_2317 MSMG1_X_6160_Y_3360 MSMG1_X_6400_Y_3360 568.4m
R_MSMG1_seg_2318 MSMG1_X_6400_Y_3360 MSMG1_X_6720_Y_3360 757.9m
R_MSMG1_seg_2319 MSMG1_X_6720_Y_3360 MSMG1_X_7040_Y_3360 757.9m
R_MSMG1_seg_2320 MSMG1_X_7040_Y_3360 MSMG1_X_7280_Y_3360 568.4m
R_MSMG1_seg_2321 MSMG1_X_7280_Y_3360 MSMG1_X_7680_Y_3360 947.3m
R_MSMG1_seg_2322 MSMG1_X_7680_Y_3360 MSMG1_X_7840_Y_3360 378.9m
R_MSMG1_seg_2323 MSMG1_X_7840_Y_3360 MSMG1_X_8320_Y_3360 1.137
R_MSMG1_seg_2324 MSMG1_X_8320_Y_3360 MSMG1_X_8400_Y_3360 189.5m
R_MSMG1_seg_2325 MSMG1_X_8400_Y_3360 MSMG1_X_8960_Y_3360 1.326
R_MSMG1_seg_2326 MSMG1_X_8960_Y_3360 MSMG1_X_9520_Y_3360 1.326
R_MSMG1_seg_2327 MSMG1_X_9520_Y_3360 MSMG1_X_9600_Y_3360 189.5m
R_MSMG1_seg_2328 MSMG1_X_9600_Y_3360 MSMG1_X_10000_Y_3360 947.3m
R_MSMG1_seg_2329 MSMG1_X_0_Y_3920 MSMG1_X_320_Y_3920 757.9m
R_MSMG1_seg_2330 MSMG1_X_320_Y_3920 MSMG1_X_560_Y_3920 568.4m
R_MSMG1_seg_2331 MSMG1_X_560_Y_3920 MSMG1_X_960_Y_3920 947.3m
R_MSMG1_seg_2332 MSMG1_X_960_Y_3920 MSMG1_X_1120_Y_3920 378.9m
R_MSMG1_seg_2333 MSMG1_X_1120_Y_3920 MSMG1_X_1600_Y_3920 1.137
R_MSMG1_seg_2334 MSMG1_X_1600_Y_3920 MSMG1_X_1680_Y_3920 189.5m
R_MSMG1_seg_2335 MSMG1_X_1680_Y_3920 MSMG1_X_2240_Y_3920 1.326
R_MSMG1_seg_2336 MSMG1_X_2240_Y_3920 MSMG1_X_2800_Y_3920 1.326
R_MSMG1_seg_2337 MSMG1_X_2800_Y_3920 MSMG1_X_2880_Y_3920 189.5m
R_MSMG1_seg_2338 MSMG1_X_2880_Y_3920 MSMG1_X_3360_Y_3920 1.137
R_MSMG1_seg_2339 MSMG1_X_3360_Y_3920 MSMG1_X_3520_Y_3920 378.9m
R_MSMG1_seg_2340 MSMG1_X_3520_Y_3920 MSMG1_X_3920_Y_3920 947.3m
R_MSMG1_seg_2341 MSMG1_X_3920_Y_3920 MSMG1_X_4160_Y_3920 568.4m
R_MSMG1_seg_2342 MSMG1_X_4160_Y_3920 MSMG1_X_4480_Y_3920 757.9m
R_MSMG1_seg_2343 MSMG1_X_4480_Y_3920 MSMG1_X_4800_Y_3920 757.9m
R_MSMG1_seg_2344 MSMG1_X_4800_Y_3920 MSMG1_X_5040_Y_3920 568.4m
R_MSMG1_seg_2345 MSMG1_X_5040_Y_3920 MSMG1_X_5440_Y_3920 947.3m
R_MSMG1_seg_2346 MSMG1_X_5440_Y_3920 MSMG1_X_5600_Y_3920 378.9m
R_MSMG1_seg_2347 MSMG1_X_5600_Y_3920 MSMG1_X_6080_Y_3920 1.137
R_MSMG1_seg_2348 MSMG1_X_6080_Y_3920 MSMG1_X_6160_Y_3920 189.5m
R_MSMG1_seg_2349 MSMG1_X_6160_Y_3920 MSMG1_X_6720_Y_3920 1.326
R_MSMG1_seg_2350 MSMG1_X_6720_Y_3920 MSMG1_X_7280_Y_3920 1.326
R_MSMG1_seg_2351 MSMG1_X_7280_Y_3920 MSMG1_X_7360_Y_3920 189.5m
R_MSMG1_seg_2352 MSMG1_X_7360_Y_3920 MSMG1_X_7840_Y_3920 1.137
R_MSMG1_seg_2353 MSMG1_X_7840_Y_3920 MSMG1_X_8000_Y_3920 378.9m
R_MSMG1_seg_2354 MSMG1_X_8000_Y_3920 MSMG1_X_8400_Y_3920 947.3m
R_MSMG1_seg_2355 MSMG1_X_8400_Y_3920 MSMG1_X_8640_Y_3920 568.4m
R_MSMG1_seg_2356 MSMG1_X_8640_Y_3920 MSMG1_X_8960_Y_3920 757.9m
R_MSMG1_seg_2357 MSMG1_X_8960_Y_3920 MSMG1_X_9280_Y_3920 757.9m
R_MSMG1_seg_2358 MSMG1_X_9280_Y_3920 MSMG1_X_9520_Y_3920 568.4m
R_MSMG1_seg_2359 MSMG1_X_9520_Y_3920 MSMG1_X_9920_Y_3920 947.3m
R_MSMG1_seg_2360 MSMG1_X_9920_Y_3920 MSMG1_X_10000_Y_3920 189.5m
R_MSMG1_seg_2361 MSMG1_X_0_Y_4480 MSMG1_X_560_Y_4480 1.326
R_MSMG1_seg_2362 MSMG1_X_560_Y_4480 MSMG1_X_640_Y_4480 189.5m
R_MSMG1_seg_2363 MSMG1_X_640_Y_4480 MSMG1_X_1120_Y_4480 1.137
R_MSMG1_seg_2364 MSMG1_X_1120_Y_4480 MSMG1_X_1280_Y_4480 378.9m
R_MSMG1_seg_2365 MSMG1_X_1280_Y_4480 MSMG1_X_1680_Y_4480 947.3m
R_MSMG1_seg_2366 MSMG1_X_1680_Y_4480 MSMG1_X_1920_Y_4480 568.4m
R_MSMG1_seg_2367 MSMG1_X_1920_Y_4480 MSMG1_X_2240_Y_4480 757.9m
R_MSMG1_seg_2368 MSMG1_X_2240_Y_4480 MSMG1_X_2560_Y_4480 757.9m
R_MSMG1_seg_2369 MSMG1_X_2560_Y_4480 MSMG1_X_2800_Y_4480 568.4m
R_MSMG1_seg_2370 MSMG1_X_2800_Y_4480 MSMG1_X_3200_Y_4480 947.3m
R_MSMG1_seg_2371 MSMG1_X_3200_Y_4480 MSMG1_X_3360_Y_4480 378.9m
R_MSMG1_seg_2372 MSMG1_X_3360_Y_4480 MSMG1_X_3840_Y_4480 1.137
R_MSMG1_seg_2373 MSMG1_X_3840_Y_4480 MSMG1_X_3920_Y_4480 189.5m
R_MSMG1_seg_2374 MSMG1_X_3920_Y_4480 MSMG1_X_4480_Y_4480 1.326
R_MSMG1_seg_2375 MSMG1_X_4480_Y_4480 MSMG1_X_5040_Y_4480 1.326
R_MSMG1_seg_2376 MSMG1_X_5040_Y_4480 MSMG1_X_5120_Y_4480 189.5m
R_MSMG1_seg_2377 MSMG1_X_5120_Y_4480 MSMG1_X_5600_Y_4480 1.137
R_MSMG1_seg_2378 MSMG1_X_5600_Y_4480 MSMG1_X_5760_Y_4480 378.9m
R_MSMG1_seg_2379 MSMG1_X_5760_Y_4480 MSMG1_X_6160_Y_4480 947.3m
R_MSMG1_seg_2380 MSMG1_X_6160_Y_4480 MSMG1_X_6400_Y_4480 568.4m
R_MSMG1_seg_2381 MSMG1_X_6400_Y_4480 MSMG1_X_6720_Y_4480 757.9m
R_MSMG1_seg_2382 MSMG1_X_6720_Y_4480 MSMG1_X_7040_Y_4480 757.9m
R_MSMG1_seg_2383 MSMG1_X_7040_Y_4480 MSMG1_X_7280_Y_4480 568.4m
R_MSMG1_seg_2384 MSMG1_X_7280_Y_4480 MSMG1_X_7680_Y_4480 947.3m
R_MSMG1_seg_2385 MSMG1_X_7680_Y_4480 MSMG1_X_7840_Y_4480 378.9m
R_MSMG1_seg_2386 MSMG1_X_7840_Y_4480 MSMG1_X_8320_Y_4480 1.137
R_MSMG1_seg_2387 MSMG1_X_8320_Y_4480 MSMG1_X_8400_Y_4480 189.5m
R_MSMG1_seg_2388 MSMG1_X_8400_Y_4480 MSMG1_X_8960_Y_4480 1.326
R_MSMG1_seg_2389 MSMG1_X_8960_Y_4480 MSMG1_X_9520_Y_4480 1.326
R_MSMG1_seg_2390 MSMG1_X_9520_Y_4480 MSMG1_X_9600_Y_4480 189.5m
R_MSMG1_seg_2391 MSMG1_X_9600_Y_4480 MSMG1_X_10000_Y_4480 947.3m
R_MSMG1_seg_2392 MSMG1_X_0_Y_5040 MSMG1_X_320_Y_5040 757.9m
R_MSMG1_seg_2393 MSMG1_X_320_Y_5040 MSMG1_X_560_Y_5040 568.4m
R_MSMG1_seg_2394 MSMG1_X_560_Y_5040 MSMG1_X_960_Y_5040 947.3m
R_MSMG1_seg_2395 MSMG1_X_960_Y_5040 MSMG1_X_1120_Y_5040 378.9m
R_MSMG1_seg_2396 MSMG1_X_1120_Y_5040 MSMG1_X_1600_Y_5040 1.137
R_MSMG1_seg_2397 MSMG1_X_1600_Y_5040 MSMG1_X_1680_Y_5040 189.5m
R_MSMG1_seg_2398 MSMG1_X_1680_Y_5040 MSMG1_X_2240_Y_5040 1.326
R_MSMG1_seg_2399 MSMG1_X_2240_Y_5040 MSMG1_X_2800_Y_5040 1.326
R_MSMG1_seg_2400 MSMG1_X_2800_Y_5040 MSMG1_X_2880_Y_5040 189.5m
R_MSMG1_seg_2401 MSMG1_X_2880_Y_5040 MSMG1_X_3360_Y_5040 1.137
R_MSMG1_seg_2402 MSMG1_X_3360_Y_5040 MSMG1_X_3520_Y_5040 378.9m
R_MSMG1_seg_2403 MSMG1_X_3520_Y_5040 MSMG1_X_3920_Y_5040 947.3m
R_MSMG1_seg_2404 MSMG1_X_3920_Y_5040 MSMG1_X_4160_Y_5040 568.4m
R_MSMG1_seg_2405 MSMG1_X_4160_Y_5040 MSMG1_X_4480_Y_5040 757.9m
R_MSMG1_seg_2406 MSMG1_X_4480_Y_5040 MSMG1_X_4800_Y_5040 757.9m
R_MSMG1_seg_2407 MSMG1_X_4800_Y_5040 MSMG1_X_5040_Y_5040 568.4m
R_MSMG1_seg_2408 MSMG1_X_5040_Y_5040 MSMG1_X_5440_Y_5040 947.3m
R_MSMG1_seg_2409 MSMG1_X_5440_Y_5040 MSMG1_X_5600_Y_5040 378.9m
R_MSMG1_seg_2410 MSMG1_X_5600_Y_5040 MSMG1_X_6080_Y_5040 1.137
R_MSMG1_seg_2411 MSMG1_X_6080_Y_5040 MSMG1_X_6160_Y_5040 189.5m
R_MSMG1_seg_2412 MSMG1_X_6160_Y_5040 MSMG1_X_6720_Y_5040 1.326
R_MSMG1_seg_2413 MSMG1_X_6720_Y_5040 MSMG1_X_7280_Y_5040 1.326
R_MSMG1_seg_2414 MSMG1_X_7280_Y_5040 MSMG1_X_7360_Y_5040 189.5m
R_MSMG1_seg_2415 MSMG1_X_7360_Y_5040 MSMG1_X_7840_Y_5040 1.137
R_MSMG1_seg_2416 MSMG1_X_7840_Y_5040 MSMG1_X_8000_Y_5040 378.9m
R_MSMG1_seg_2417 MSMG1_X_8000_Y_5040 MSMG1_X_8400_Y_5040 947.3m
R_MSMG1_seg_2418 MSMG1_X_8400_Y_5040 MSMG1_X_8640_Y_5040 568.4m
R_MSMG1_seg_2419 MSMG1_X_8640_Y_5040 MSMG1_X_8960_Y_5040 757.9m
R_MSMG1_seg_2420 MSMG1_X_8960_Y_5040 MSMG1_X_9280_Y_5040 757.9m
R_MSMG1_seg_2421 MSMG1_X_9280_Y_5040 MSMG1_X_9520_Y_5040 568.4m
R_MSMG1_seg_2422 MSMG1_X_9520_Y_5040 MSMG1_X_9920_Y_5040 947.3m
R_MSMG1_seg_2423 MSMG1_X_9920_Y_5040 MSMG1_X_10000_Y_5040 189.5m
R_MSMG1_seg_2424 MSMG1_X_0_Y_5600 MSMG1_X_560_Y_5600 1.326
R_MSMG1_seg_2425 MSMG1_X_560_Y_5600 MSMG1_X_640_Y_5600 189.5m
R_MSMG1_seg_2426 MSMG1_X_640_Y_5600 MSMG1_X_1120_Y_5600 1.137
R_MSMG1_seg_2427 MSMG1_X_1120_Y_5600 MSMG1_X_1280_Y_5600 378.9m
R_MSMG1_seg_2428 MSMG1_X_1280_Y_5600 MSMG1_X_1680_Y_5600 947.3m
R_MSMG1_seg_2429 MSMG1_X_1680_Y_5600 MSMG1_X_1920_Y_5600 568.4m
R_MSMG1_seg_2430 MSMG1_X_1920_Y_5600 MSMG1_X_2240_Y_5600 757.9m
R_MSMG1_seg_2431 MSMG1_X_2240_Y_5600 MSMG1_X_2560_Y_5600 757.9m
R_MSMG1_seg_2432 MSMG1_X_2560_Y_5600 MSMG1_X_2800_Y_5600 568.4m
R_MSMG1_seg_2433 MSMG1_X_2800_Y_5600 MSMG1_X_3200_Y_5600 947.3m
R_MSMG1_seg_2434 MSMG1_X_3200_Y_5600 MSMG1_X_3360_Y_5600 378.9m
R_MSMG1_seg_2435 MSMG1_X_3360_Y_5600 MSMG1_X_3840_Y_5600 1.137
R_MSMG1_seg_2436 MSMG1_X_3840_Y_5600 MSMG1_X_3920_Y_5600 189.5m
R_MSMG1_seg_2437 MSMG1_X_3920_Y_5600 MSMG1_X_4480_Y_5600 1.326
R_MSMG1_seg_2438 MSMG1_X_4480_Y_5600 MSMG1_X_5040_Y_5600 1.326
R_MSMG1_seg_2439 MSMG1_X_5040_Y_5600 MSMG1_X_5120_Y_5600 189.5m
R_MSMG1_seg_2440 MSMG1_X_5120_Y_5600 MSMG1_X_5600_Y_5600 1.137
R_MSMG1_seg_2441 MSMG1_X_5600_Y_5600 MSMG1_X_5760_Y_5600 378.9m
R_MSMG1_seg_2442 MSMG1_X_5760_Y_5600 MSMG1_X_6160_Y_5600 947.3m
R_MSMG1_seg_2443 MSMG1_X_6160_Y_5600 MSMG1_X_6400_Y_5600 568.4m
R_MSMG1_seg_2444 MSMG1_X_6400_Y_5600 MSMG1_X_6720_Y_5600 757.9m
R_MSMG1_seg_2445 MSMG1_X_6720_Y_5600 MSMG1_X_7040_Y_5600 757.9m
R_MSMG1_seg_2446 MSMG1_X_7040_Y_5600 MSMG1_X_7280_Y_5600 568.4m
R_MSMG1_seg_2447 MSMG1_X_7280_Y_5600 MSMG1_X_7680_Y_5600 947.3m
R_MSMG1_seg_2448 MSMG1_X_7680_Y_5600 MSMG1_X_7840_Y_5600 378.9m
R_MSMG1_seg_2449 MSMG1_X_7840_Y_5600 MSMG1_X_8320_Y_5600 1.137
R_MSMG1_seg_2450 MSMG1_X_8320_Y_5600 MSMG1_X_8400_Y_5600 189.5m
R_MSMG1_seg_2451 MSMG1_X_8400_Y_5600 MSMG1_X_8960_Y_5600 1.326
R_MSMG1_seg_2452 MSMG1_X_8960_Y_5600 MSMG1_X_9520_Y_5600 1.326
R_MSMG1_seg_2453 MSMG1_X_9520_Y_5600 MSMG1_X_9600_Y_5600 189.5m
R_MSMG1_seg_2454 MSMG1_X_9600_Y_5600 MSMG1_X_10000_Y_5600 947.3m
R_MSMG1_seg_2455 MSMG1_X_0_Y_6160 MSMG1_X_320_Y_6160 757.9m
R_MSMG1_seg_2456 MSMG1_X_320_Y_6160 MSMG1_X_560_Y_6160 568.4m
R_MSMG1_seg_2457 MSMG1_X_560_Y_6160 MSMG1_X_960_Y_6160 947.3m
R_MSMG1_seg_2458 MSMG1_X_960_Y_6160 MSMG1_X_1120_Y_6160 378.9m
R_MSMG1_seg_2459 MSMG1_X_1120_Y_6160 MSMG1_X_1600_Y_6160 1.137
R_MSMG1_seg_2460 MSMG1_X_1600_Y_6160 MSMG1_X_1680_Y_6160 189.5m
R_MSMG1_seg_2461 MSMG1_X_1680_Y_6160 MSMG1_X_2240_Y_6160 1.326
R_MSMG1_seg_2462 MSMG1_X_2240_Y_6160 MSMG1_X_2800_Y_6160 1.326
R_MSMG1_seg_2463 MSMG1_X_2800_Y_6160 MSMG1_X_2880_Y_6160 189.5m
R_MSMG1_seg_2464 MSMG1_X_2880_Y_6160 MSMG1_X_3360_Y_6160 1.137
R_MSMG1_seg_2465 MSMG1_X_3360_Y_6160 MSMG1_X_3520_Y_6160 378.9m
R_MSMG1_seg_2466 MSMG1_X_3520_Y_6160 MSMG1_X_3920_Y_6160 947.3m
R_MSMG1_seg_2467 MSMG1_X_3920_Y_6160 MSMG1_X_4160_Y_6160 568.4m
R_MSMG1_seg_2468 MSMG1_X_4160_Y_6160 MSMG1_X_4480_Y_6160 757.9m
R_MSMG1_seg_2469 MSMG1_X_4480_Y_6160 MSMG1_X_4800_Y_6160 757.9m
R_MSMG1_seg_2470 MSMG1_X_4800_Y_6160 MSMG1_X_5040_Y_6160 568.4m
R_MSMG1_seg_2471 MSMG1_X_5040_Y_6160 MSMG1_X_5440_Y_6160 947.3m
R_MSMG1_seg_2472 MSMG1_X_5440_Y_6160 MSMG1_X_5600_Y_6160 378.9m
R_MSMG1_seg_2473 MSMG1_X_5600_Y_6160 MSMG1_X_6080_Y_6160 1.137
R_MSMG1_seg_2474 MSMG1_X_6080_Y_6160 MSMG1_X_6160_Y_6160 189.5m
R_MSMG1_seg_2475 MSMG1_X_6160_Y_6160 MSMG1_X_6720_Y_6160 1.326
R_MSMG1_seg_2476 MSMG1_X_6720_Y_6160 MSMG1_X_7280_Y_6160 1.326
R_MSMG1_seg_2477 MSMG1_X_7280_Y_6160 MSMG1_X_7360_Y_6160 189.5m
R_MSMG1_seg_2478 MSMG1_X_7360_Y_6160 MSMG1_X_7840_Y_6160 1.137
R_MSMG1_seg_2479 MSMG1_X_7840_Y_6160 MSMG1_X_8000_Y_6160 378.9m
R_MSMG1_seg_2480 MSMG1_X_8000_Y_6160 MSMG1_X_8400_Y_6160 947.3m
R_MSMG1_seg_2481 MSMG1_X_8400_Y_6160 MSMG1_X_8640_Y_6160 568.4m
R_MSMG1_seg_2482 MSMG1_X_8640_Y_6160 MSMG1_X_8960_Y_6160 757.9m
R_MSMG1_seg_2483 MSMG1_X_8960_Y_6160 MSMG1_X_9280_Y_6160 757.9m
R_MSMG1_seg_2484 MSMG1_X_9280_Y_6160 MSMG1_X_9520_Y_6160 568.4m
R_MSMG1_seg_2485 MSMG1_X_9520_Y_6160 MSMG1_X_9920_Y_6160 947.3m
R_MSMG1_seg_2486 MSMG1_X_9920_Y_6160 MSMG1_X_10000_Y_6160 189.5m
R_MSMG1_seg_2487 MSMG1_X_0_Y_6720 MSMG1_X_560_Y_6720 1.326
R_MSMG1_seg_2488 MSMG1_X_560_Y_6720 MSMG1_X_640_Y_6720 189.5m
R_MSMG1_seg_2489 MSMG1_X_640_Y_6720 MSMG1_X_1120_Y_6720 1.137
R_MSMG1_seg_2490 MSMG1_X_1120_Y_6720 MSMG1_X_1280_Y_6720 378.9m
R_MSMG1_seg_2491 MSMG1_X_1280_Y_6720 MSMG1_X_1680_Y_6720 947.3m
R_MSMG1_seg_2492 MSMG1_X_1680_Y_6720 MSMG1_X_1920_Y_6720 568.4m
R_MSMG1_seg_2493 MSMG1_X_1920_Y_6720 MSMG1_X_2240_Y_6720 757.9m
R_MSMG1_seg_2494 MSMG1_X_2240_Y_6720 MSMG1_X_2560_Y_6720 757.9m
R_MSMG1_seg_2495 MSMG1_X_2560_Y_6720 MSMG1_X_2800_Y_6720 568.4m
R_MSMG1_seg_2496 MSMG1_X_2800_Y_6720 MSMG1_X_3200_Y_6720 947.3m
R_MSMG1_seg_2497 MSMG1_X_3200_Y_6720 MSMG1_X_3360_Y_6720 378.9m
R_MSMG1_seg_2498 MSMG1_X_3360_Y_6720 MSMG1_X_3840_Y_6720 1.137
R_MSMG1_seg_2499 MSMG1_X_3840_Y_6720 MSMG1_X_3920_Y_6720 189.5m
R_MSMG1_seg_2500 MSMG1_X_3920_Y_6720 MSMG1_X_4480_Y_6720 1.326
R_MSMG1_seg_2501 MSMG1_X_4480_Y_6720 MSMG1_X_5040_Y_6720 1.326
R_MSMG1_seg_2502 MSMG1_X_5040_Y_6720 MSMG1_X_5120_Y_6720 189.5m
R_MSMG1_seg_2503 MSMG1_X_5120_Y_6720 MSMG1_X_5600_Y_6720 1.137
R_MSMG1_seg_2504 MSMG1_X_5600_Y_6720 MSMG1_X_5760_Y_6720 378.9m
R_MSMG1_seg_2505 MSMG1_X_5760_Y_6720 MSMG1_X_6160_Y_6720 947.3m
R_MSMG1_seg_2506 MSMG1_X_6160_Y_6720 MSMG1_X_6400_Y_6720 568.4m
R_MSMG1_seg_2507 MSMG1_X_6400_Y_6720 MSMG1_X_6720_Y_6720 757.9m
R_MSMG1_seg_2508 MSMG1_X_6720_Y_6720 MSMG1_X_7040_Y_6720 757.9m
R_MSMG1_seg_2509 MSMG1_X_7040_Y_6720 MSMG1_X_7280_Y_6720 568.4m
R_MSMG1_seg_2510 MSMG1_X_7280_Y_6720 MSMG1_X_7680_Y_6720 947.3m
R_MSMG1_seg_2511 MSMG1_X_7680_Y_6720 MSMG1_X_7840_Y_6720 378.9m
R_MSMG1_seg_2512 MSMG1_X_7840_Y_6720 MSMG1_X_8320_Y_6720 1.137
R_MSMG1_seg_2513 MSMG1_X_8320_Y_6720 MSMG1_X_8400_Y_6720 189.5m
R_MSMG1_seg_2514 MSMG1_X_8400_Y_6720 MSMG1_X_8960_Y_6720 1.326
R_MSMG1_seg_2515 MSMG1_X_8960_Y_6720 MSMG1_X_9520_Y_6720 1.326
R_MSMG1_seg_2516 MSMG1_X_9520_Y_6720 MSMG1_X_9600_Y_6720 189.5m
R_MSMG1_seg_2517 MSMG1_X_9600_Y_6720 MSMG1_X_10000_Y_6720 947.3m
R_MSMG1_seg_2518 MSMG1_X_0_Y_7280 MSMG1_X_320_Y_7280 757.9m
R_MSMG1_seg_2519 MSMG1_X_320_Y_7280 MSMG1_X_560_Y_7280 568.4m
R_MSMG1_seg_2520 MSMG1_X_560_Y_7280 MSMG1_X_960_Y_7280 947.3m
R_MSMG1_seg_2521 MSMG1_X_960_Y_7280 MSMG1_X_1120_Y_7280 378.9m
R_MSMG1_seg_2522 MSMG1_X_1120_Y_7280 MSMG1_X_1600_Y_7280 1.137
R_MSMG1_seg_2523 MSMG1_X_1600_Y_7280 MSMG1_X_1680_Y_7280 189.5m
R_MSMG1_seg_2524 MSMG1_X_1680_Y_7280 MSMG1_X_2240_Y_7280 1.326
R_MSMG1_seg_2525 MSMG1_X_2240_Y_7280 MSMG1_X_2800_Y_7280 1.326
R_MSMG1_seg_2526 MSMG1_X_2800_Y_7280 MSMG1_X_2880_Y_7280 189.5m
R_MSMG1_seg_2527 MSMG1_X_2880_Y_7280 MSMG1_X_3360_Y_7280 1.137
R_MSMG1_seg_2528 MSMG1_X_3360_Y_7280 MSMG1_X_3520_Y_7280 378.9m
R_MSMG1_seg_2529 MSMG1_X_3520_Y_7280 MSMG1_X_3920_Y_7280 947.3m
R_MSMG1_seg_2530 MSMG1_X_3920_Y_7280 MSMG1_X_4160_Y_7280 568.4m
R_MSMG1_seg_2531 MSMG1_X_4160_Y_7280 MSMG1_X_4480_Y_7280 757.9m
R_MSMG1_seg_2532 MSMG1_X_4480_Y_7280 MSMG1_X_4800_Y_7280 757.9m
R_MSMG1_seg_2533 MSMG1_X_4800_Y_7280 MSMG1_X_5040_Y_7280 568.4m
R_MSMG1_seg_2534 MSMG1_X_5040_Y_7280 MSMG1_X_5440_Y_7280 947.3m
R_MSMG1_seg_2535 MSMG1_X_5440_Y_7280 MSMG1_X_5600_Y_7280 378.9m
R_MSMG1_seg_2536 MSMG1_X_5600_Y_7280 MSMG1_X_6080_Y_7280 1.137
R_MSMG1_seg_2537 MSMG1_X_6080_Y_7280 MSMG1_X_6160_Y_7280 189.5m
R_MSMG1_seg_2538 MSMG1_X_6160_Y_7280 MSMG1_X_6720_Y_7280 1.326
R_MSMG1_seg_2539 MSMG1_X_6720_Y_7280 MSMG1_X_7280_Y_7280 1.326
R_MSMG1_seg_2540 MSMG1_X_7280_Y_7280 MSMG1_X_7360_Y_7280 189.5m
R_MSMG1_seg_2541 MSMG1_X_7360_Y_7280 MSMG1_X_7840_Y_7280 1.137
R_MSMG1_seg_2542 MSMG1_X_7840_Y_7280 MSMG1_X_8000_Y_7280 378.9m
R_MSMG1_seg_2543 MSMG1_X_8000_Y_7280 MSMG1_X_8400_Y_7280 947.3m
R_MSMG1_seg_2544 MSMG1_X_8400_Y_7280 MSMG1_X_8640_Y_7280 568.4m
R_MSMG1_seg_2545 MSMG1_X_8640_Y_7280 MSMG1_X_8960_Y_7280 757.9m
R_MSMG1_seg_2546 MSMG1_X_8960_Y_7280 MSMG1_X_9280_Y_7280 757.9m
R_MSMG1_seg_2547 MSMG1_X_9280_Y_7280 MSMG1_X_9520_Y_7280 568.4m
R_MSMG1_seg_2548 MSMG1_X_9520_Y_7280 MSMG1_X_9920_Y_7280 947.3m
R_MSMG1_seg_2549 MSMG1_X_9920_Y_7280 MSMG1_X_10000_Y_7280 189.5m
R_MSMG1_seg_2550 MSMG1_X_0_Y_7840 MSMG1_X_560_Y_7840 1.326
R_MSMG1_seg_2551 MSMG1_X_560_Y_7840 MSMG1_X_640_Y_7840 189.5m
R_MSMG1_seg_2552 MSMG1_X_640_Y_7840 MSMG1_X_1120_Y_7840 1.137
R_MSMG1_seg_2553 MSMG1_X_1120_Y_7840 MSMG1_X_1280_Y_7840 378.9m
R_MSMG1_seg_2554 MSMG1_X_1280_Y_7840 MSMG1_X_1680_Y_7840 947.3m
R_MSMG1_seg_2555 MSMG1_X_1680_Y_7840 MSMG1_X_1920_Y_7840 568.4m
R_MSMG1_seg_2556 MSMG1_X_1920_Y_7840 MSMG1_X_2240_Y_7840 757.9m
R_MSMG1_seg_2557 MSMG1_X_2240_Y_7840 MSMG1_X_2560_Y_7840 757.9m
R_MSMG1_seg_2558 MSMG1_X_2560_Y_7840 MSMG1_X_2800_Y_7840 568.4m
R_MSMG1_seg_2559 MSMG1_X_2800_Y_7840 MSMG1_X_3200_Y_7840 947.3m
R_MSMG1_seg_2560 MSMG1_X_3200_Y_7840 MSMG1_X_3360_Y_7840 378.9m
R_MSMG1_seg_2561 MSMG1_X_3360_Y_7840 MSMG1_X_3840_Y_7840 1.137
R_MSMG1_seg_2562 MSMG1_X_3840_Y_7840 MSMG1_X_3920_Y_7840 189.5m
R_MSMG1_seg_2563 MSMG1_X_3920_Y_7840 MSMG1_X_4480_Y_7840 1.326
R_MSMG1_seg_2564 MSMG1_X_4480_Y_7840 MSMG1_X_5040_Y_7840 1.326
R_MSMG1_seg_2565 MSMG1_X_5040_Y_7840 MSMG1_X_5120_Y_7840 189.5m
R_MSMG1_seg_2566 MSMG1_X_5120_Y_7840 MSMG1_X_5600_Y_7840 1.137
R_MSMG1_seg_2567 MSMG1_X_5600_Y_7840 MSMG1_X_5760_Y_7840 378.9m
R_MSMG1_seg_2568 MSMG1_X_5760_Y_7840 MSMG1_X_6160_Y_7840 947.3m
R_MSMG1_seg_2569 MSMG1_X_6160_Y_7840 MSMG1_X_6400_Y_7840 568.4m
R_MSMG1_seg_2570 MSMG1_X_6400_Y_7840 MSMG1_X_6720_Y_7840 757.9m
R_MSMG1_seg_2571 MSMG1_X_6720_Y_7840 MSMG1_X_7040_Y_7840 757.9m
R_MSMG1_seg_2572 MSMG1_X_7040_Y_7840 MSMG1_X_7280_Y_7840 568.4m
R_MSMG1_seg_2573 MSMG1_X_7280_Y_7840 MSMG1_X_7680_Y_7840 947.3m
R_MSMG1_seg_2574 MSMG1_X_7680_Y_7840 MSMG1_X_7840_Y_7840 378.9m
R_MSMG1_seg_2575 MSMG1_X_7840_Y_7840 MSMG1_X_8320_Y_7840 1.137
R_MSMG1_seg_2576 MSMG1_X_8320_Y_7840 MSMG1_X_8400_Y_7840 189.5m
R_MSMG1_seg_2577 MSMG1_X_8400_Y_7840 MSMG1_X_8960_Y_7840 1.326
R_MSMG1_seg_2578 MSMG1_X_8960_Y_7840 MSMG1_X_9520_Y_7840 1.326
R_MSMG1_seg_2579 MSMG1_X_9520_Y_7840 MSMG1_X_9600_Y_7840 189.5m
R_MSMG1_seg_2580 MSMG1_X_9600_Y_7840 MSMG1_X_10000_Y_7840 947.3m
R_MSMG1_seg_2581 MSMG1_X_0_Y_8400 MSMG1_X_320_Y_8400 757.9m
R_MSMG1_seg_2582 MSMG1_X_320_Y_8400 MSMG1_X_560_Y_8400 568.4m
R_MSMG1_seg_2583 MSMG1_X_560_Y_8400 MSMG1_X_960_Y_8400 947.3m
R_MSMG1_seg_2584 MSMG1_X_960_Y_8400 MSMG1_X_1120_Y_8400 378.9m
R_MSMG1_seg_2585 MSMG1_X_1120_Y_8400 MSMG1_X_1600_Y_8400 1.137
R_MSMG1_seg_2586 MSMG1_X_1600_Y_8400 MSMG1_X_1680_Y_8400 189.5m
R_MSMG1_seg_2587 MSMG1_X_1680_Y_8400 MSMG1_X_2240_Y_8400 1.326
R_MSMG1_seg_2588 MSMG1_X_2240_Y_8400 MSMG1_X_2800_Y_8400 1.326
R_MSMG1_seg_2589 MSMG1_X_2800_Y_8400 MSMG1_X_2880_Y_8400 189.5m
R_MSMG1_seg_2590 MSMG1_X_2880_Y_8400 MSMG1_X_3360_Y_8400 1.137
R_MSMG1_seg_2591 MSMG1_X_3360_Y_8400 MSMG1_X_3520_Y_8400 378.9m
R_MSMG1_seg_2592 MSMG1_X_3520_Y_8400 MSMG1_X_3920_Y_8400 947.3m
R_MSMG1_seg_2593 MSMG1_X_3920_Y_8400 MSMG1_X_4160_Y_8400 568.4m
R_MSMG1_seg_2594 MSMG1_X_4160_Y_8400 MSMG1_X_4480_Y_8400 757.9m
R_MSMG1_seg_2595 MSMG1_X_4480_Y_8400 MSMG1_X_4800_Y_8400 757.9m
R_MSMG1_seg_2596 MSMG1_X_4800_Y_8400 MSMG1_X_5040_Y_8400 568.4m
R_MSMG1_seg_2597 MSMG1_X_5040_Y_8400 MSMG1_X_5440_Y_8400 947.3m
R_MSMG1_seg_2598 MSMG1_X_5440_Y_8400 MSMG1_X_5600_Y_8400 378.9m
R_MSMG1_seg_2599 MSMG1_X_5600_Y_8400 MSMG1_X_6080_Y_8400 1.137
R_MSMG1_seg_2600 MSMG1_X_6080_Y_8400 MSMG1_X_6160_Y_8400 189.5m
R_MSMG1_seg_2601 MSMG1_X_6160_Y_8400 MSMG1_X_6720_Y_8400 1.326
R_MSMG1_seg_2602 MSMG1_X_6720_Y_8400 MSMG1_X_7280_Y_8400 1.326
R_MSMG1_seg_2603 MSMG1_X_7280_Y_8400 MSMG1_X_7360_Y_8400 189.5m
R_MSMG1_seg_2604 MSMG1_X_7360_Y_8400 MSMG1_X_7840_Y_8400 1.137
R_MSMG1_seg_2605 MSMG1_X_7840_Y_8400 MSMG1_X_8000_Y_8400 378.9m
R_MSMG1_seg_2606 MSMG1_X_8000_Y_8400 MSMG1_X_8400_Y_8400 947.3m
R_MSMG1_seg_2607 MSMG1_X_8400_Y_8400 MSMG1_X_8640_Y_8400 568.4m
R_MSMG1_seg_2608 MSMG1_X_8640_Y_8400 MSMG1_X_8960_Y_8400 757.9m
R_MSMG1_seg_2609 MSMG1_X_8960_Y_8400 MSMG1_X_9280_Y_8400 757.9m
R_MSMG1_seg_2610 MSMG1_X_9280_Y_8400 MSMG1_X_9520_Y_8400 568.4m
R_MSMG1_seg_2611 MSMG1_X_9520_Y_8400 MSMG1_X_9920_Y_8400 947.3m
R_MSMG1_seg_2612 MSMG1_X_9920_Y_8400 MSMG1_X_10000_Y_8400 189.5m
R_MSMG1_seg_2613 MSMG1_X_0_Y_8960 MSMG1_X_560_Y_8960 1.326
R_MSMG1_seg_2614 MSMG1_X_560_Y_8960 MSMG1_X_640_Y_8960 189.5m
R_MSMG1_seg_2615 MSMG1_X_640_Y_8960 MSMG1_X_1120_Y_8960 1.137
R_MSMG1_seg_2616 MSMG1_X_1120_Y_8960 MSMG1_X_1280_Y_8960 378.9m
R_MSMG1_seg_2617 MSMG1_X_1280_Y_8960 MSMG1_X_1680_Y_8960 947.3m
R_MSMG1_seg_2618 MSMG1_X_1680_Y_8960 MSMG1_X_1920_Y_8960 568.4m
R_MSMG1_seg_2619 MSMG1_X_1920_Y_8960 MSMG1_X_2240_Y_8960 757.9m
R_MSMG1_seg_2620 MSMG1_X_2240_Y_8960 MSMG1_X_2560_Y_8960 757.9m
R_MSMG1_seg_2621 MSMG1_X_2560_Y_8960 MSMG1_X_2800_Y_8960 568.4m
R_MSMG1_seg_2622 MSMG1_X_2800_Y_8960 MSMG1_X_3200_Y_8960 947.3m
R_MSMG1_seg_2623 MSMG1_X_3200_Y_8960 MSMG1_X_3360_Y_8960 378.9m
R_MSMG1_seg_2624 MSMG1_X_3360_Y_8960 MSMG1_X_3840_Y_8960 1.137
R_MSMG1_seg_2625 MSMG1_X_3840_Y_8960 MSMG1_X_3920_Y_8960 189.5m
R_MSMG1_seg_2626 MSMG1_X_3920_Y_8960 MSMG1_X_4480_Y_8960 1.326
R_MSMG1_seg_2627 MSMG1_X_4480_Y_8960 MSMG1_X_5040_Y_8960 1.326
R_MSMG1_seg_2628 MSMG1_X_5040_Y_8960 MSMG1_X_5120_Y_8960 189.5m
R_MSMG1_seg_2629 MSMG1_X_5120_Y_8960 MSMG1_X_5600_Y_8960 1.137
R_MSMG1_seg_2630 MSMG1_X_5600_Y_8960 MSMG1_X_5760_Y_8960 378.9m
R_MSMG1_seg_2631 MSMG1_X_5760_Y_8960 MSMG1_X_6160_Y_8960 947.3m
R_MSMG1_seg_2632 MSMG1_X_6160_Y_8960 MSMG1_X_6400_Y_8960 568.4m
R_MSMG1_seg_2633 MSMG1_X_6400_Y_8960 MSMG1_X_6720_Y_8960 757.9m
R_MSMG1_seg_2634 MSMG1_X_6720_Y_8960 MSMG1_X_7040_Y_8960 757.9m
R_MSMG1_seg_2635 MSMG1_X_7040_Y_8960 MSMG1_X_7280_Y_8960 568.4m
R_MSMG1_seg_2636 MSMG1_X_7280_Y_8960 MSMG1_X_7680_Y_8960 947.3m
R_MSMG1_seg_2637 MSMG1_X_7680_Y_8960 MSMG1_X_7840_Y_8960 378.9m
R_MSMG1_seg_2638 MSMG1_X_7840_Y_8960 MSMG1_X_8320_Y_8960 1.137
R_MSMG1_seg_2639 MSMG1_X_8320_Y_8960 MSMG1_X_8400_Y_8960 189.5m
R_MSMG1_seg_2640 MSMG1_X_8400_Y_8960 MSMG1_X_8960_Y_8960 1.326
R_MSMG1_seg_2641 MSMG1_X_8960_Y_8960 MSMG1_X_9520_Y_8960 1.326
R_MSMG1_seg_2642 MSMG1_X_9520_Y_8960 MSMG1_X_9600_Y_8960 189.5m
R_MSMG1_seg_2643 MSMG1_X_9600_Y_8960 MSMG1_X_10000_Y_8960 947.3m
R_MSMG1_seg_2644 MSMG1_X_0_Y_9520 MSMG1_X_320_Y_9520 757.9m
R_MSMG1_seg_2645 MSMG1_X_320_Y_9520 MSMG1_X_560_Y_9520 568.4m
R_MSMG1_seg_2646 MSMG1_X_560_Y_9520 MSMG1_X_960_Y_9520 947.3m
R_MSMG1_seg_2647 MSMG1_X_960_Y_9520 MSMG1_X_1120_Y_9520 378.9m
R_MSMG1_seg_2648 MSMG1_X_1120_Y_9520 MSMG1_X_1600_Y_9520 1.137
R_MSMG1_seg_2649 MSMG1_X_1600_Y_9520 MSMG1_X_1680_Y_9520 189.5m
R_MSMG1_seg_2650 MSMG1_X_1680_Y_9520 MSMG1_X_2240_Y_9520 1.326
R_MSMG1_seg_2651 MSMG1_X_2240_Y_9520 MSMG1_X_2800_Y_9520 1.326
R_MSMG1_seg_2652 MSMG1_X_2800_Y_9520 MSMG1_X_2880_Y_9520 189.5m
R_MSMG1_seg_2653 MSMG1_X_2880_Y_9520 MSMG1_X_3360_Y_9520 1.137
R_MSMG1_seg_2654 MSMG1_X_3360_Y_9520 MSMG1_X_3520_Y_9520 378.9m
R_MSMG1_seg_2655 MSMG1_X_3520_Y_9520 MSMG1_X_3920_Y_9520 947.3m
R_MSMG1_seg_2656 MSMG1_X_3920_Y_9520 MSMG1_X_4160_Y_9520 568.4m
R_MSMG1_seg_2657 MSMG1_X_4160_Y_9520 MSMG1_X_4480_Y_9520 757.9m
R_MSMG1_seg_2658 MSMG1_X_4480_Y_9520 MSMG1_X_4800_Y_9520 757.9m
R_MSMG1_seg_2659 MSMG1_X_4800_Y_9520 MSMG1_X_5040_Y_9520 568.4m
R_MSMG1_seg_2660 MSMG1_X_5040_Y_9520 MSMG1_X_5440_Y_9520 947.3m
R_MSMG1_seg_2661 MSMG1_X_5440_Y_9520 MSMG1_X_5600_Y_9520 378.9m
R_MSMG1_seg_2662 MSMG1_X_5600_Y_9520 MSMG1_X_6080_Y_9520 1.137
R_MSMG1_seg_2663 MSMG1_X_6080_Y_9520 MSMG1_X_6160_Y_9520 189.5m
R_MSMG1_seg_2664 MSMG1_X_6160_Y_9520 MSMG1_X_6720_Y_9520 1.326
R_MSMG1_seg_2665 MSMG1_X_6720_Y_9520 MSMG1_X_7280_Y_9520 1.326
R_MSMG1_seg_2666 MSMG1_X_7280_Y_9520 MSMG1_X_7360_Y_9520 189.5m
R_MSMG1_seg_2667 MSMG1_X_7360_Y_9520 MSMG1_X_7840_Y_9520 1.137
R_MSMG1_seg_2668 MSMG1_X_7840_Y_9520 MSMG1_X_8000_Y_9520 378.9m
R_MSMG1_seg_2669 MSMG1_X_8000_Y_9520 MSMG1_X_8400_Y_9520 947.3m
R_MSMG1_seg_2670 MSMG1_X_8400_Y_9520 MSMG1_X_8640_Y_9520 568.4m
R_MSMG1_seg_2671 MSMG1_X_8640_Y_9520 MSMG1_X_8960_Y_9520 757.9m
R_MSMG1_seg_2672 MSMG1_X_8960_Y_9520 MSMG1_X_9280_Y_9520 757.9m
R_MSMG1_seg_2673 MSMG1_X_9280_Y_9520 MSMG1_X_9520_Y_9520 568.4m
R_MSMG1_seg_2674 MSMG1_X_9520_Y_9520 MSMG1_X_9920_Y_9520 947.3m
R_MSMG1_seg_2675 MSMG1_X_9920_Y_9520 MSMG1_X_10000_Y_9520 189.5m
* Layer: MINT5
R_MINT5_seg_2676 MINT5_X_0_Y_0 MINT5_X_0_Y_320 3.284
R_MINT5_seg_2677 MINT5_X_0_Y_320 MINT5_X_0_Y_640 3.284
R_MINT5_seg_2678 MINT5_X_0_Y_640 MINT5_X_0_Y_960 3.284
R_MINT5_seg_2679 MINT5_X_0_Y_960 MINT5_X_0_Y_1120 1.642
R_MINT5_seg_2680 MINT5_X_0_Y_1120 MINT5_X_0_Y_1280 1.642
R_MINT5_seg_2681 MINT5_X_0_Y_1280 MINT5_X_0_Y_1600 3.284
R_MINT5_seg_2682 MINT5_X_0_Y_1600 MINT5_X_0_Y_1920 3.284
R_MINT5_seg_2683 MINT5_X_0_Y_1920 MINT5_X_0_Y_2240 3.284
R_MINT5_seg_2684 MINT5_X_0_Y_2240 MINT5_X_0_Y_2560 3.284
R_MINT5_seg_2685 MINT5_X_0_Y_2560 MINT5_X_0_Y_2880 3.284
R_MINT5_seg_2686 MINT5_X_0_Y_2880 MINT5_X_0_Y_3200 3.284
R_MINT5_seg_2687 MINT5_X_0_Y_3200 MINT5_X_0_Y_3360 1.642
R_MINT5_seg_2688 MINT5_X_0_Y_3360 MINT5_X_0_Y_3520 1.642
R_MINT5_seg_2689 MINT5_X_0_Y_3520 MINT5_X_0_Y_3840 3.284
R_MINT5_seg_2690 MINT5_X_0_Y_3840 MINT5_X_0_Y_4160 3.284
R_MINT5_seg_2691 MINT5_X_0_Y_4160 MINT5_X_0_Y_4480 3.284
R_MINT5_seg_2692 MINT5_X_0_Y_4480 MINT5_X_0_Y_4800 3.284
R_MINT5_seg_2693 MINT5_X_0_Y_4800 MINT5_X_0_Y_5120 3.284
R_MINT5_seg_2694 MINT5_X_0_Y_5120 MINT5_X_0_Y_5440 3.284
R_MINT5_seg_2695 MINT5_X_0_Y_5440 MINT5_X_0_Y_5600 1.642
R_MINT5_seg_2696 MINT5_X_0_Y_5600 MINT5_X_0_Y_5760 1.642
R_MINT5_seg_2697 MINT5_X_0_Y_5760 MINT5_X_0_Y_6080 3.284
R_MINT5_seg_2698 MINT5_X_0_Y_6080 MINT5_X_0_Y_6400 3.284
R_MINT5_seg_2699 MINT5_X_0_Y_6400 MINT5_X_0_Y_6720 3.284
R_MINT5_seg_2700 MINT5_X_0_Y_6720 MINT5_X_0_Y_7040 3.284
R_MINT5_seg_2701 MINT5_X_0_Y_7040 MINT5_X_0_Y_7360 3.284
R_MINT5_seg_2702 MINT5_X_0_Y_7360 MINT5_X_0_Y_7680 3.284
R_MINT5_seg_2703 MINT5_X_0_Y_7680 MINT5_X_0_Y_7840 1.642
R_MINT5_seg_2704 MINT5_X_0_Y_7840 MINT5_X_0_Y_8000 1.642
R_MINT5_seg_2705 MINT5_X_0_Y_8000 MINT5_X_0_Y_8320 3.284
R_MINT5_seg_2706 MINT5_X_0_Y_8320 MINT5_X_0_Y_8640 3.284
R_MINT5_seg_2707 MINT5_X_0_Y_8640 MINT5_X_0_Y_8960 3.284
R_MINT5_seg_2708 MINT5_X_0_Y_8960 MINT5_X_0_Y_9280 3.284
R_MINT5_seg_2709 MINT5_X_0_Y_9280 MINT5_X_0_Y_9600 3.284
R_MINT5_seg_2710 MINT5_X_0_Y_9600 MINT5_X_0_Y_9920 3.284
R_MINT5_seg_2711 MINT5_X_0_Y_9920 MINT5_X_0_Y_10000 821m
R_MINT5_seg_2712 MINT5_X_320_Y_0 MINT5_X_320_Y_320 3.284
R_MINT5_seg_2713 MINT5_X_320_Y_320 MINT5_X_320_Y_560 2.463
R_MINT5_seg_2714 MINT5_X_320_Y_560 MINT5_X_320_Y_640 821m
R_MINT5_seg_2715 MINT5_X_320_Y_640 MINT5_X_320_Y_960 3.284
R_MINT5_seg_2716 MINT5_X_320_Y_960 MINT5_X_320_Y_1280 3.284
R_MINT5_seg_2717 MINT5_X_320_Y_1280 MINT5_X_320_Y_1600 3.284
R_MINT5_seg_2718 MINT5_X_320_Y_1600 MINT5_X_320_Y_1680 821m
R_MINT5_seg_2719 MINT5_X_320_Y_1680 MINT5_X_320_Y_1920 2.463
R_MINT5_seg_2720 MINT5_X_320_Y_1920 MINT5_X_320_Y_2240 3.284
R_MINT5_seg_2721 MINT5_X_320_Y_2240 MINT5_X_320_Y_2560 3.284
R_MINT5_seg_2722 MINT5_X_320_Y_2560 MINT5_X_320_Y_2800 2.463
R_MINT5_seg_2723 MINT5_X_320_Y_2800 MINT5_X_320_Y_2880 821m
R_MINT5_seg_2724 MINT5_X_320_Y_2880 MINT5_X_320_Y_3200 3.284
R_MINT5_seg_2725 MINT5_X_320_Y_3200 MINT5_X_320_Y_3520 3.284
R_MINT5_seg_2726 MINT5_X_320_Y_3520 MINT5_X_320_Y_3840 3.284
R_MINT5_seg_2727 MINT5_X_320_Y_3840 MINT5_X_320_Y_3920 821m
R_MINT5_seg_2728 MINT5_X_320_Y_3920 MINT5_X_320_Y_4160 2.463
R_MINT5_seg_2729 MINT5_X_320_Y_4160 MINT5_X_320_Y_4480 3.284
R_MINT5_seg_2730 MINT5_X_320_Y_4480 MINT5_X_320_Y_4800 3.284
R_MINT5_seg_2731 MINT5_X_320_Y_4800 MINT5_X_320_Y_5040 2.463
R_MINT5_seg_2732 MINT5_X_320_Y_5040 MINT5_X_320_Y_5120 821m
R_MINT5_seg_2733 MINT5_X_320_Y_5120 MINT5_X_320_Y_5440 3.284
R_MINT5_seg_2734 MINT5_X_320_Y_5440 MINT5_X_320_Y_5760 3.284
R_MINT5_seg_2735 MINT5_X_320_Y_5760 MINT5_X_320_Y_6080 3.284
R_MINT5_seg_2736 MINT5_X_320_Y_6080 MINT5_X_320_Y_6160 821m
R_MINT5_seg_2737 MINT5_X_320_Y_6160 MINT5_X_320_Y_6400 2.463
R_MINT5_seg_2738 MINT5_X_320_Y_6400 MINT5_X_320_Y_6720 3.284
R_MINT5_seg_2739 MINT5_X_320_Y_6720 MINT5_X_320_Y_7040 3.284
R_MINT5_seg_2740 MINT5_X_320_Y_7040 MINT5_X_320_Y_7280 2.463
R_MINT5_seg_2741 MINT5_X_320_Y_7280 MINT5_X_320_Y_7360 821m
R_MINT5_seg_2742 MINT5_X_320_Y_7360 MINT5_X_320_Y_7680 3.284
R_MINT5_seg_2743 MINT5_X_320_Y_7680 MINT5_X_320_Y_8000 3.284
R_MINT5_seg_2744 MINT5_X_320_Y_8000 MINT5_X_320_Y_8320 3.284
R_MINT5_seg_2745 MINT5_X_320_Y_8320 MINT5_X_320_Y_8400 821m
R_MINT5_seg_2746 MINT5_X_320_Y_8400 MINT5_X_320_Y_8640 2.463
R_MINT5_seg_2747 MINT5_X_320_Y_8640 MINT5_X_320_Y_8960 3.284
R_MINT5_seg_2748 MINT5_X_320_Y_8960 MINT5_X_320_Y_9280 3.284
R_MINT5_seg_2749 MINT5_X_320_Y_9280 MINT5_X_320_Y_9520 2.463
R_MINT5_seg_2750 MINT5_X_320_Y_9520 MINT5_X_320_Y_9600 821m
R_MINT5_seg_2751 MINT5_X_320_Y_9600 MINT5_X_320_Y_9920 3.284
R_MINT5_seg_2752 MINT5_X_320_Y_9920 MINT5_X_320_Y_10000 821m
R_MINT5_seg_2753 MINT5_X_640_Y_0 MINT5_X_640_Y_320 3.284
R_MINT5_seg_2754 MINT5_X_640_Y_320 MINT5_X_640_Y_640 3.284
R_MINT5_seg_2755 MINT5_X_640_Y_640 MINT5_X_640_Y_960 3.284
R_MINT5_seg_2756 MINT5_X_640_Y_960 MINT5_X_640_Y_1120 1.642
R_MINT5_seg_2757 MINT5_X_640_Y_1120 MINT5_X_640_Y_1280 1.642
R_MINT5_seg_2758 MINT5_X_640_Y_1280 MINT5_X_640_Y_1600 3.284
R_MINT5_seg_2759 MINT5_X_640_Y_1600 MINT5_X_640_Y_1920 3.284
R_MINT5_seg_2760 MINT5_X_640_Y_1920 MINT5_X_640_Y_2240 3.284
R_MINT5_seg_2761 MINT5_X_640_Y_2240 MINT5_X_640_Y_2560 3.284
R_MINT5_seg_2762 MINT5_X_640_Y_2560 MINT5_X_640_Y_2880 3.284
R_MINT5_seg_2763 MINT5_X_640_Y_2880 MINT5_X_640_Y_3200 3.284
R_MINT5_seg_2764 MINT5_X_640_Y_3200 MINT5_X_640_Y_3360 1.642
R_MINT5_seg_2765 MINT5_X_640_Y_3360 MINT5_X_640_Y_3520 1.642
R_MINT5_seg_2766 MINT5_X_640_Y_3520 MINT5_X_640_Y_3840 3.284
R_MINT5_seg_2767 MINT5_X_640_Y_3840 MINT5_X_640_Y_4160 3.284
R_MINT5_seg_2768 MINT5_X_640_Y_4160 MINT5_X_640_Y_4480 3.284
R_MINT5_seg_2769 MINT5_X_640_Y_4480 MINT5_X_640_Y_4800 3.284
R_MINT5_seg_2770 MINT5_X_640_Y_4800 MINT5_X_640_Y_5120 3.284
R_MINT5_seg_2771 MINT5_X_640_Y_5120 MINT5_X_640_Y_5440 3.284
R_MINT5_seg_2772 MINT5_X_640_Y_5440 MINT5_X_640_Y_5600 1.642
R_MINT5_seg_2773 MINT5_X_640_Y_5600 MINT5_X_640_Y_5760 1.642
R_MINT5_seg_2774 MINT5_X_640_Y_5760 MINT5_X_640_Y_6080 3.284
R_MINT5_seg_2775 MINT5_X_640_Y_6080 MINT5_X_640_Y_6400 3.284
R_MINT5_seg_2776 MINT5_X_640_Y_6400 MINT5_X_640_Y_6720 3.284
R_MINT5_seg_2777 MINT5_X_640_Y_6720 MINT5_X_640_Y_7040 3.284
R_MINT5_seg_2778 MINT5_X_640_Y_7040 MINT5_X_640_Y_7360 3.284
R_MINT5_seg_2779 MINT5_X_640_Y_7360 MINT5_X_640_Y_7680 3.284
R_MINT5_seg_2780 MINT5_X_640_Y_7680 MINT5_X_640_Y_7840 1.642
R_MINT5_seg_2781 MINT5_X_640_Y_7840 MINT5_X_640_Y_8000 1.642
R_MINT5_seg_2782 MINT5_X_640_Y_8000 MINT5_X_640_Y_8320 3.284
R_MINT5_seg_2783 MINT5_X_640_Y_8320 MINT5_X_640_Y_8640 3.284
R_MINT5_seg_2784 MINT5_X_640_Y_8640 MINT5_X_640_Y_8960 3.284
R_MINT5_seg_2785 MINT5_X_640_Y_8960 MINT5_X_640_Y_9280 3.284
R_MINT5_seg_2786 MINT5_X_640_Y_9280 MINT5_X_640_Y_9600 3.284
R_MINT5_seg_2787 MINT5_X_640_Y_9600 MINT5_X_640_Y_9920 3.284
R_MINT5_seg_2788 MINT5_X_640_Y_9920 MINT5_X_640_Y_10000 821m
R_MINT5_seg_2789 MINT5_X_960_Y_0 MINT5_X_960_Y_320 3.284
R_MINT5_seg_2790 MINT5_X_960_Y_320 MINT5_X_960_Y_560 2.463
R_MINT5_seg_2791 MINT5_X_960_Y_560 MINT5_X_960_Y_640 821m
R_MINT5_seg_2792 MINT5_X_960_Y_640 MINT5_X_960_Y_960 3.284
R_MINT5_seg_2793 MINT5_X_960_Y_960 MINT5_X_960_Y_1280 3.284
R_MINT5_seg_2794 MINT5_X_960_Y_1280 MINT5_X_960_Y_1600 3.284
R_MINT5_seg_2795 MINT5_X_960_Y_1600 MINT5_X_960_Y_1680 821m
R_MINT5_seg_2796 MINT5_X_960_Y_1680 MINT5_X_960_Y_1920 2.463
R_MINT5_seg_2797 MINT5_X_960_Y_1920 MINT5_X_960_Y_2240 3.284
R_MINT5_seg_2798 MINT5_X_960_Y_2240 MINT5_X_960_Y_2560 3.284
R_MINT5_seg_2799 MINT5_X_960_Y_2560 MINT5_X_960_Y_2800 2.463
R_MINT5_seg_2800 MINT5_X_960_Y_2800 MINT5_X_960_Y_2880 821m
R_MINT5_seg_2801 MINT5_X_960_Y_2880 MINT5_X_960_Y_3200 3.284
R_MINT5_seg_2802 MINT5_X_960_Y_3200 MINT5_X_960_Y_3520 3.284
R_MINT5_seg_2803 MINT5_X_960_Y_3520 MINT5_X_960_Y_3840 3.284
R_MINT5_seg_2804 MINT5_X_960_Y_3840 MINT5_X_960_Y_3920 821m
R_MINT5_seg_2805 MINT5_X_960_Y_3920 MINT5_X_960_Y_4160 2.463
R_MINT5_seg_2806 MINT5_X_960_Y_4160 MINT5_X_960_Y_4480 3.284
R_MINT5_seg_2807 MINT5_X_960_Y_4480 MINT5_X_960_Y_4800 3.284
R_MINT5_seg_2808 MINT5_X_960_Y_4800 MINT5_X_960_Y_5040 2.463
R_MINT5_seg_2809 MINT5_X_960_Y_5040 MINT5_X_960_Y_5120 821m
R_MINT5_seg_2810 MINT5_X_960_Y_5120 MINT5_X_960_Y_5440 3.284
R_MINT5_seg_2811 MINT5_X_960_Y_5440 MINT5_X_960_Y_5760 3.284
R_MINT5_seg_2812 MINT5_X_960_Y_5760 MINT5_X_960_Y_6080 3.284
R_MINT5_seg_2813 MINT5_X_960_Y_6080 MINT5_X_960_Y_6160 821m
R_MINT5_seg_2814 MINT5_X_960_Y_6160 MINT5_X_960_Y_6400 2.463
R_MINT5_seg_2815 MINT5_X_960_Y_6400 MINT5_X_960_Y_6720 3.284
R_MINT5_seg_2816 MINT5_X_960_Y_6720 MINT5_X_960_Y_7040 3.284
R_MINT5_seg_2817 MINT5_X_960_Y_7040 MINT5_X_960_Y_7280 2.463
R_MINT5_seg_2818 MINT5_X_960_Y_7280 MINT5_X_960_Y_7360 821m
R_MINT5_seg_2819 MINT5_X_960_Y_7360 MINT5_X_960_Y_7680 3.284
R_MINT5_seg_2820 MINT5_X_960_Y_7680 MINT5_X_960_Y_8000 3.284
R_MINT5_seg_2821 MINT5_X_960_Y_8000 MINT5_X_960_Y_8320 3.284
R_MINT5_seg_2822 MINT5_X_960_Y_8320 MINT5_X_960_Y_8400 821m
R_MINT5_seg_2823 MINT5_X_960_Y_8400 MINT5_X_960_Y_8640 2.463
R_MINT5_seg_2824 MINT5_X_960_Y_8640 MINT5_X_960_Y_8960 3.284
R_MINT5_seg_2825 MINT5_X_960_Y_8960 MINT5_X_960_Y_9280 3.284
R_MINT5_seg_2826 MINT5_X_960_Y_9280 MINT5_X_960_Y_9520 2.463
R_MINT5_seg_2827 MINT5_X_960_Y_9520 MINT5_X_960_Y_9600 821m
R_MINT5_seg_2828 MINT5_X_960_Y_9600 MINT5_X_960_Y_9920 3.284
R_MINT5_seg_2829 MINT5_X_960_Y_9920 MINT5_X_960_Y_10000 821m
R_MINT5_seg_2830 MINT5_X_1280_Y_0 MINT5_X_1280_Y_320 3.284
R_MINT5_seg_2831 MINT5_X_1280_Y_320 MINT5_X_1280_Y_640 3.284
R_MINT5_seg_2832 MINT5_X_1280_Y_640 MINT5_X_1280_Y_960 3.284
R_MINT5_seg_2833 MINT5_X_1280_Y_960 MINT5_X_1280_Y_1120 1.642
R_MINT5_seg_2834 MINT5_X_1280_Y_1120 MINT5_X_1280_Y_1280 1.642
R_MINT5_seg_2835 MINT5_X_1280_Y_1280 MINT5_X_1280_Y_1600 3.284
R_MINT5_seg_2836 MINT5_X_1280_Y_1600 MINT5_X_1280_Y_1920 3.284
R_MINT5_seg_2837 MINT5_X_1280_Y_1920 MINT5_X_1280_Y_2240 3.284
R_MINT5_seg_2838 MINT5_X_1280_Y_2240 MINT5_X_1280_Y_2560 3.284
R_MINT5_seg_2839 MINT5_X_1280_Y_2560 MINT5_X_1280_Y_2880 3.284
R_MINT5_seg_2840 MINT5_X_1280_Y_2880 MINT5_X_1280_Y_3200 3.284
R_MINT5_seg_2841 MINT5_X_1280_Y_3200 MINT5_X_1280_Y_3360 1.642
R_MINT5_seg_2842 MINT5_X_1280_Y_3360 MINT5_X_1280_Y_3520 1.642
R_MINT5_seg_2843 MINT5_X_1280_Y_3520 MINT5_X_1280_Y_3840 3.284
R_MINT5_seg_2844 MINT5_X_1280_Y_3840 MINT5_X_1280_Y_4160 3.284
R_MINT5_seg_2845 MINT5_X_1280_Y_4160 MINT5_X_1280_Y_4480 3.284
R_MINT5_seg_2846 MINT5_X_1280_Y_4480 MINT5_X_1280_Y_4800 3.284
R_MINT5_seg_2847 MINT5_X_1280_Y_4800 MINT5_X_1280_Y_5120 3.284
R_MINT5_seg_2848 MINT5_X_1280_Y_5120 MINT5_X_1280_Y_5440 3.284
R_MINT5_seg_2849 MINT5_X_1280_Y_5440 MINT5_X_1280_Y_5600 1.642
R_MINT5_seg_2850 MINT5_X_1280_Y_5600 MINT5_X_1280_Y_5760 1.642
R_MINT5_seg_2851 MINT5_X_1280_Y_5760 MINT5_X_1280_Y_6080 3.284
R_MINT5_seg_2852 MINT5_X_1280_Y_6080 MINT5_X_1280_Y_6400 3.284
R_MINT5_seg_2853 MINT5_X_1280_Y_6400 MINT5_X_1280_Y_6720 3.284
R_MINT5_seg_2854 MINT5_X_1280_Y_6720 MINT5_X_1280_Y_7040 3.284
R_MINT5_seg_2855 MINT5_X_1280_Y_7040 MINT5_X_1280_Y_7360 3.284
R_MINT5_seg_2856 MINT5_X_1280_Y_7360 MINT5_X_1280_Y_7680 3.284
R_MINT5_seg_2857 MINT5_X_1280_Y_7680 MINT5_X_1280_Y_7840 1.642
R_MINT5_seg_2858 MINT5_X_1280_Y_7840 MINT5_X_1280_Y_8000 1.642
R_MINT5_seg_2859 MINT5_X_1280_Y_8000 MINT5_X_1280_Y_8320 3.284
R_MINT5_seg_2860 MINT5_X_1280_Y_8320 MINT5_X_1280_Y_8640 3.284
R_MINT5_seg_2861 MINT5_X_1280_Y_8640 MINT5_X_1280_Y_8960 3.284
R_MINT5_seg_2862 MINT5_X_1280_Y_8960 MINT5_X_1280_Y_9280 3.284
R_MINT5_seg_2863 MINT5_X_1280_Y_9280 MINT5_X_1280_Y_9600 3.284
R_MINT5_seg_2864 MINT5_X_1280_Y_9600 MINT5_X_1280_Y_9920 3.284
R_MINT5_seg_2865 MINT5_X_1280_Y_9920 MINT5_X_1280_Y_10000 821m
R_MINT5_seg_2866 MINT5_X_1600_Y_0 MINT5_X_1600_Y_320 3.284
R_MINT5_seg_2867 MINT5_X_1600_Y_320 MINT5_X_1600_Y_560 2.463
R_MINT5_seg_2868 MINT5_X_1600_Y_560 MINT5_X_1600_Y_640 821m
R_MINT5_seg_2869 MINT5_X_1600_Y_640 MINT5_X_1600_Y_960 3.284
R_MINT5_seg_2870 MINT5_X_1600_Y_960 MINT5_X_1600_Y_1280 3.284
R_MINT5_seg_2871 MINT5_X_1600_Y_1280 MINT5_X_1600_Y_1600 3.284
R_MINT5_seg_2872 MINT5_X_1600_Y_1600 MINT5_X_1600_Y_1680 821m
R_MINT5_seg_2873 MINT5_X_1600_Y_1680 MINT5_X_1600_Y_1920 2.463
R_MINT5_seg_2874 MINT5_X_1600_Y_1920 MINT5_X_1600_Y_2240 3.284
R_MINT5_seg_2875 MINT5_X_1600_Y_2240 MINT5_X_1600_Y_2560 3.284
R_MINT5_seg_2876 MINT5_X_1600_Y_2560 MINT5_X_1600_Y_2800 2.463
R_MINT5_seg_2877 MINT5_X_1600_Y_2800 MINT5_X_1600_Y_2880 821m
R_MINT5_seg_2878 MINT5_X_1600_Y_2880 MINT5_X_1600_Y_3200 3.284
R_MINT5_seg_2879 MINT5_X_1600_Y_3200 MINT5_X_1600_Y_3520 3.284
R_MINT5_seg_2880 MINT5_X_1600_Y_3520 MINT5_X_1600_Y_3840 3.284
R_MINT5_seg_2881 MINT5_X_1600_Y_3840 MINT5_X_1600_Y_3920 821m
R_MINT5_seg_2882 MINT5_X_1600_Y_3920 MINT5_X_1600_Y_4160 2.463
R_MINT5_seg_2883 MINT5_X_1600_Y_4160 MINT5_X_1600_Y_4480 3.284
R_MINT5_seg_2884 MINT5_X_1600_Y_4480 MINT5_X_1600_Y_4800 3.284
R_MINT5_seg_2885 MINT5_X_1600_Y_4800 MINT5_X_1600_Y_5040 2.463
R_MINT5_seg_2886 MINT5_X_1600_Y_5040 MINT5_X_1600_Y_5120 821m
R_MINT5_seg_2887 MINT5_X_1600_Y_5120 MINT5_X_1600_Y_5440 3.284
R_MINT5_seg_2888 MINT5_X_1600_Y_5440 MINT5_X_1600_Y_5760 3.284
R_MINT5_seg_2889 MINT5_X_1600_Y_5760 MINT5_X_1600_Y_6080 3.284
R_MINT5_seg_2890 MINT5_X_1600_Y_6080 MINT5_X_1600_Y_6160 821m
R_MINT5_seg_2891 MINT5_X_1600_Y_6160 MINT5_X_1600_Y_6400 2.463
R_MINT5_seg_2892 MINT5_X_1600_Y_6400 MINT5_X_1600_Y_6720 3.284
R_MINT5_seg_2893 MINT5_X_1600_Y_6720 MINT5_X_1600_Y_7040 3.284
R_MINT5_seg_2894 MINT5_X_1600_Y_7040 MINT5_X_1600_Y_7280 2.463
R_MINT5_seg_2895 MINT5_X_1600_Y_7280 MINT5_X_1600_Y_7360 821m
R_MINT5_seg_2896 MINT5_X_1600_Y_7360 MINT5_X_1600_Y_7680 3.284
R_MINT5_seg_2897 MINT5_X_1600_Y_7680 MINT5_X_1600_Y_8000 3.284
R_MINT5_seg_2898 MINT5_X_1600_Y_8000 MINT5_X_1600_Y_8320 3.284
R_MINT5_seg_2899 MINT5_X_1600_Y_8320 MINT5_X_1600_Y_8400 821m
R_MINT5_seg_2900 MINT5_X_1600_Y_8400 MINT5_X_1600_Y_8640 2.463
R_MINT5_seg_2901 MINT5_X_1600_Y_8640 MINT5_X_1600_Y_8960 3.284
R_MINT5_seg_2902 MINT5_X_1600_Y_8960 MINT5_X_1600_Y_9280 3.284
R_MINT5_seg_2903 MINT5_X_1600_Y_9280 MINT5_X_1600_Y_9520 2.463
R_MINT5_seg_2904 MINT5_X_1600_Y_9520 MINT5_X_1600_Y_9600 821m
R_MINT5_seg_2905 MINT5_X_1600_Y_9600 MINT5_X_1600_Y_9920 3.284
R_MINT5_seg_2906 MINT5_X_1600_Y_9920 MINT5_X_1600_Y_10000 821m
R_MINT5_seg_2907 MINT5_X_1920_Y_0 MINT5_X_1920_Y_320 3.284
R_MINT5_seg_2908 MINT5_X_1920_Y_320 MINT5_X_1920_Y_640 3.284
R_MINT5_seg_2909 MINT5_X_1920_Y_640 MINT5_X_1920_Y_960 3.284
R_MINT5_seg_2910 MINT5_X_1920_Y_960 MINT5_X_1920_Y_1120 1.642
R_MINT5_seg_2911 MINT5_X_1920_Y_1120 MINT5_X_1920_Y_1280 1.642
R_MINT5_seg_2912 MINT5_X_1920_Y_1280 MINT5_X_1920_Y_1600 3.284
R_MINT5_seg_2913 MINT5_X_1920_Y_1600 MINT5_X_1920_Y_1920 3.284
R_MINT5_seg_2914 MINT5_X_1920_Y_1920 MINT5_X_1920_Y_2240 3.284
R_MINT5_seg_2915 MINT5_X_1920_Y_2240 MINT5_X_1920_Y_2560 3.284
R_MINT5_seg_2916 MINT5_X_1920_Y_2560 MINT5_X_1920_Y_2880 3.284
R_MINT5_seg_2917 MINT5_X_1920_Y_2880 MINT5_X_1920_Y_3200 3.284
R_MINT5_seg_2918 MINT5_X_1920_Y_3200 MINT5_X_1920_Y_3360 1.642
R_MINT5_seg_2919 MINT5_X_1920_Y_3360 MINT5_X_1920_Y_3520 1.642
R_MINT5_seg_2920 MINT5_X_1920_Y_3520 MINT5_X_1920_Y_3840 3.284
R_MINT5_seg_2921 MINT5_X_1920_Y_3840 MINT5_X_1920_Y_4160 3.284
R_MINT5_seg_2922 MINT5_X_1920_Y_4160 MINT5_X_1920_Y_4480 3.284
R_MINT5_seg_2923 MINT5_X_1920_Y_4480 MINT5_X_1920_Y_4800 3.284
R_MINT5_seg_2924 MINT5_X_1920_Y_4800 MINT5_X_1920_Y_5120 3.284
R_MINT5_seg_2925 MINT5_X_1920_Y_5120 MINT5_X_1920_Y_5440 3.284
R_MINT5_seg_2926 MINT5_X_1920_Y_5440 MINT5_X_1920_Y_5600 1.642
R_MINT5_seg_2927 MINT5_X_1920_Y_5600 MINT5_X_1920_Y_5760 1.642
R_MINT5_seg_2928 MINT5_X_1920_Y_5760 MINT5_X_1920_Y_6080 3.284
R_MINT5_seg_2929 MINT5_X_1920_Y_6080 MINT5_X_1920_Y_6400 3.284
R_MINT5_seg_2930 MINT5_X_1920_Y_6400 MINT5_X_1920_Y_6720 3.284
R_MINT5_seg_2931 MINT5_X_1920_Y_6720 MINT5_X_1920_Y_7040 3.284
R_MINT5_seg_2932 MINT5_X_1920_Y_7040 MINT5_X_1920_Y_7360 3.284
R_MINT5_seg_2933 MINT5_X_1920_Y_7360 MINT5_X_1920_Y_7680 3.284
R_MINT5_seg_2934 MINT5_X_1920_Y_7680 MINT5_X_1920_Y_7840 1.642
R_MINT5_seg_2935 MINT5_X_1920_Y_7840 MINT5_X_1920_Y_8000 1.642
R_MINT5_seg_2936 MINT5_X_1920_Y_8000 MINT5_X_1920_Y_8320 3.284
R_MINT5_seg_2937 MINT5_X_1920_Y_8320 MINT5_X_1920_Y_8640 3.284
R_MINT5_seg_2938 MINT5_X_1920_Y_8640 MINT5_X_1920_Y_8960 3.284
R_MINT5_seg_2939 MINT5_X_1920_Y_8960 MINT5_X_1920_Y_9280 3.284
R_MINT5_seg_2940 MINT5_X_1920_Y_9280 MINT5_X_1920_Y_9600 3.284
R_MINT5_seg_2941 MINT5_X_1920_Y_9600 MINT5_X_1920_Y_9920 3.284
R_MINT5_seg_2942 MINT5_X_1920_Y_9920 MINT5_X_1920_Y_10000 821m
R_MINT5_seg_2943 MINT5_X_2240_Y_0 MINT5_X_2240_Y_320 3.284
R_MINT5_seg_2944 MINT5_X_2240_Y_320 MINT5_X_2240_Y_560 2.463
R_MINT5_seg_2945 MINT5_X_2240_Y_560 MINT5_X_2240_Y_640 821m
R_MINT5_seg_2946 MINT5_X_2240_Y_640 MINT5_X_2240_Y_960 3.284
R_MINT5_seg_2947 MINT5_X_2240_Y_960 MINT5_X_2240_Y_1280 3.284
R_MINT5_seg_2948 MINT5_X_2240_Y_1280 MINT5_X_2240_Y_1600 3.284
R_MINT5_seg_2949 MINT5_X_2240_Y_1600 MINT5_X_2240_Y_1680 821m
R_MINT5_seg_2950 MINT5_X_2240_Y_1680 MINT5_X_2240_Y_1920 2.463
R_MINT5_seg_2951 MINT5_X_2240_Y_1920 MINT5_X_2240_Y_2240 3.284
R_MINT5_seg_2952 MINT5_X_2240_Y_2240 MINT5_X_2240_Y_2560 3.284
R_MINT5_seg_2953 MINT5_X_2240_Y_2560 MINT5_X_2240_Y_2800 2.463
R_MINT5_seg_2954 MINT5_X_2240_Y_2800 MINT5_X_2240_Y_2880 821m
R_MINT5_seg_2955 MINT5_X_2240_Y_2880 MINT5_X_2240_Y_3200 3.284
R_MINT5_seg_2956 MINT5_X_2240_Y_3200 MINT5_X_2240_Y_3520 3.284
R_MINT5_seg_2957 MINT5_X_2240_Y_3520 MINT5_X_2240_Y_3840 3.284
R_MINT5_seg_2958 MINT5_X_2240_Y_3840 MINT5_X_2240_Y_3920 821m
R_MINT5_seg_2959 MINT5_X_2240_Y_3920 MINT5_X_2240_Y_4160 2.463
R_MINT5_seg_2960 MINT5_X_2240_Y_4160 MINT5_X_2240_Y_4480 3.284
R_MINT5_seg_2961 MINT5_X_2240_Y_4480 MINT5_X_2240_Y_4800 3.284
R_MINT5_seg_2962 MINT5_X_2240_Y_4800 MINT5_X_2240_Y_5040 2.463
R_MINT5_seg_2963 MINT5_X_2240_Y_5040 MINT5_X_2240_Y_5120 821m
R_MINT5_seg_2964 MINT5_X_2240_Y_5120 MINT5_X_2240_Y_5440 3.284
R_MINT5_seg_2965 MINT5_X_2240_Y_5440 MINT5_X_2240_Y_5760 3.284
R_MINT5_seg_2966 MINT5_X_2240_Y_5760 MINT5_X_2240_Y_6080 3.284
R_MINT5_seg_2967 MINT5_X_2240_Y_6080 MINT5_X_2240_Y_6160 821m
R_MINT5_seg_2968 MINT5_X_2240_Y_6160 MINT5_X_2240_Y_6400 2.463
R_MINT5_seg_2969 MINT5_X_2240_Y_6400 MINT5_X_2240_Y_6720 3.284
R_MINT5_seg_2970 MINT5_X_2240_Y_6720 MINT5_X_2240_Y_7040 3.284
R_MINT5_seg_2971 MINT5_X_2240_Y_7040 MINT5_X_2240_Y_7280 2.463
R_MINT5_seg_2972 MINT5_X_2240_Y_7280 MINT5_X_2240_Y_7360 821m
R_MINT5_seg_2973 MINT5_X_2240_Y_7360 MINT5_X_2240_Y_7680 3.284
R_MINT5_seg_2974 MINT5_X_2240_Y_7680 MINT5_X_2240_Y_8000 3.284
R_MINT5_seg_2975 MINT5_X_2240_Y_8000 MINT5_X_2240_Y_8320 3.284
R_MINT5_seg_2976 MINT5_X_2240_Y_8320 MINT5_X_2240_Y_8400 821m
R_MINT5_seg_2977 MINT5_X_2240_Y_8400 MINT5_X_2240_Y_8640 2.463
R_MINT5_seg_2978 MINT5_X_2240_Y_8640 MINT5_X_2240_Y_8960 3.284
R_MINT5_seg_2979 MINT5_X_2240_Y_8960 MINT5_X_2240_Y_9280 3.284
R_MINT5_seg_2980 MINT5_X_2240_Y_9280 MINT5_X_2240_Y_9520 2.463
R_MINT5_seg_2981 MINT5_X_2240_Y_9520 MINT5_X_2240_Y_9600 821m
R_MINT5_seg_2982 MINT5_X_2240_Y_9600 MINT5_X_2240_Y_9920 3.284
R_MINT5_seg_2983 MINT5_X_2240_Y_9920 MINT5_X_2240_Y_10000 821m
R_MINT5_seg_2984 MINT5_X_2560_Y_0 MINT5_X_2560_Y_320 3.284
R_MINT5_seg_2985 MINT5_X_2560_Y_320 MINT5_X_2560_Y_640 3.284
R_MINT5_seg_2986 MINT5_X_2560_Y_640 MINT5_X_2560_Y_960 3.284
R_MINT5_seg_2987 MINT5_X_2560_Y_960 MINT5_X_2560_Y_1120 1.642
R_MINT5_seg_2988 MINT5_X_2560_Y_1120 MINT5_X_2560_Y_1280 1.642
R_MINT5_seg_2989 MINT5_X_2560_Y_1280 MINT5_X_2560_Y_1600 3.284
R_MINT5_seg_2990 MINT5_X_2560_Y_1600 MINT5_X_2560_Y_1920 3.284
R_MINT5_seg_2991 MINT5_X_2560_Y_1920 MINT5_X_2560_Y_2240 3.284
R_MINT5_seg_2992 MINT5_X_2560_Y_2240 MINT5_X_2560_Y_2560 3.284
R_MINT5_seg_2993 MINT5_X_2560_Y_2560 MINT5_X_2560_Y_2880 3.284
R_MINT5_seg_2994 MINT5_X_2560_Y_2880 MINT5_X_2560_Y_3200 3.284
R_MINT5_seg_2995 MINT5_X_2560_Y_3200 MINT5_X_2560_Y_3360 1.642
R_MINT5_seg_2996 MINT5_X_2560_Y_3360 MINT5_X_2560_Y_3520 1.642
R_MINT5_seg_2997 MINT5_X_2560_Y_3520 MINT5_X_2560_Y_3840 3.284
R_MINT5_seg_2998 MINT5_X_2560_Y_3840 MINT5_X_2560_Y_4160 3.284
R_MINT5_seg_2999 MINT5_X_2560_Y_4160 MINT5_X_2560_Y_4480 3.284
R_MINT5_seg_3000 MINT5_X_2560_Y_4480 MINT5_X_2560_Y_4800 3.284
R_MINT5_seg_3001 MINT5_X_2560_Y_4800 MINT5_X_2560_Y_5120 3.284
R_MINT5_seg_3002 MINT5_X_2560_Y_5120 MINT5_X_2560_Y_5440 3.284
R_MINT5_seg_3003 MINT5_X_2560_Y_5440 MINT5_X_2560_Y_5600 1.642
R_MINT5_seg_3004 MINT5_X_2560_Y_5600 MINT5_X_2560_Y_5760 1.642
R_MINT5_seg_3005 MINT5_X_2560_Y_5760 MINT5_X_2560_Y_6080 3.284
R_MINT5_seg_3006 MINT5_X_2560_Y_6080 MINT5_X_2560_Y_6400 3.284
R_MINT5_seg_3007 MINT5_X_2560_Y_6400 MINT5_X_2560_Y_6720 3.284
R_MINT5_seg_3008 MINT5_X_2560_Y_6720 MINT5_X_2560_Y_7040 3.284
R_MINT5_seg_3009 MINT5_X_2560_Y_7040 MINT5_X_2560_Y_7360 3.284
R_MINT5_seg_3010 MINT5_X_2560_Y_7360 MINT5_X_2560_Y_7680 3.284
R_MINT5_seg_3011 MINT5_X_2560_Y_7680 MINT5_X_2560_Y_7840 1.642
R_MINT5_seg_3012 MINT5_X_2560_Y_7840 MINT5_X_2560_Y_8000 1.642
R_MINT5_seg_3013 MINT5_X_2560_Y_8000 MINT5_X_2560_Y_8320 3.284
R_MINT5_seg_3014 MINT5_X_2560_Y_8320 MINT5_X_2560_Y_8640 3.284
R_MINT5_seg_3015 MINT5_X_2560_Y_8640 MINT5_X_2560_Y_8960 3.284
R_MINT5_seg_3016 MINT5_X_2560_Y_8960 MINT5_X_2560_Y_9280 3.284
R_MINT5_seg_3017 MINT5_X_2560_Y_9280 MINT5_X_2560_Y_9600 3.284
R_MINT5_seg_3018 MINT5_X_2560_Y_9600 MINT5_X_2560_Y_9920 3.284
R_MINT5_seg_3019 MINT5_X_2560_Y_9920 MINT5_X_2560_Y_10000 821m
R_MINT5_seg_3020 MINT5_X_2880_Y_0 MINT5_X_2880_Y_320 3.284
R_MINT5_seg_3021 MINT5_X_2880_Y_320 MINT5_X_2880_Y_560 2.463
R_MINT5_seg_3022 MINT5_X_2880_Y_560 MINT5_X_2880_Y_640 821m
R_MINT5_seg_3023 MINT5_X_2880_Y_640 MINT5_X_2880_Y_960 3.284
R_MINT5_seg_3024 MINT5_X_2880_Y_960 MINT5_X_2880_Y_1280 3.284
R_MINT5_seg_3025 MINT5_X_2880_Y_1280 MINT5_X_2880_Y_1600 3.284
R_MINT5_seg_3026 MINT5_X_2880_Y_1600 MINT5_X_2880_Y_1680 821m
R_MINT5_seg_3027 MINT5_X_2880_Y_1680 MINT5_X_2880_Y_1920 2.463
R_MINT5_seg_3028 MINT5_X_2880_Y_1920 MINT5_X_2880_Y_2240 3.284
R_MINT5_seg_3029 MINT5_X_2880_Y_2240 MINT5_X_2880_Y_2560 3.284
R_MINT5_seg_3030 MINT5_X_2880_Y_2560 MINT5_X_2880_Y_2800 2.463
R_MINT5_seg_3031 MINT5_X_2880_Y_2800 MINT5_X_2880_Y_2880 821m
R_MINT5_seg_3032 MINT5_X_2880_Y_2880 MINT5_X_2880_Y_3200 3.284
R_MINT5_seg_3033 MINT5_X_2880_Y_3200 MINT5_X_2880_Y_3520 3.284
R_MINT5_seg_3034 MINT5_X_2880_Y_3520 MINT5_X_2880_Y_3840 3.284
R_MINT5_seg_3035 MINT5_X_2880_Y_3840 MINT5_X_2880_Y_3920 821m
R_MINT5_seg_3036 MINT5_X_2880_Y_3920 MINT5_X_2880_Y_4160 2.463
R_MINT5_seg_3037 MINT5_X_2880_Y_4160 MINT5_X_2880_Y_4480 3.284
R_MINT5_seg_3038 MINT5_X_2880_Y_4480 MINT5_X_2880_Y_4800 3.284
R_MINT5_seg_3039 MINT5_X_2880_Y_4800 MINT5_X_2880_Y_5040 2.463
R_MINT5_seg_3040 MINT5_X_2880_Y_5040 MINT5_X_2880_Y_5120 821m
R_MINT5_seg_3041 MINT5_X_2880_Y_5120 MINT5_X_2880_Y_5440 3.284
R_MINT5_seg_3042 MINT5_X_2880_Y_5440 MINT5_X_2880_Y_5760 3.284
R_MINT5_seg_3043 MINT5_X_2880_Y_5760 MINT5_X_2880_Y_6080 3.284
R_MINT5_seg_3044 MINT5_X_2880_Y_6080 MINT5_X_2880_Y_6160 821m
R_MINT5_seg_3045 MINT5_X_2880_Y_6160 MINT5_X_2880_Y_6400 2.463
R_MINT5_seg_3046 MINT5_X_2880_Y_6400 MINT5_X_2880_Y_6720 3.284
R_MINT5_seg_3047 MINT5_X_2880_Y_6720 MINT5_X_2880_Y_7040 3.284
R_MINT5_seg_3048 MINT5_X_2880_Y_7040 MINT5_X_2880_Y_7280 2.463
R_MINT5_seg_3049 MINT5_X_2880_Y_7280 MINT5_X_2880_Y_7360 821m
R_MINT5_seg_3050 MINT5_X_2880_Y_7360 MINT5_X_2880_Y_7680 3.284
R_MINT5_seg_3051 MINT5_X_2880_Y_7680 MINT5_X_2880_Y_8000 3.284
R_MINT5_seg_3052 MINT5_X_2880_Y_8000 MINT5_X_2880_Y_8320 3.284
R_MINT5_seg_3053 MINT5_X_2880_Y_8320 MINT5_X_2880_Y_8400 821m
R_MINT5_seg_3054 MINT5_X_2880_Y_8400 MINT5_X_2880_Y_8640 2.463
R_MINT5_seg_3055 MINT5_X_2880_Y_8640 MINT5_X_2880_Y_8960 3.284
R_MINT5_seg_3056 MINT5_X_2880_Y_8960 MINT5_X_2880_Y_9280 3.284
R_MINT5_seg_3057 MINT5_X_2880_Y_9280 MINT5_X_2880_Y_9520 2.463
R_MINT5_seg_3058 MINT5_X_2880_Y_9520 MINT5_X_2880_Y_9600 821m
R_MINT5_seg_3059 MINT5_X_2880_Y_9600 MINT5_X_2880_Y_9920 3.284
R_MINT5_seg_3060 MINT5_X_2880_Y_9920 MINT5_X_2880_Y_10000 821m
R_MINT5_seg_3061 MINT5_X_3200_Y_0 MINT5_X_3200_Y_320 3.284
R_MINT5_seg_3062 MINT5_X_3200_Y_320 MINT5_X_3200_Y_640 3.284
R_MINT5_seg_3063 MINT5_X_3200_Y_640 MINT5_X_3200_Y_960 3.284
R_MINT5_seg_3064 MINT5_X_3200_Y_960 MINT5_X_3200_Y_1120 1.642
R_MINT5_seg_3065 MINT5_X_3200_Y_1120 MINT5_X_3200_Y_1280 1.642
R_MINT5_seg_3066 MINT5_X_3200_Y_1280 MINT5_X_3200_Y_1600 3.284
R_MINT5_seg_3067 MINT5_X_3200_Y_1600 MINT5_X_3200_Y_1920 3.284
R_MINT5_seg_3068 MINT5_X_3200_Y_1920 MINT5_X_3200_Y_2240 3.284
R_MINT5_seg_3069 MINT5_X_3200_Y_2240 MINT5_X_3200_Y_2560 3.284
R_MINT5_seg_3070 MINT5_X_3200_Y_2560 MINT5_X_3200_Y_2880 3.284
R_MINT5_seg_3071 MINT5_X_3200_Y_2880 MINT5_X_3200_Y_3200 3.284
R_MINT5_seg_3072 MINT5_X_3200_Y_3200 MINT5_X_3200_Y_3360 1.642
R_MINT5_seg_3073 MINT5_X_3200_Y_3360 MINT5_X_3200_Y_3520 1.642
R_MINT5_seg_3074 MINT5_X_3200_Y_3520 MINT5_X_3200_Y_3840 3.284
R_MINT5_seg_3075 MINT5_X_3200_Y_3840 MINT5_X_3200_Y_4160 3.284
R_MINT5_seg_3076 MINT5_X_3200_Y_4160 MINT5_X_3200_Y_4480 3.284
R_MINT5_seg_3077 MINT5_X_3200_Y_4480 MINT5_X_3200_Y_4800 3.284
R_MINT5_seg_3078 MINT5_X_3200_Y_4800 MINT5_X_3200_Y_5120 3.284
R_MINT5_seg_3079 MINT5_X_3200_Y_5120 MINT5_X_3200_Y_5440 3.284
R_MINT5_seg_3080 MINT5_X_3200_Y_5440 MINT5_X_3200_Y_5600 1.642
R_MINT5_seg_3081 MINT5_X_3200_Y_5600 MINT5_X_3200_Y_5760 1.642
R_MINT5_seg_3082 MINT5_X_3200_Y_5760 MINT5_X_3200_Y_6080 3.284
R_MINT5_seg_3083 MINT5_X_3200_Y_6080 MINT5_X_3200_Y_6400 3.284
R_MINT5_seg_3084 MINT5_X_3200_Y_6400 MINT5_X_3200_Y_6720 3.284
R_MINT5_seg_3085 MINT5_X_3200_Y_6720 MINT5_X_3200_Y_7040 3.284
R_MINT5_seg_3086 MINT5_X_3200_Y_7040 MINT5_X_3200_Y_7360 3.284
R_MINT5_seg_3087 MINT5_X_3200_Y_7360 MINT5_X_3200_Y_7680 3.284
R_MINT5_seg_3088 MINT5_X_3200_Y_7680 MINT5_X_3200_Y_7840 1.642
R_MINT5_seg_3089 MINT5_X_3200_Y_7840 MINT5_X_3200_Y_8000 1.642
R_MINT5_seg_3090 MINT5_X_3200_Y_8000 MINT5_X_3200_Y_8320 3.284
R_MINT5_seg_3091 MINT5_X_3200_Y_8320 MINT5_X_3200_Y_8640 3.284
R_MINT5_seg_3092 MINT5_X_3200_Y_8640 MINT5_X_3200_Y_8960 3.284
R_MINT5_seg_3093 MINT5_X_3200_Y_8960 MINT5_X_3200_Y_9280 3.284
R_MINT5_seg_3094 MINT5_X_3200_Y_9280 MINT5_X_3200_Y_9600 3.284
R_MINT5_seg_3095 MINT5_X_3200_Y_9600 MINT5_X_3200_Y_9920 3.284
R_MINT5_seg_3096 MINT5_X_3200_Y_9920 MINT5_X_3200_Y_10000 821m
R_MINT5_seg_3097 MINT5_X_3520_Y_0 MINT5_X_3520_Y_320 3.284
R_MINT5_seg_3098 MINT5_X_3520_Y_320 MINT5_X_3520_Y_560 2.463
R_MINT5_seg_3099 MINT5_X_3520_Y_560 MINT5_X_3520_Y_640 821m
R_MINT5_seg_3100 MINT5_X_3520_Y_640 MINT5_X_3520_Y_960 3.284
R_MINT5_seg_3101 MINT5_X_3520_Y_960 MINT5_X_3520_Y_1280 3.284
R_MINT5_seg_3102 MINT5_X_3520_Y_1280 MINT5_X_3520_Y_1600 3.284
R_MINT5_seg_3103 MINT5_X_3520_Y_1600 MINT5_X_3520_Y_1680 821m
R_MINT5_seg_3104 MINT5_X_3520_Y_1680 MINT5_X_3520_Y_1920 2.463
R_MINT5_seg_3105 MINT5_X_3520_Y_1920 MINT5_X_3520_Y_2240 3.284
R_MINT5_seg_3106 MINT5_X_3520_Y_2240 MINT5_X_3520_Y_2560 3.284
R_MINT5_seg_3107 MINT5_X_3520_Y_2560 MINT5_X_3520_Y_2800 2.463
R_MINT5_seg_3108 MINT5_X_3520_Y_2800 MINT5_X_3520_Y_2880 821m
R_MINT5_seg_3109 MINT5_X_3520_Y_2880 MINT5_X_3520_Y_3200 3.284
R_MINT5_seg_3110 MINT5_X_3520_Y_3200 MINT5_X_3520_Y_3520 3.284
R_MINT5_seg_3111 MINT5_X_3520_Y_3520 MINT5_X_3520_Y_3840 3.284
R_MINT5_seg_3112 MINT5_X_3520_Y_3840 MINT5_X_3520_Y_3920 821m
R_MINT5_seg_3113 MINT5_X_3520_Y_3920 MINT5_X_3520_Y_4160 2.463
R_MINT5_seg_3114 MINT5_X_3520_Y_4160 MINT5_X_3520_Y_4480 3.284
R_MINT5_seg_3115 MINT5_X_3520_Y_4480 MINT5_X_3520_Y_4800 3.284
R_MINT5_seg_3116 MINT5_X_3520_Y_4800 MINT5_X_3520_Y_5040 2.463
R_MINT5_seg_3117 MINT5_X_3520_Y_5040 MINT5_X_3520_Y_5120 821m
R_MINT5_seg_3118 MINT5_X_3520_Y_5120 MINT5_X_3520_Y_5440 3.284
R_MINT5_seg_3119 MINT5_X_3520_Y_5440 MINT5_X_3520_Y_5760 3.284
R_MINT5_seg_3120 MINT5_X_3520_Y_5760 MINT5_X_3520_Y_6080 3.284
R_MINT5_seg_3121 MINT5_X_3520_Y_6080 MINT5_X_3520_Y_6160 821m
R_MINT5_seg_3122 MINT5_X_3520_Y_6160 MINT5_X_3520_Y_6400 2.463
R_MINT5_seg_3123 MINT5_X_3520_Y_6400 MINT5_X_3520_Y_6720 3.284
R_MINT5_seg_3124 MINT5_X_3520_Y_6720 MINT5_X_3520_Y_7040 3.284
R_MINT5_seg_3125 MINT5_X_3520_Y_7040 MINT5_X_3520_Y_7280 2.463
R_MINT5_seg_3126 MINT5_X_3520_Y_7280 MINT5_X_3520_Y_7360 821m
R_MINT5_seg_3127 MINT5_X_3520_Y_7360 MINT5_X_3520_Y_7680 3.284
R_MINT5_seg_3128 MINT5_X_3520_Y_7680 MINT5_X_3520_Y_8000 3.284
R_MINT5_seg_3129 MINT5_X_3520_Y_8000 MINT5_X_3520_Y_8320 3.284
R_MINT5_seg_3130 MINT5_X_3520_Y_8320 MINT5_X_3520_Y_8400 821m
R_MINT5_seg_3131 MINT5_X_3520_Y_8400 MINT5_X_3520_Y_8640 2.463
R_MINT5_seg_3132 MINT5_X_3520_Y_8640 MINT5_X_3520_Y_8960 3.284
R_MINT5_seg_3133 MINT5_X_3520_Y_8960 MINT5_X_3520_Y_9280 3.284
R_MINT5_seg_3134 MINT5_X_3520_Y_9280 MINT5_X_3520_Y_9520 2.463
R_MINT5_seg_3135 MINT5_X_3520_Y_9520 MINT5_X_3520_Y_9600 821m
R_MINT5_seg_3136 MINT5_X_3520_Y_9600 MINT5_X_3520_Y_9920 3.284
R_MINT5_seg_3137 MINT5_X_3520_Y_9920 MINT5_X_3520_Y_10000 821m
R_MINT5_seg_3138 MINT5_X_3840_Y_0 MINT5_X_3840_Y_320 3.284
R_MINT5_seg_3139 MINT5_X_3840_Y_320 MINT5_X_3840_Y_640 3.284
R_MINT5_seg_3140 MINT5_X_3840_Y_640 MINT5_X_3840_Y_960 3.284
R_MINT5_seg_3141 MINT5_X_3840_Y_960 MINT5_X_3840_Y_1120 1.642
R_MINT5_seg_3142 MINT5_X_3840_Y_1120 MINT5_X_3840_Y_1280 1.642
R_MINT5_seg_3143 MINT5_X_3840_Y_1280 MINT5_X_3840_Y_1600 3.284
R_MINT5_seg_3144 MINT5_X_3840_Y_1600 MINT5_X_3840_Y_1920 3.284
R_MINT5_seg_3145 MINT5_X_3840_Y_1920 MINT5_X_3840_Y_2240 3.284
R_MINT5_seg_3146 MINT5_X_3840_Y_2240 MINT5_X_3840_Y_2560 3.284
R_MINT5_seg_3147 MINT5_X_3840_Y_2560 MINT5_X_3840_Y_2880 3.284
R_MINT5_seg_3148 MINT5_X_3840_Y_2880 MINT5_X_3840_Y_3200 3.284
R_MINT5_seg_3149 MINT5_X_3840_Y_3200 MINT5_X_3840_Y_3360 1.642
R_MINT5_seg_3150 MINT5_X_3840_Y_3360 MINT5_X_3840_Y_3520 1.642
R_MINT5_seg_3151 MINT5_X_3840_Y_3520 MINT5_X_3840_Y_3840 3.284
R_MINT5_seg_3152 MINT5_X_3840_Y_3840 MINT5_X_3840_Y_4160 3.284
R_MINT5_seg_3153 MINT5_X_3840_Y_4160 MINT5_X_3840_Y_4480 3.284
R_MINT5_seg_3154 MINT5_X_3840_Y_4480 MINT5_X_3840_Y_4800 3.284
R_MINT5_seg_3155 MINT5_X_3840_Y_4800 MINT5_X_3840_Y_5120 3.284
R_MINT5_seg_3156 MINT5_X_3840_Y_5120 MINT5_X_3840_Y_5440 3.284
R_MINT5_seg_3157 MINT5_X_3840_Y_5440 MINT5_X_3840_Y_5600 1.642
R_MINT5_seg_3158 MINT5_X_3840_Y_5600 MINT5_X_3840_Y_5760 1.642
R_MINT5_seg_3159 MINT5_X_3840_Y_5760 MINT5_X_3840_Y_6080 3.284
R_MINT5_seg_3160 MINT5_X_3840_Y_6080 MINT5_X_3840_Y_6400 3.284
R_MINT5_seg_3161 MINT5_X_3840_Y_6400 MINT5_X_3840_Y_6720 3.284
R_MINT5_seg_3162 MINT5_X_3840_Y_6720 MINT5_X_3840_Y_7040 3.284
R_MINT5_seg_3163 MINT5_X_3840_Y_7040 MINT5_X_3840_Y_7360 3.284
R_MINT5_seg_3164 MINT5_X_3840_Y_7360 MINT5_X_3840_Y_7680 3.284
R_MINT5_seg_3165 MINT5_X_3840_Y_7680 MINT5_X_3840_Y_7840 1.642
R_MINT5_seg_3166 MINT5_X_3840_Y_7840 MINT5_X_3840_Y_8000 1.642
R_MINT5_seg_3167 MINT5_X_3840_Y_8000 MINT5_X_3840_Y_8320 3.284
R_MINT5_seg_3168 MINT5_X_3840_Y_8320 MINT5_X_3840_Y_8640 3.284
R_MINT5_seg_3169 MINT5_X_3840_Y_8640 MINT5_X_3840_Y_8960 3.284
R_MINT5_seg_3170 MINT5_X_3840_Y_8960 MINT5_X_3840_Y_9280 3.284
R_MINT5_seg_3171 MINT5_X_3840_Y_9280 MINT5_X_3840_Y_9600 3.284
R_MINT5_seg_3172 MINT5_X_3840_Y_9600 MINT5_X_3840_Y_9920 3.284
R_MINT5_seg_3173 MINT5_X_3840_Y_9920 MINT5_X_3840_Y_10000 821m
R_MINT5_seg_3174 MINT5_X_4160_Y_0 MINT5_X_4160_Y_320 3.284
R_MINT5_seg_3175 MINT5_X_4160_Y_320 MINT5_X_4160_Y_560 2.463
R_MINT5_seg_3176 MINT5_X_4160_Y_560 MINT5_X_4160_Y_640 821m
R_MINT5_seg_3177 MINT5_X_4160_Y_640 MINT5_X_4160_Y_960 3.284
R_MINT5_seg_3178 MINT5_X_4160_Y_960 MINT5_X_4160_Y_1280 3.284
R_MINT5_seg_3179 MINT5_X_4160_Y_1280 MINT5_X_4160_Y_1600 3.284
R_MINT5_seg_3180 MINT5_X_4160_Y_1600 MINT5_X_4160_Y_1680 821m
R_MINT5_seg_3181 MINT5_X_4160_Y_1680 MINT5_X_4160_Y_1920 2.463
R_MINT5_seg_3182 MINT5_X_4160_Y_1920 MINT5_X_4160_Y_2240 3.284
R_MINT5_seg_3183 MINT5_X_4160_Y_2240 MINT5_X_4160_Y_2560 3.284
R_MINT5_seg_3184 MINT5_X_4160_Y_2560 MINT5_X_4160_Y_2800 2.463
R_MINT5_seg_3185 MINT5_X_4160_Y_2800 MINT5_X_4160_Y_2880 821m
R_MINT5_seg_3186 MINT5_X_4160_Y_2880 MINT5_X_4160_Y_3200 3.284
R_MINT5_seg_3187 MINT5_X_4160_Y_3200 MINT5_X_4160_Y_3520 3.284
R_MINT5_seg_3188 MINT5_X_4160_Y_3520 MINT5_X_4160_Y_3840 3.284
R_MINT5_seg_3189 MINT5_X_4160_Y_3840 MINT5_X_4160_Y_3920 821m
R_MINT5_seg_3190 MINT5_X_4160_Y_3920 MINT5_X_4160_Y_4160 2.463
R_MINT5_seg_3191 MINT5_X_4160_Y_4160 MINT5_X_4160_Y_4480 3.284
R_MINT5_seg_3192 MINT5_X_4160_Y_4480 MINT5_X_4160_Y_4800 3.284
R_MINT5_seg_3193 MINT5_X_4160_Y_4800 MINT5_X_4160_Y_5040 2.463
R_MINT5_seg_3194 MINT5_X_4160_Y_5040 MINT5_X_4160_Y_5120 821m
R_MINT5_seg_3195 MINT5_X_4160_Y_5120 MINT5_X_4160_Y_5440 3.284
R_MINT5_seg_3196 MINT5_X_4160_Y_5440 MINT5_X_4160_Y_5760 3.284
R_MINT5_seg_3197 MINT5_X_4160_Y_5760 MINT5_X_4160_Y_6080 3.284
R_MINT5_seg_3198 MINT5_X_4160_Y_6080 MINT5_X_4160_Y_6160 821m
R_MINT5_seg_3199 MINT5_X_4160_Y_6160 MINT5_X_4160_Y_6400 2.463
R_MINT5_seg_3200 MINT5_X_4160_Y_6400 MINT5_X_4160_Y_6720 3.284
R_MINT5_seg_3201 MINT5_X_4160_Y_6720 MINT5_X_4160_Y_7040 3.284
R_MINT5_seg_3202 MINT5_X_4160_Y_7040 MINT5_X_4160_Y_7280 2.463
R_MINT5_seg_3203 MINT5_X_4160_Y_7280 MINT5_X_4160_Y_7360 821m
R_MINT5_seg_3204 MINT5_X_4160_Y_7360 MINT5_X_4160_Y_7680 3.284
R_MINT5_seg_3205 MINT5_X_4160_Y_7680 MINT5_X_4160_Y_8000 3.284
R_MINT5_seg_3206 MINT5_X_4160_Y_8000 MINT5_X_4160_Y_8320 3.284
R_MINT5_seg_3207 MINT5_X_4160_Y_8320 MINT5_X_4160_Y_8400 821m
R_MINT5_seg_3208 MINT5_X_4160_Y_8400 MINT5_X_4160_Y_8640 2.463
R_MINT5_seg_3209 MINT5_X_4160_Y_8640 MINT5_X_4160_Y_8960 3.284
R_MINT5_seg_3210 MINT5_X_4160_Y_8960 MINT5_X_4160_Y_9280 3.284
R_MINT5_seg_3211 MINT5_X_4160_Y_9280 MINT5_X_4160_Y_9520 2.463
R_MINT5_seg_3212 MINT5_X_4160_Y_9520 MINT5_X_4160_Y_9600 821m
R_MINT5_seg_3213 MINT5_X_4160_Y_9600 MINT5_X_4160_Y_9920 3.284
R_MINT5_seg_3214 MINT5_X_4160_Y_9920 MINT5_X_4160_Y_10000 821m
R_MINT5_seg_3215 MINT5_X_4480_Y_0 MINT5_X_4480_Y_320 3.284
R_MINT5_seg_3216 MINT5_X_4480_Y_320 MINT5_X_4480_Y_640 3.284
R_MINT5_seg_3217 MINT5_X_4480_Y_640 MINT5_X_4480_Y_960 3.284
R_MINT5_seg_3218 MINT5_X_4480_Y_960 MINT5_X_4480_Y_1120 1.642
R_MINT5_seg_3219 MINT5_X_4480_Y_1120 MINT5_X_4480_Y_1280 1.642
R_MINT5_seg_3220 MINT5_X_4480_Y_1280 MINT5_X_4480_Y_1600 3.284
R_MINT5_seg_3221 MINT5_X_4480_Y_1600 MINT5_X_4480_Y_1920 3.284
R_MINT5_seg_3222 MINT5_X_4480_Y_1920 MINT5_X_4480_Y_2240 3.284
R_MINT5_seg_3223 MINT5_X_4480_Y_2240 MINT5_X_4480_Y_2560 3.284
R_MINT5_seg_3224 MINT5_X_4480_Y_2560 MINT5_X_4480_Y_2880 3.284
R_MINT5_seg_3225 MINT5_X_4480_Y_2880 MINT5_X_4480_Y_3200 3.284
R_MINT5_seg_3226 MINT5_X_4480_Y_3200 MINT5_X_4480_Y_3360 1.642
R_MINT5_seg_3227 MINT5_X_4480_Y_3360 MINT5_X_4480_Y_3520 1.642
R_MINT5_seg_3228 MINT5_X_4480_Y_3520 MINT5_X_4480_Y_3840 3.284
R_MINT5_seg_3229 MINT5_X_4480_Y_3840 MINT5_X_4480_Y_4160 3.284
R_MINT5_seg_3230 MINT5_X_4480_Y_4160 MINT5_X_4480_Y_4480 3.284
R_MINT5_seg_3231 MINT5_X_4480_Y_4480 MINT5_X_4480_Y_4800 3.284
R_MINT5_seg_3232 MINT5_X_4480_Y_4800 MINT5_X_4480_Y_5120 3.284
R_MINT5_seg_3233 MINT5_X_4480_Y_5120 MINT5_X_4480_Y_5440 3.284
R_MINT5_seg_3234 MINT5_X_4480_Y_5440 MINT5_X_4480_Y_5600 1.642
R_MINT5_seg_3235 MINT5_X_4480_Y_5600 MINT5_X_4480_Y_5760 1.642
R_MINT5_seg_3236 MINT5_X_4480_Y_5760 MINT5_X_4480_Y_6080 3.284
R_MINT5_seg_3237 MINT5_X_4480_Y_6080 MINT5_X_4480_Y_6400 3.284
R_MINT5_seg_3238 MINT5_X_4480_Y_6400 MINT5_X_4480_Y_6720 3.284
R_MINT5_seg_3239 MINT5_X_4480_Y_6720 MINT5_X_4480_Y_7040 3.284
R_MINT5_seg_3240 MINT5_X_4480_Y_7040 MINT5_X_4480_Y_7360 3.284
R_MINT5_seg_3241 MINT5_X_4480_Y_7360 MINT5_X_4480_Y_7680 3.284
R_MINT5_seg_3242 MINT5_X_4480_Y_7680 MINT5_X_4480_Y_7840 1.642
R_MINT5_seg_3243 MINT5_X_4480_Y_7840 MINT5_X_4480_Y_8000 1.642
R_MINT5_seg_3244 MINT5_X_4480_Y_8000 MINT5_X_4480_Y_8320 3.284
R_MINT5_seg_3245 MINT5_X_4480_Y_8320 MINT5_X_4480_Y_8640 3.284
R_MINT5_seg_3246 MINT5_X_4480_Y_8640 MINT5_X_4480_Y_8960 3.284
R_MINT5_seg_3247 MINT5_X_4480_Y_8960 MINT5_X_4480_Y_9280 3.284
R_MINT5_seg_3248 MINT5_X_4480_Y_9280 MINT5_X_4480_Y_9600 3.284
R_MINT5_seg_3249 MINT5_X_4480_Y_9600 MINT5_X_4480_Y_9920 3.284
R_MINT5_seg_3250 MINT5_X_4480_Y_9920 MINT5_X_4480_Y_10000 821m
R_MINT5_seg_3251 MINT5_X_4800_Y_0 MINT5_X_4800_Y_320 3.284
R_MINT5_seg_3252 MINT5_X_4800_Y_320 MINT5_X_4800_Y_560 2.463
R_MINT5_seg_3253 MINT5_X_4800_Y_560 MINT5_X_4800_Y_640 821m
R_MINT5_seg_3254 MINT5_X_4800_Y_640 MINT5_X_4800_Y_960 3.284
R_MINT5_seg_3255 MINT5_X_4800_Y_960 MINT5_X_4800_Y_1280 3.284
R_MINT5_seg_3256 MINT5_X_4800_Y_1280 MINT5_X_4800_Y_1600 3.284
R_MINT5_seg_3257 MINT5_X_4800_Y_1600 MINT5_X_4800_Y_1680 821m
R_MINT5_seg_3258 MINT5_X_4800_Y_1680 MINT5_X_4800_Y_1920 2.463
R_MINT5_seg_3259 MINT5_X_4800_Y_1920 MINT5_X_4800_Y_2240 3.284
R_MINT5_seg_3260 MINT5_X_4800_Y_2240 MINT5_X_4800_Y_2560 3.284
R_MINT5_seg_3261 MINT5_X_4800_Y_2560 MINT5_X_4800_Y_2800 2.463
R_MINT5_seg_3262 MINT5_X_4800_Y_2800 MINT5_X_4800_Y_2880 821m
R_MINT5_seg_3263 MINT5_X_4800_Y_2880 MINT5_X_4800_Y_3200 3.284
R_MINT5_seg_3264 MINT5_X_4800_Y_3200 MINT5_X_4800_Y_3520 3.284
R_MINT5_seg_3265 MINT5_X_4800_Y_3520 MINT5_X_4800_Y_3840 3.284
R_MINT5_seg_3266 MINT5_X_4800_Y_3840 MINT5_X_4800_Y_3920 821m
R_MINT5_seg_3267 MINT5_X_4800_Y_3920 MINT5_X_4800_Y_4160 2.463
R_MINT5_seg_3268 MINT5_X_4800_Y_4160 MINT5_X_4800_Y_4480 3.284
R_MINT5_seg_3269 MINT5_X_4800_Y_4480 MINT5_X_4800_Y_4800 3.284
R_MINT5_seg_3270 MINT5_X_4800_Y_4800 MINT5_X_4800_Y_5040 2.463
R_MINT5_seg_3271 MINT5_X_4800_Y_5040 MINT5_X_4800_Y_5120 821m
R_MINT5_seg_3272 MINT5_X_4800_Y_5120 MINT5_X_4800_Y_5440 3.284
R_MINT5_seg_3273 MINT5_X_4800_Y_5440 MINT5_X_4800_Y_5760 3.284
R_MINT5_seg_3274 MINT5_X_4800_Y_5760 MINT5_X_4800_Y_6080 3.284
R_MINT5_seg_3275 MINT5_X_4800_Y_6080 MINT5_X_4800_Y_6160 821m
R_MINT5_seg_3276 MINT5_X_4800_Y_6160 MINT5_X_4800_Y_6400 2.463
R_MINT5_seg_3277 MINT5_X_4800_Y_6400 MINT5_X_4800_Y_6720 3.284
R_MINT5_seg_3278 MINT5_X_4800_Y_6720 MINT5_X_4800_Y_7040 3.284
R_MINT5_seg_3279 MINT5_X_4800_Y_7040 MINT5_X_4800_Y_7280 2.463
R_MINT5_seg_3280 MINT5_X_4800_Y_7280 MINT5_X_4800_Y_7360 821m
R_MINT5_seg_3281 MINT5_X_4800_Y_7360 MINT5_X_4800_Y_7680 3.284
R_MINT5_seg_3282 MINT5_X_4800_Y_7680 MINT5_X_4800_Y_8000 3.284
R_MINT5_seg_3283 MINT5_X_4800_Y_8000 MINT5_X_4800_Y_8320 3.284
R_MINT5_seg_3284 MINT5_X_4800_Y_8320 MINT5_X_4800_Y_8400 821m
R_MINT5_seg_3285 MINT5_X_4800_Y_8400 MINT5_X_4800_Y_8640 2.463
R_MINT5_seg_3286 MINT5_X_4800_Y_8640 MINT5_X_4800_Y_8960 3.284
R_MINT5_seg_3287 MINT5_X_4800_Y_8960 MINT5_X_4800_Y_9280 3.284
R_MINT5_seg_3288 MINT5_X_4800_Y_9280 MINT5_X_4800_Y_9520 2.463
R_MINT5_seg_3289 MINT5_X_4800_Y_9520 MINT5_X_4800_Y_9600 821m
R_MINT5_seg_3290 MINT5_X_4800_Y_9600 MINT5_X_4800_Y_9920 3.284
R_MINT5_seg_3291 MINT5_X_4800_Y_9920 MINT5_X_4800_Y_10000 821m
R_MINT5_seg_3292 MINT5_X_5120_Y_0 MINT5_X_5120_Y_320 3.284
R_MINT5_seg_3293 MINT5_X_5120_Y_320 MINT5_X_5120_Y_640 3.284
R_MINT5_seg_3294 MINT5_X_5120_Y_640 MINT5_X_5120_Y_960 3.284
R_MINT5_seg_3295 MINT5_X_5120_Y_960 MINT5_X_5120_Y_1120 1.642
R_MINT5_seg_3296 MINT5_X_5120_Y_1120 MINT5_X_5120_Y_1280 1.642
R_MINT5_seg_3297 MINT5_X_5120_Y_1280 MINT5_X_5120_Y_1600 3.284
R_MINT5_seg_3298 MINT5_X_5120_Y_1600 MINT5_X_5120_Y_1920 3.284
R_MINT5_seg_3299 MINT5_X_5120_Y_1920 MINT5_X_5120_Y_2240 3.284
R_MINT5_seg_3300 MINT5_X_5120_Y_2240 MINT5_X_5120_Y_2560 3.284
R_MINT5_seg_3301 MINT5_X_5120_Y_2560 MINT5_X_5120_Y_2880 3.284
R_MINT5_seg_3302 MINT5_X_5120_Y_2880 MINT5_X_5120_Y_3200 3.284
R_MINT5_seg_3303 MINT5_X_5120_Y_3200 MINT5_X_5120_Y_3360 1.642
R_MINT5_seg_3304 MINT5_X_5120_Y_3360 MINT5_X_5120_Y_3520 1.642
R_MINT5_seg_3305 MINT5_X_5120_Y_3520 MINT5_X_5120_Y_3840 3.284
R_MINT5_seg_3306 MINT5_X_5120_Y_3840 MINT5_X_5120_Y_4160 3.284
R_MINT5_seg_3307 MINT5_X_5120_Y_4160 MINT5_X_5120_Y_4480 3.284
R_MINT5_seg_3308 MINT5_X_5120_Y_4480 MINT5_X_5120_Y_4800 3.284
R_MINT5_seg_3309 MINT5_X_5120_Y_4800 MINT5_X_5120_Y_5120 3.284
R_MINT5_seg_3310 MINT5_X_5120_Y_5120 MINT5_X_5120_Y_5440 3.284
R_MINT5_seg_3311 MINT5_X_5120_Y_5440 MINT5_X_5120_Y_5600 1.642
R_MINT5_seg_3312 MINT5_X_5120_Y_5600 MINT5_X_5120_Y_5760 1.642
R_MINT5_seg_3313 MINT5_X_5120_Y_5760 MINT5_X_5120_Y_6080 3.284
R_MINT5_seg_3314 MINT5_X_5120_Y_6080 MINT5_X_5120_Y_6400 3.284
R_MINT5_seg_3315 MINT5_X_5120_Y_6400 MINT5_X_5120_Y_6720 3.284
R_MINT5_seg_3316 MINT5_X_5120_Y_6720 MINT5_X_5120_Y_7040 3.284
R_MINT5_seg_3317 MINT5_X_5120_Y_7040 MINT5_X_5120_Y_7360 3.284
R_MINT5_seg_3318 MINT5_X_5120_Y_7360 MINT5_X_5120_Y_7680 3.284
R_MINT5_seg_3319 MINT5_X_5120_Y_7680 MINT5_X_5120_Y_7840 1.642
R_MINT5_seg_3320 MINT5_X_5120_Y_7840 MINT5_X_5120_Y_8000 1.642
R_MINT5_seg_3321 MINT5_X_5120_Y_8000 MINT5_X_5120_Y_8320 3.284
R_MINT5_seg_3322 MINT5_X_5120_Y_8320 MINT5_X_5120_Y_8640 3.284
R_MINT5_seg_3323 MINT5_X_5120_Y_8640 MINT5_X_5120_Y_8960 3.284
R_MINT5_seg_3324 MINT5_X_5120_Y_8960 MINT5_X_5120_Y_9280 3.284
R_MINT5_seg_3325 MINT5_X_5120_Y_9280 MINT5_X_5120_Y_9600 3.284
R_MINT5_seg_3326 MINT5_X_5120_Y_9600 MINT5_X_5120_Y_9920 3.284
R_MINT5_seg_3327 MINT5_X_5120_Y_9920 MINT5_X_5120_Y_10000 821m
R_MINT5_seg_3328 MINT5_X_5440_Y_0 MINT5_X_5440_Y_320 3.284
R_MINT5_seg_3329 MINT5_X_5440_Y_320 MINT5_X_5440_Y_560 2.463
R_MINT5_seg_3330 MINT5_X_5440_Y_560 MINT5_X_5440_Y_640 821m
R_MINT5_seg_3331 MINT5_X_5440_Y_640 MINT5_X_5440_Y_960 3.284
R_MINT5_seg_3332 MINT5_X_5440_Y_960 MINT5_X_5440_Y_1280 3.284
R_MINT5_seg_3333 MINT5_X_5440_Y_1280 MINT5_X_5440_Y_1600 3.284
R_MINT5_seg_3334 MINT5_X_5440_Y_1600 MINT5_X_5440_Y_1680 821m
R_MINT5_seg_3335 MINT5_X_5440_Y_1680 MINT5_X_5440_Y_1920 2.463
R_MINT5_seg_3336 MINT5_X_5440_Y_1920 MINT5_X_5440_Y_2240 3.284
R_MINT5_seg_3337 MINT5_X_5440_Y_2240 MINT5_X_5440_Y_2560 3.284
R_MINT5_seg_3338 MINT5_X_5440_Y_2560 MINT5_X_5440_Y_2800 2.463
R_MINT5_seg_3339 MINT5_X_5440_Y_2800 MINT5_X_5440_Y_2880 821m
R_MINT5_seg_3340 MINT5_X_5440_Y_2880 MINT5_X_5440_Y_3200 3.284
R_MINT5_seg_3341 MINT5_X_5440_Y_3200 MINT5_X_5440_Y_3520 3.284
R_MINT5_seg_3342 MINT5_X_5440_Y_3520 MINT5_X_5440_Y_3840 3.284
R_MINT5_seg_3343 MINT5_X_5440_Y_3840 MINT5_X_5440_Y_3920 821m
R_MINT5_seg_3344 MINT5_X_5440_Y_3920 MINT5_X_5440_Y_4160 2.463
R_MINT5_seg_3345 MINT5_X_5440_Y_4160 MINT5_X_5440_Y_4480 3.284
R_MINT5_seg_3346 MINT5_X_5440_Y_4480 MINT5_X_5440_Y_4800 3.284
R_MINT5_seg_3347 MINT5_X_5440_Y_4800 MINT5_X_5440_Y_5040 2.463
R_MINT5_seg_3348 MINT5_X_5440_Y_5040 MINT5_X_5440_Y_5120 821m
R_MINT5_seg_3349 MINT5_X_5440_Y_5120 MINT5_X_5440_Y_5440 3.284
R_MINT5_seg_3350 MINT5_X_5440_Y_5440 MINT5_X_5440_Y_5760 3.284
R_MINT5_seg_3351 MINT5_X_5440_Y_5760 MINT5_X_5440_Y_6080 3.284
R_MINT5_seg_3352 MINT5_X_5440_Y_6080 MINT5_X_5440_Y_6160 821m
R_MINT5_seg_3353 MINT5_X_5440_Y_6160 MINT5_X_5440_Y_6400 2.463
R_MINT5_seg_3354 MINT5_X_5440_Y_6400 MINT5_X_5440_Y_6720 3.284
R_MINT5_seg_3355 MINT5_X_5440_Y_6720 MINT5_X_5440_Y_7040 3.284
R_MINT5_seg_3356 MINT5_X_5440_Y_7040 MINT5_X_5440_Y_7280 2.463
R_MINT5_seg_3357 MINT5_X_5440_Y_7280 MINT5_X_5440_Y_7360 821m
R_MINT5_seg_3358 MINT5_X_5440_Y_7360 MINT5_X_5440_Y_7680 3.284
R_MINT5_seg_3359 MINT5_X_5440_Y_7680 MINT5_X_5440_Y_8000 3.284
R_MINT5_seg_3360 MINT5_X_5440_Y_8000 MINT5_X_5440_Y_8320 3.284
R_MINT5_seg_3361 MINT5_X_5440_Y_8320 MINT5_X_5440_Y_8400 821m
R_MINT5_seg_3362 MINT5_X_5440_Y_8400 MINT5_X_5440_Y_8640 2.463
R_MINT5_seg_3363 MINT5_X_5440_Y_8640 MINT5_X_5440_Y_8960 3.284
R_MINT5_seg_3364 MINT5_X_5440_Y_8960 MINT5_X_5440_Y_9280 3.284
R_MINT5_seg_3365 MINT5_X_5440_Y_9280 MINT5_X_5440_Y_9520 2.463
R_MINT5_seg_3366 MINT5_X_5440_Y_9520 MINT5_X_5440_Y_9600 821m
R_MINT5_seg_3367 MINT5_X_5440_Y_9600 MINT5_X_5440_Y_9920 3.284
R_MINT5_seg_3368 MINT5_X_5440_Y_9920 MINT5_X_5440_Y_10000 821m
R_MINT5_seg_3369 MINT5_X_5760_Y_0 MINT5_X_5760_Y_320 3.284
R_MINT5_seg_3370 MINT5_X_5760_Y_320 MINT5_X_5760_Y_640 3.284
R_MINT5_seg_3371 MINT5_X_5760_Y_640 MINT5_X_5760_Y_960 3.284
R_MINT5_seg_3372 MINT5_X_5760_Y_960 MINT5_X_5760_Y_1120 1.642
R_MINT5_seg_3373 MINT5_X_5760_Y_1120 MINT5_X_5760_Y_1280 1.642
R_MINT5_seg_3374 MINT5_X_5760_Y_1280 MINT5_X_5760_Y_1600 3.284
R_MINT5_seg_3375 MINT5_X_5760_Y_1600 MINT5_X_5760_Y_1920 3.284
R_MINT5_seg_3376 MINT5_X_5760_Y_1920 MINT5_X_5760_Y_2240 3.284
R_MINT5_seg_3377 MINT5_X_5760_Y_2240 MINT5_X_5760_Y_2560 3.284
R_MINT5_seg_3378 MINT5_X_5760_Y_2560 MINT5_X_5760_Y_2880 3.284
R_MINT5_seg_3379 MINT5_X_5760_Y_2880 MINT5_X_5760_Y_3200 3.284
R_MINT5_seg_3380 MINT5_X_5760_Y_3200 MINT5_X_5760_Y_3360 1.642
R_MINT5_seg_3381 MINT5_X_5760_Y_3360 MINT5_X_5760_Y_3520 1.642
R_MINT5_seg_3382 MINT5_X_5760_Y_3520 MINT5_X_5760_Y_3840 3.284
R_MINT5_seg_3383 MINT5_X_5760_Y_3840 MINT5_X_5760_Y_4160 3.284
R_MINT5_seg_3384 MINT5_X_5760_Y_4160 MINT5_X_5760_Y_4480 3.284
R_MINT5_seg_3385 MINT5_X_5760_Y_4480 MINT5_X_5760_Y_4800 3.284
R_MINT5_seg_3386 MINT5_X_5760_Y_4800 MINT5_X_5760_Y_5120 3.284
R_MINT5_seg_3387 MINT5_X_5760_Y_5120 MINT5_X_5760_Y_5440 3.284
R_MINT5_seg_3388 MINT5_X_5760_Y_5440 MINT5_X_5760_Y_5600 1.642
R_MINT5_seg_3389 MINT5_X_5760_Y_5600 MINT5_X_5760_Y_5760 1.642
R_MINT5_seg_3390 MINT5_X_5760_Y_5760 MINT5_X_5760_Y_6080 3.284
R_MINT5_seg_3391 MINT5_X_5760_Y_6080 MINT5_X_5760_Y_6400 3.284
R_MINT5_seg_3392 MINT5_X_5760_Y_6400 MINT5_X_5760_Y_6720 3.284
R_MINT5_seg_3393 MINT5_X_5760_Y_6720 MINT5_X_5760_Y_7040 3.284
R_MINT5_seg_3394 MINT5_X_5760_Y_7040 MINT5_X_5760_Y_7360 3.284
R_MINT5_seg_3395 MINT5_X_5760_Y_7360 MINT5_X_5760_Y_7680 3.284
R_MINT5_seg_3396 MINT5_X_5760_Y_7680 MINT5_X_5760_Y_7840 1.642
R_MINT5_seg_3397 MINT5_X_5760_Y_7840 MINT5_X_5760_Y_8000 1.642
R_MINT5_seg_3398 MINT5_X_5760_Y_8000 MINT5_X_5760_Y_8320 3.284
R_MINT5_seg_3399 MINT5_X_5760_Y_8320 MINT5_X_5760_Y_8640 3.284
R_MINT5_seg_3400 MINT5_X_5760_Y_8640 MINT5_X_5760_Y_8960 3.284
R_MINT5_seg_3401 MINT5_X_5760_Y_8960 MINT5_X_5760_Y_9280 3.284
R_MINT5_seg_3402 MINT5_X_5760_Y_9280 MINT5_X_5760_Y_9600 3.284
R_MINT5_seg_3403 MINT5_X_5760_Y_9600 MINT5_X_5760_Y_9920 3.284
R_MINT5_seg_3404 MINT5_X_5760_Y_9920 MINT5_X_5760_Y_10000 821m
R_MINT5_seg_3405 MINT5_X_6080_Y_0 MINT5_X_6080_Y_320 3.284
R_MINT5_seg_3406 MINT5_X_6080_Y_320 MINT5_X_6080_Y_560 2.463
R_MINT5_seg_3407 MINT5_X_6080_Y_560 MINT5_X_6080_Y_640 821m
R_MINT5_seg_3408 MINT5_X_6080_Y_640 MINT5_X_6080_Y_960 3.284
R_MINT5_seg_3409 MINT5_X_6080_Y_960 MINT5_X_6080_Y_1280 3.284
R_MINT5_seg_3410 MINT5_X_6080_Y_1280 MINT5_X_6080_Y_1600 3.284
R_MINT5_seg_3411 MINT5_X_6080_Y_1600 MINT5_X_6080_Y_1680 821m
R_MINT5_seg_3412 MINT5_X_6080_Y_1680 MINT5_X_6080_Y_1920 2.463
R_MINT5_seg_3413 MINT5_X_6080_Y_1920 MINT5_X_6080_Y_2240 3.284
R_MINT5_seg_3414 MINT5_X_6080_Y_2240 MINT5_X_6080_Y_2560 3.284
R_MINT5_seg_3415 MINT5_X_6080_Y_2560 MINT5_X_6080_Y_2800 2.463
R_MINT5_seg_3416 MINT5_X_6080_Y_2800 MINT5_X_6080_Y_2880 821m
R_MINT5_seg_3417 MINT5_X_6080_Y_2880 MINT5_X_6080_Y_3200 3.284
R_MINT5_seg_3418 MINT5_X_6080_Y_3200 MINT5_X_6080_Y_3520 3.284
R_MINT5_seg_3419 MINT5_X_6080_Y_3520 MINT5_X_6080_Y_3840 3.284
R_MINT5_seg_3420 MINT5_X_6080_Y_3840 MINT5_X_6080_Y_3920 821m
R_MINT5_seg_3421 MINT5_X_6080_Y_3920 MINT5_X_6080_Y_4160 2.463
R_MINT5_seg_3422 MINT5_X_6080_Y_4160 MINT5_X_6080_Y_4480 3.284
R_MINT5_seg_3423 MINT5_X_6080_Y_4480 MINT5_X_6080_Y_4800 3.284
R_MINT5_seg_3424 MINT5_X_6080_Y_4800 MINT5_X_6080_Y_5040 2.463
R_MINT5_seg_3425 MINT5_X_6080_Y_5040 MINT5_X_6080_Y_5120 821m
R_MINT5_seg_3426 MINT5_X_6080_Y_5120 MINT5_X_6080_Y_5440 3.284
R_MINT5_seg_3427 MINT5_X_6080_Y_5440 MINT5_X_6080_Y_5760 3.284
R_MINT5_seg_3428 MINT5_X_6080_Y_5760 MINT5_X_6080_Y_6080 3.284
R_MINT5_seg_3429 MINT5_X_6080_Y_6080 MINT5_X_6080_Y_6160 821m
R_MINT5_seg_3430 MINT5_X_6080_Y_6160 MINT5_X_6080_Y_6400 2.463
R_MINT5_seg_3431 MINT5_X_6080_Y_6400 MINT5_X_6080_Y_6720 3.284
R_MINT5_seg_3432 MINT5_X_6080_Y_6720 MINT5_X_6080_Y_7040 3.284
R_MINT5_seg_3433 MINT5_X_6080_Y_7040 MINT5_X_6080_Y_7280 2.463
R_MINT5_seg_3434 MINT5_X_6080_Y_7280 MINT5_X_6080_Y_7360 821m
R_MINT5_seg_3435 MINT5_X_6080_Y_7360 MINT5_X_6080_Y_7680 3.284
R_MINT5_seg_3436 MINT5_X_6080_Y_7680 MINT5_X_6080_Y_8000 3.284
R_MINT5_seg_3437 MINT5_X_6080_Y_8000 MINT5_X_6080_Y_8320 3.284
R_MINT5_seg_3438 MINT5_X_6080_Y_8320 MINT5_X_6080_Y_8400 821m
R_MINT5_seg_3439 MINT5_X_6080_Y_8400 MINT5_X_6080_Y_8640 2.463
R_MINT5_seg_3440 MINT5_X_6080_Y_8640 MINT5_X_6080_Y_8960 3.284
R_MINT5_seg_3441 MINT5_X_6080_Y_8960 MINT5_X_6080_Y_9280 3.284
R_MINT5_seg_3442 MINT5_X_6080_Y_9280 MINT5_X_6080_Y_9520 2.463
R_MINT5_seg_3443 MINT5_X_6080_Y_9520 MINT5_X_6080_Y_9600 821m
R_MINT5_seg_3444 MINT5_X_6080_Y_9600 MINT5_X_6080_Y_9920 3.284
R_MINT5_seg_3445 MINT5_X_6080_Y_9920 MINT5_X_6080_Y_10000 821m
R_MINT5_seg_3446 MINT5_X_6400_Y_0 MINT5_X_6400_Y_320 3.284
R_MINT5_seg_3447 MINT5_X_6400_Y_320 MINT5_X_6400_Y_640 3.284
R_MINT5_seg_3448 MINT5_X_6400_Y_640 MINT5_X_6400_Y_960 3.284
R_MINT5_seg_3449 MINT5_X_6400_Y_960 MINT5_X_6400_Y_1120 1.642
R_MINT5_seg_3450 MINT5_X_6400_Y_1120 MINT5_X_6400_Y_1280 1.642
R_MINT5_seg_3451 MINT5_X_6400_Y_1280 MINT5_X_6400_Y_1600 3.284
R_MINT5_seg_3452 MINT5_X_6400_Y_1600 MINT5_X_6400_Y_1920 3.284
R_MINT5_seg_3453 MINT5_X_6400_Y_1920 MINT5_X_6400_Y_2240 3.284
R_MINT5_seg_3454 MINT5_X_6400_Y_2240 MINT5_X_6400_Y_2560 3.284
R_MINT5_seg_3455 MINT5_X_6400_Y_2560 MINT5_X_6400_Y_2880 3.284
R_MINT5_seg_3456 MINT5_X_6400_Y_2880 MINT5_X_6400_Y_3200 3.284
R_MINT5_seg_3457 MINT5_X_6400_Y_3200 MINT5_X_6400_Y_3360 1.642
R_MINT5_seg_3458 MINT5_X_6400_Y_3360 MINT5_X_6400_Y_3520 1.642
R_MINT5_seg_3459 MINT5_X_6400_Y_3520 MINT5_X_6400_Y_3840 3.284
R_MINT5_seg_3460 MINT5_X_6400_Y_3840 MINT5_X_6400_Y_4160 3.284
R_MINT5_seg_3461 MINT5_X_6400_Y_4160 MINT5_X_6400_Y_4480 3.284
R_MINT5_seg_3462 MINT5_X_6400_Y_4480 MINT5_X_6400_Y_4800 3.284
R_MINT5_seg_3463 MINT5_X_6400_Y_4800 MINT5_X_6400_Y_5120 3.284
R_MINT5_seg_3464 MINT5_X_6400_Y_5120 MINT5_X_6400_Y_5440 3.284
R_MINT5_seg_3465 MINT5_X_6400_Y_5440 MINT5_X_6400_Y_5600 1.642
R_MINT5_seg_3466 MINT5_X_6400_Y_5600 MINT5_X_6400_Y_5760 1.642
R_MINT5_seg_3467 MINT5_X_6400_Y_5760 MINT5_X_6400_Y_6080 3.284
R_MINT5_seg_3468 MINT5_X_6400_Y_6080 MINT5_X_6400_Y_6400 3.284
R_MINT5_seg_3469 MINT5_X_6400_Y_6400 MINT5_X_6400_Y_6720 3.284
R_MINT5_seg_3470 MINT5_X_6400_Y_6720 MINT5_X_6400_Y_7040 3.284
R_MINT5_seg_3471 MINT5_X_6400_Y_7040 MINT5_X_6400_Y_7360 3.284
R_MINT5_seg_3472 MINT5_X_6400_Y_7360 MINT5_X_6400_Y_7680 3.284
R_MINT5_seg_3473 MINT5_X_6400_Y_7680 MINT5_X_6400_Y_7840 1.642
R_MINT5_seg_3474 MINT5_X_6400_Y_7840 MINT5_X_6400_Y_8000 1.642
R_MINT5_seg_3475 MINT5_X_6400_Y_8000 MINT5_X_6400_Y_8320 3.284
R_MINT5_seg_3476 MINT5_X_6400_Y_8320 MINT5_X_6400_Y_8640 3.284
R_MINT5_seg_3477 MINT5_X_6400_Y_8640 MINT5_X_6400_Y_8960 3.284
R_MINT5_seg_3478 MINT5_X_6400_Y_8960 MINT5_X_6400_Y_9280 3.284
R_MINT5_seg_3479 MINT5_X_6400_Y_9280 MINT5_X_6400_Y_9600 3.284
R_MINT5_seg_3480 MINT5_X_6400_Y_9600 MINT5_X_6400_Y_9920 3.284
R_MINT5_seg_3481 MINT5_X_6400_Y_9920 MINT5_X_6400_Y_10000 821m
R_MINT5_seg_3482 MINT5_X_6720_Y_0 MINT5_X_6720_Y_320 3.284
R_MINT5_seg_3483 MINT5_X_6720_Y_320 MINT5_X_6720_Y_560 2.463
R_MINT5_seg_3484 MINT5_X_6720_Y_560 MINT5_X_6720_Y_640 821m
R_MINT5_seg_3485 MINT5_X_6720_Y_640 MINT5_X_6720_Y_960 3.284
R_MINT5_seg_3486 MINT5_X_6720_Y_960 MINT5_X_6720_Y_1280 3.284
R_MINT5_seg_3487 MINT5_X_6720_Y_1280 MINT5_X_6720_Y_1600 3.284
R_MINT5_seg_3488 MINT5_X_6720_Y_1600 MINT5_X_6720_Y_1680 821m
R_MINT5_seg_3489 MINT5_X_6720_Y_1680 MINT5_X_6720_Y_1920 2.463
R_MINT5_seg_3490 MINT5_X_6720_Y_1920 MINT5_X_6720_Y_2240 3.284
R_MINT5_seg_3491 MINT5_X_6720_Y_2240 MINT5_X_6720_Y_2560 3.284
R_MINT5_seg_3492 MINT5_X_6720_Y_2560 MINT5_X_6720_Y_2800 2.463
R_MINT5_seg_3493 MINT5_X_6720_Y_2800 MINT5_X_6720_Y_2880 821m
R_MINT5_seg_3494 MINT5_X_6720_Y_2880 MINT5_X_6720_Y_3200 3.284
R_MINT5_seg_3495 MINT5_X_6720_Y_3200 MINT5_X_6720_Y_3520 3.284
R_MINT5_seg_3496 MINT5_X_6720_Y_3520 MINT5_X_6720_Y_3840 3.284
R_MINT5_seg_3497 MINT5_X_6720_Y_3840 MINT5_X_6720_Y_3920 821m
R_MINT5_seg_3498 MINT5_X_6720_Y_3920 MINT5_X_6720_Y_4160 2.463
R_MINT5_seg_3499 MINT5_X_6720_Y_4160 MINT5_X_6720_Y_4480 3.284
R_MINT5_seg_3500 MINT5_X_6720_Y_4480 MINT5_X_6720_Y_4800 3.284
R_MINT5_seg_3501 MINT5_X_6720_Y_4800 MINT5_X_6720_Y_5040 2.463
R_MINT5_seg_3502 MINT5_X_6720_Y_5040 MINT5_X_6720_Y_5120 821m
R_MINT5_seg_3503 MINT5_X_6720_Y_5120 MINT5_X_6720_Y_5440 3.284
R_MINT5_seg_3504 MINT5_X_6720_Y_5440 MINT5_X_6720_Y_5760 3.284
R_MINT5_seg_3505 MINT5_X_6720_Y_5760 MINT5_X_6720_Y_6080 3.284
R_MINT5_seg_3506 MINT5_X_6720_Y_6080 MINT5_X_6720_Y_6160 821m
R_MINT5_seg_3507 MINT5_X_6720_Y_6160 MINT5_X_6720_Y_6400 2.463
R_MINT5_seg_3508 MINT5_X_6720_Y_6400 MINT5_X_6720_Y_6720 3.284
R_MINT5_seg_3509 MINT5_X_6720_Y_6720 MINT5_X_6720_Y_7040 3.284
R_MINT5_seg_3510 MINT5_X_6720_Y_7040 MINT5_X_6720_Y_7280 2.463
R_MINT5_seg_3511 MINT5_X_6720_Y_7280 MINT5_X_6720_Y_7360 821m
R_MINT5_seg_3512 MINT5_X_6720_Y_7360 MINT5_X_6720_Y_7680 3.284
R_MINT5_seg_3513 MINT5_X_6720_Y_7680 MINT5_X_6720_Y_8000 3.284
R_MINT5_seg_3514 MINT5_X_6720_Y_8000 MINT5_X_6720_Y_8320 3.284
R_MINT5_seg_3515 MINT5_X_6720_Y_8320 MINT5_X_6720_Y_8400 821m
R_MINT5_seg_3516 MINT5_X_6720_Y_8400 MINT5_X_6720_Y_8640 2.463
R_MINT5_seg_3517 MINT5_X_6720_Y_8640 MINT5_X_6720_Y_8960 3.284
R_MINT5_seg_3518 MINT5_X_6720_Y_8960 MINT5_X_6720_Y_9280 3.284
R_MINT5_seg_3519 MINT5_X_6720_Y_9280 MINT5_X_6720_Y_9520 2.463
R_MINT5_seg_3520 MINT5_X_6720_Y_9520 MINT5_X_6720_Y_9600 821m
R_MINT5_seg_3521 MINT5_X_6720_Y_9600 MINT5_X_6720_Y_9920 3.284
R_MINT5_seg_3522 MINT5_X_6720_Y_9920 MINT5_X_6720_Y_10000 821m
R_MINT5_seg_3523 MINT5_X_7040_Y_0 MINT5_X_7040_Y_320 3.284
R_MINT5_seg_3524 MINT5_X_7040_Y_320 MINT5_X_7040_Y_640 3.284
R_MINT5_seg_3525 MINT5_X_7040_Y_640 MINT5_X_7040_Y_960 3.284
R_MINT5_seg_3526 MINT5_X_7040_Y_960 MINT5_X_7040_Y_1120 1.642
R_MINT5_seg_3527 MINT5_X_7040_Y_1120 MINT5_X_7040_Y_1280 1.642
R_MINT5_seg_3528 MINT5_X_7040_Y_1280 MINT5_X_7040_Y_1600 3.284
R_MINT5_seg_3529 MINT5_X_7040_Y_1600 MINT5_X_7040_Y_1920 3.284
R_MINT5_seg_3530 MINT5_X_7040_Y_1920 MINT5_X_7040_Y_2240 3.284
R_MINT5_seg_3531 MINT5_X_7040_Y_2240 MINT5_X_7040_Y_2560 3.284
R_MINT5_seg_3532 MINT5_X_7040_Y_2560 MINT5_X_7040_Y_2880 3.284
R_MINT5_seg_3533 MINT5_X_7040_Y_2880 MINT5_X_7040_Y_3200 3.284
R_MINT5_seg_3534 MINT5_X_7040_Y_3200 MINT5_X_7040_Y_3360 1.642
R_MINT5_seg_3535 MINT5_X_7040_Y_3360 MINT5_X_7040_Y_3520 1.642
R_MINT5_seg_3536 MINT5_X_7040_Y_3520 MINT5_X_7040_Y_3840 3.284
R_MINT5_seg_3537 MINT5_X_7040_Y_3840 MINT5_X_7040_Y_4160 3.284
R_MINT5_seg_3538 MINT5_X_7040_Y_4160 MINT5_X_7040_Y_4480 3.284
R_MINT5_seg_3539 MINT5_X_7040_Y_4480 MINT5_X_7040_Y_4800 3.284
R_MINT5_seg_3540 MINT5_X_7040_Y_4800 MINT5_X_7040_Y_5120 3.284
R_MINT5_seg_3541 MINT5_X_7040_Y_5120 MINT5_X_7040_Y_5440 3.284
R_MINT5_seg_3542 MINT5_X_7040_Y_5440 MINT5_X_7040_Y_5600 1.642
R_MINT5_seg_3543 MINT5_X_7040_Y_5600 MINT5_X_7040_Y_5760 1.642
R_MINT5_seg_3544 MINT5_X_7040_Y_5760 MINT5_X_7040_Y_6080 3.284
R_MINT5_seg_3545 MINT5_X_7040_Y_6080 MINT5_X_7040_Y_6400 3.284
R_MINT5_seg_3546 MINT5_X_7040_Y_6400 MINT5_X_7040_Y_6720 3.284
R_MINT5_seg_3547 MINT5_X_7040_Y_6720 MINT5_X_7040_Y_7040 3.284
R_MINT5_seg_3548 MINT5_X_7040_Y_7040 MINT5_X_7040_Y_7360 3.284
R_MINT5_seg_3549 MINT5_X_7040_Y_7360 MINT5_X_7040_Y_7680 3.284
R_MINT5_seg_3550 MINT5_X_7040_Y_7680 MINT5_X_7040_Y_7840 1.642
R_MINT5_seg_3551 MINT5_X_7040_Y_7840 MINT5_X_7040_Y_8000 1.642
R_MINT5_seg_3552 MINT5_X_7040_Y_8000 MINT5_X_7040_Y_8320 3.284
R_MINT5_seg_3553 MINT5_X_7040_Y_8320 MINT5_X_7040_Y_8640 3.284
R_MINT5_seg_3554 MINT5_X_7040_Y_8640 MINT5_X_7040_Y_8960 3.284
R_MINT5_seg_3555 MINT5_X_7040_Y_8960 MINT5_X_7040_Y_9280 3.284
R_MINT5_seg_3556 MINT5_X_7040_Y_9280 MINT5_X_7040_Y_9600 3.284
R_MINT5_seg_3557 MINT5_X_7040_Y_9600 MINT5_X_7040_Y_9920 3.284
R_MINT5_seg_3558 MINT5_X_7040_Y_9920 MINT5_X_7040_Y_10000 821m
R_MINT5_seg_3559 MINT5_X_7360_Y_0 MINT5_X_7360_Y_320 3.284
R_MINT5_seg_3560 MINT5_X_7360_Y_320 MINT5_X_7360_Y_560 2.463
R_MINT5_seg_3561 MINT5_X_7360_Y_560 MINT5_X_7360_Y_640 821m
R_MINT5_seg_3562 MINT5_X_7360_Y_640 MINT5_X_7360_Y_960 3.284
R_MINT5_seg_3563 MINT5_X_7360_Y_960 MINT5_X_7360_Y_1280 3.284
R_MINT5_seg_3564 MINT5_X_7360_Y_1280 MINT5_X_7360_Y_1600 3.284
R_MINT5_seg_3565 MINT5_X_7360_Y_1600 MINT5_X_7360_Y_1680 821m
R_MINT5_seg_3566 MINT5_X_7360_Y_1680 MINT5_X_7360_Y_1920 2.463
R_MINT5_seg_3567 MINT5_X_7360_Y_1920 MINT5_X_7360_Y_2240 3.284
R_MINT5_seg_3568 MINT5_X_7360_Y_2240 MINT5_X_7360_Y_2560 3.284
R_MINT5_seg_3569 MINT5_X_7360_Y_2560 MINT5_X_7360_Y_2800 2.463
R_MINT5_seg_3570 MINT5_X_7360_Y_2800 MINT5_X_7360_Y_2880 821m
R_MINT5_seg_3571 MINT5_X_7360_Y_2880 MINT5_X_7360_Y_3200 3.284
R_MINT5_seg_3572 MINT5_X_7360_Y_3200 MINT5_X_7360_Y_3520 3.284
R_MINT5_seg_3573 MINT5_X_7360_Y_3520 MINT5_X_7360_Y_3840 3.284
R_MINT5_seg_3574 MINT5_X_7360_Y_3840 MINT5_X_7360_Y_3920 821m
R_MINT5_seg_3575 MINT5_X_7360_Y_3920 MINT5_X_7360_Y_4160 2.463
R_MINT5_seg_3576 MINT5_X_7360_Y_4160 MINT5_X_7360_Y_4480 3.284
R_MINT5_seg_3577 MINT5_X_7360_Y_4480 MINT5_X_7360_Y_4800 3.284
R_MINT5_seg_3578 MINT5_X_7360_Y_4800 MINT5_X_7360_Y_5040 2.463
R_MINT5_seg_3579 MINT5_X_7360_Y_5040 MINT5_X_7360_Y_5120 821m
R_MINT5_seg_3580 MINT5_X_7360_Y_5120 MINT5_X_7360_Y_5440 3.284
R_MINT5_seg_3581 MINT5_X_7360_Y_5440 MINT5_X_7360_Y_5760 3.284
R_MINT5_seg_3582 MINT5_X_7360_Y_5760 MINT5_X_7360_Y_6080 3.284
R_MINT5_seg_3583 MINT5_X_7360_Y_6080 MINT5_X_7360_Y_6160 821m
R_MINT5_seg_3584 MINT5_X_7360_Y_6160 MINT5_X_7360_Y_6400 2.463
R_MINT5_seg_3585 MINT5_X_7360_Y_6400 MINT5_X_7360_Y_6720 3.284
R_MINT5_seg_3586 MINT5_X_7360_Y_6720 MINT5_X_7360_Y_7040 3.284
R_MINT5_seg_3587 MINT5_X_7360_Y_7040 MINT5_X_7360_Y_7280 2.463
R_MINT5_seg_3588 MINT5_X_7360_Y_7280 MINT5_X_7360_Y_7360 821m
R_MINT5_seg_3589 MINT5_X_7360_Y_7360 MINT5_X_7360_Y_7680 3.284
R_MINT5_seg_3590 MINT5_X_7360_Y_7680 MINT5_X_7360_Y_8000 3.284
R_MINT5_seg_3591 MINT5_X_7360_Y_8000 MINT5_X_7360_Y_8320 3.284
R_MINT5_seg_3592 MINT5_X_7360_Y_8320 MINT5_X_7360_Y_8400 821m
R_MINT5_seg_3593 MINT5_X_7360_Y_8400 MINT5_X_7360_Y_8640 2.463
R_MINT5_seg_3594 MINT5_X_7360_Y_8640 MINT5_X_7360_Y_8960 3.284
R_MINT5_seg_3595 MINT5_X_7360_Y_8960 MINT5_X_7360_Y_9280 3.284
R_MINT5_seg_3596 MINT5_X_7360_Y_9280 MINT5_X_7360_Y_9520 2.463
R_MINT5_seg_3597 MINT5_X_7360_Y_9520 MINT5_X_7360_Y_9600 821m
R_MINT5_seg_3598 MINT5_X_7360_Y_9600 MINT5_X_7360_Y_9920 3.284
R_MINT5_seg_3599 MINT5_X_7360_Y_9920 MINT5_X_7360_Y_10000 821m
R_MINT5_seg_3600 MINT5_X_7680_Y_0 MINT5_X_7680_Y_320 3.284
R_MINT5_seg_3601 MINT5_X_7680_Y_320 MINT5_X_7680_Y_640 3.284
R_MINT5_seg_3602 MINT5_X_7680_Y_640 MINT5_X_7680_Y_960 3.284
R_MINT5_seg_3603 MINT5_X_7680_Y_960 MINT5_X_7680_Y_1120 1.642
R_MINT5_seg_3604 MINT5_X_7680_Y_1120 MINT5_X_7680_Y_1280 1.642
R_MINT5_seg_3605 MINT5_X_7680_Y_1280 MINT5_X_7680_Y_1600 3.284
R_MINT5_seg_3606 MINT5_X_7680_Y_1600 MINT5_X_7680_Y_1920 3.284
R_MINT5_seg_3607 MINT5_X_7680_Y_1920 MINT5_X_7680_Y_2240 3.284
R_MINT5_seg_3608 MINT5_X_7680_Y_2240 MINT5_X_7680_Y_2560 3.284
R_MINT5_seg_3609 MINT5_X_7680_Y_2560 MINT5_X_7680_Y_2880 3.284
R_MINT5_seg_3610 MINT5_X_7680_Y_2880 MINT5_X_7680_Y_3200 3.284
R_MINT5_seg_3611 MINT5_X_7680_Y_3200 MINT5_X_7680_Y_3360 1.642
R_MINT5_seg_3612 MINT5_X_7680_Y_3360 MINT5_X_7680_Y_3520 1.642
R_MINT5_seg_3613 MINT5_X_7680_Y_3520 MINT5_X_7680_Y_3840 3.284
R_MINT5_seg_3614 MINT5_X_7680_Y_3840 MINT5_X_7680_Y_4160 3.284
R_MINT5_seg_3615 MINT5_X_7680_Y_4160 MINT5_X_7680_Y_4480 3.284
R_MINT5_seg_3616 MINT5_X_7680_Y_4480 MINT5_X_7680_Y_4800 3.284
R_MINT5_seg_3617 MINT5_X_7680_Y_4800 MINT5_X_7680_Y_5120 3.284
R_MINT5_seg_3618 MINT5_X_7680_Y_5120 MINT5_X_7680_Y_5440 3.284
R_MINT5_seg_3619 MINT5_X_7680_Y_5440 MINT5_X_7680_Y_5600 1.642
R_MINT5_seg_3620 MINT5_X_7680_Y_5600 MINT5_X_7680_Y_5760 1.642
R_MINT5_seg_3621 MINT5_X_7680_Y_5760 MINT5_X_7680_Y_6080 3.284
R_MINT5_seg_3622 MINT5_X_7680_Y_6080 MINT5_X_7680_Y_6400 3.284
R_MINT5_seg_3623 MINT5_X_7680_Y_6400 MINT5_X_7680_Y_6720 3.284
R_MINT5_seg_3624 MINT5_X_7680_Y_6720 MINT5_X_7680_Y_7040 3.284
R_MINT5_seg_3625 MINT5_X_7680_Y_7040 MINT5_X_7680_Y_7360 3.284
R_MINT5_seg_3626 MINT5_X_7680_Y_7360 MINT5_X_7680_Y_7680 3.284
R_MINT5_seg_3627 MINT5_X_7680_Y_7680 MINT5_X_7680_Y_7840 1.642
R_MINT5_seg_3628 MINT5_X_7680_Y_7840 MINT5_X_7680_Y_8000 1.642
R_MINT5_seg_3629 MINT5_X_7680_Y_8000 MINT5_X_7680_Y_8320 3.284
R_MINT5_seg_3630 MINT5_X_7680_Y_8320 MINT5_X_7680_Y_8640 3.284
R_MINT5_seg_3631 MINT5_X_7680_Y_8640 MINT5_X_7680_Y_8960 3.284
R_MINT5_seg_3632 MINT5_X_7680_Y_8960 MINT5_X_7680_Y_9280 3.284
R_MINT5_seg_3633 MINT5_X_7680_Y_9280 MINT5_X_7680_Y_9600 3.284
R_MINT5_seg_3634 MINT5_X_7680_Y_9600 MINT5_X_7680_Y_9920 3.284
R_MINT5_seg_3635 MINT5_X_7680_Y_9920 MINT5_X_7680_Y_10000 821m
R_MINT5_seg_3636 MINT5_X_8000_Y_0 MINT5_X_8000_Y_320 3.284
R_MINT5_seg_3637 MINT5_X_8000_Y_320 MINT5_X_8000_Y_560 2.463
R_MINT5_seg_3638 MINT5_X_8000_Y_560 MINT5_X_8000_Y_640 821m
R_MINT5_seg_3639 MINT5_X_8000_Y_640 MINT5_X_8000_Y_960 3.284
R_MINT5_seg_3640 MINT5_X_8000_Y_960 MINT5_X_8000_Y_1280 3.284
R_MINT5_seg_3641 MINT5_X_8000_Y_1280 MINT5_X_8000_Y_1600 3.284
R_MINT5_seg_3642 MINT5_X_8000_Y_1600 MINT5_X_8000_Y_1680 821m
R_MINT5_seg_3643 MINT5_X_8000_Y_1680 MINT5_X_8000_Y_1920 2.463
R_MINT5_seg_3644 MINT5_X_8000_Y_1920 MINT5_X_8000_Y_2240 3.284
R_MINT5_seg_3645 MINT5_X_8000_Y_2240 MINT5_X_8000_Y_2560 3.284
R_MINT5_seg_3646 MINT5_X_8000_Y_2560 MINT5_X_8000_Y_2800 2.463
R_MINT5_seg_3647 MINT5_X_8000_Y_2800 MINT5_X_8000_Y_2880 821m
R_MINT5_seg_3648 MINT5_X_8000_Y_2880 MINT5_X_8000_Y_3200 3.284
R_MINT5_seg_3649 MINT5_X_8000_Y_3200 MINT5_X_8000_Y_3520 3.284
R_MINT5_seg_3650 MINT5_X_8000_Y_3520 MINT5_X_8000_Y_3840 3.284
R_MINT5_seg_3651 MINT5_X_8000_Y_3840 MINT5_X_8000_Y_3920 821m
R_MINT5_seg_3652 MINT5_X_8000_Y_3920 MINT5_X_8000_Y_4160 2.463
R_MINT5_seg_3653 MINT5_X_8000_Y_4160 MINT5_X_8000_Y_4480 3.284
R_MINT5_seg_3654 MINT5_X_8000_Y_4480 MINT5_X_8000_Y_4800 3.284
R_MINT5_seg_3655 MINT5_X_8000_Y_4800 MINT5_X_8000_Y_5040 2.463
R_MINT5_seg_3656 MINT5_X_8000_Y_5040 MINT5_X_8000_Y_5120 821m
R_MINT5_seg_3657 MINT5_X_8000_Y_5120 MINT5_X_8000_Y_5440 3.284
R_MINT5_seg_3658 MINT5_X_8000_Y_5440 MINT5_X_8000_Y_5760 3.284
R_MINT5_seg_3659 MINT5_X_8000_Y_5760 MINT5_X_8000_Y_6080 3.284
R_MINT5_seg_3660 MINT5_X_8000_Y_6080 MINT5_X_8000_Y_6160 821m
R_MINT5_seg_3661 MINT5_X_8000_Y_6160 MINT5_X_8000_Y_6400 2.463
R_MINT5_seg_3662 MINT5_X_8000_Y_6400 MINT5_X_8000_Y_6720 3.284
R_MINT5_seg_3663 MINT5_X_8000_Y_6720 MINT5_X_8000_Y_7040 3.284
R_MINT5_seg_3664 MINT5_X_8000_Y_7040 MINT5_X_8000_Y_7280 2.463
R_MINT5_seg_3665 MINT5_X_8000_Y_7280 MINT5_X_8000_Y_7360 821m
R_MINT5_seg_3666 MINT5_X_8000_Y_7360 MINT5_X_8000_Y_7680 3.284
R_MINT5_seg_3667 MINT5_X_8000_Y_7680 MINT5_X_8000_Y_8000 3.284
R_MINT5_seg_3668 MINT5_X_8000_Y_8000 MINT5_X_8000_Y_8320 3.284
R_MINT5_seg_3669 MINT5_X_8000_Y_8320 MINT5_X_8000_Y_8400 821m
R_MINT5_seg_3670 MINT5_X_8000_Y_8400 MINT5_X_8000_Y_8640 2.463
R_MINT5_seg_3671 MINT5_X_8000_Y_8640 MINT5_X_8000_Y_8960 3.284
R_MINT5_seg_3672 MINT5_X_8000_Y_8960 MINT5_X_8000_Y_9280 3.284
R_MINT5_seg_3673 MINT5_X_8000_Y_9280 MINT5_X_8000_Y_9520 2.463
R_MINT5_seg_3674 MINT5_X_8000_Y_9520 MINT5_X_8000_Y_9600 821m
R_MINT5_seg_3675 MINT5_X_8000_Y_9600 MINT5_X_8000_Y_9920 3.284
R_MINT5_seg_3676 MINT5_X_8000_Y_9920 MINT5_X_8000_Y_10000 821m
R_MINT5_seg_3677 MINT5_X_8320_Y_0 MINT5_X_8320_Y_320 3.284
R_MINT5_seg_3678 MINT5_X_8320_Y_320 MINT5_X_8320_Y_640 3.284
R_MINT5_seg_3679 MINT5_X_8320_Y_640 MINT5_X_8320_Y_960 3.284
R_MINT5_seg_3680 MINT5_X_8320_Y_960 MINT5_X_8320_Y_1120 1.642
R_MINT5_seg_3681 MINT5_X_8320_Y_1120 MINT5_X_8320_Y_1280 1.642
R_MINT5_seg_3682 MINT5_X_8320_Y_1280 MINT5_X_8320_Y_1600 3.284
R_MINT5_seg_3683 MINT5_X_8320_Y_1600 MINT5_X_8320_Y_1920 3.284
R_MINT5_seg_3684 MINT5_X_8320_Y_1920 MINT5_X_8320_Y_2240 3.284
R_MINT5_seg_3685 MINT5_X_8320_Y_2240 MINT5_X_8320_Y_2560 3.284
R_MINT5_seg_3686 MINT5_X_8320_Y_2560 MINT5_X_8320_Y_2880 3.284
R_MINT5_seg_3687 MINT5_X_8320_Y_2880 MINT5_X_8320_Y_3200 3.284
R_MINT5_seg_3688 MINT5_X_8320_Y_3200 MINT5_X_8320_Y_3360 1.642
R_MINT5_seg_3689 MINT5_X_8320_Y_3360 MINT5_X_8320_Y_3520 1.642
R_MINT5_seg_3690 MINT5_X_8320_Y_3520 MINT5_X_8320_Y_3840 3.284
R_MINT5_seg_3691 MINT5_X_8320_Y_3840 MINT5_X_8320_Y_4160 3.284
R_MINT5_seg_3692 MINT5_X_8320_Y_4160 MINT5_X_8320_Y_4480 3.284
R_MINT5_seg_3693 MINT5_X_8320_Y_4480 MINT5_X_8320_Y_4800 3.284
R_MINT5_seg_3694 MINT5_X_8320_Y_4800 MINT5_X_8320_Y_5120 3.284
R_MINT5_seg_3695 MINT5_X_8320_Y_5120 MINT5_X_8320_Y_5440 3.284
R_MINT5_seg_3696 MINT5_X_8320_Y_5440 MINT5_X_8320_Y_5600 1.642
R_MINT5_seg_3697 MINT5_X_8320_Y_5600 MINT5_X_8320_Y_5760 1.642
R_MINT5_seg_3698 MINT5_X_8320_Y_5760 MINT5_X_8320_Y_6080 3.284
R_MINT5_seg_3699 MINT5_X_8320_Y_6080 MINT5_X_8320_Y_6400 3.284
R_MINT5_seg_3700 MINT5_X_8320_Y_6400 MINT5_X_8320_Y_6720 3.284
R_MINT5_seg_3701 MINT5_X_8320_Y_6720 MINT5_X_8320_Y_7040 3.284
R_MINT5_seg_3702 MINT5_X_8320_Y_7040 MINT5_X_8320_Y_7360 3.284
R_MINT5_seg_3703 MINT5_X_8320_Y_7360 MINT5_X_8320_Y_7680 3.284
R_MINT5_seg_3704 MINT5_X_8320_Y_7680 MINT5_X_8320_Y_7840 1.642
R_MINT5_seg_3705 MINT5_X_8320_Y_7840 MINT5_X_8320_Y_8000 1.642
R_MINT5_seg_3706 MINT5_X_8320_Y_8000 MINT5_X_8320_Y_8320 3.284
R_MINT5_seg_3707 MINT5_X_8320_Y_8320 MINT5_X_8320_Y_8640 3.284
R_MINT5_seg_3708 MINT5_X_8320_Y_8640 MINT5_X_8320_Y_8960 3.284
R_MINT5_seg_3709 MINT5_X_8320_Y_8960 MINT5_X_8320_Y_9280 3.284
R_MINT5_seg_3710 MINT5_X_8320_Y_9280 MINT5_X_8320_Y_9600 3.284
R_MINT5_seg_3711 MINT5_X_8320_Y_9600 MINT5_X_8320_Y_9920 3.284
R_MINT5_seg_3712 MINT5_X_8320_Y_9920 MINT5_X_8320_Y_10000 821m
R_MINT5_seg_3713 MINT5_X_8640_Y_0 MINT5_X_8640_Y_320 3.284
R_MINT5_seg_3714 MINT5_X_8640_Y_320 MINT5_X_8640_Y_560 2.463
R_MINT5_seg_3715 MINT5_X_8640_Y_560 MINT5_X_8640_Y_640 821m
R_MINT5_seg_3716 MINT5_X_8640_Y_640 MINT5_X_8640_Y_960 3.284
R_MINT5_seg_3717 MINT5_X_8640_Y_960 MINT5_X_8640_Y_1280 3.284
R_MINT5_seg_3718 MINT5_X_8640_Y_1280 MINT5_X_8640_Y_1600 3.284
R_MINT5_seg_3719 MINT5_X_8640_Y_1600 MINT5_X_8640_Y_1680 821m
R_MINT5_seg_3720 MINT5_X_8640_Y_1680 MINT5_X_8640_Y_1920 2.463
R_MINT5_seg_3721 MINT5_X_8640_Y_1920 MINT5_X_8640_Y_2240 3.284
R_MINT5_seg_3722 MINT5_X_8640_Y_2240 MINT5_X_8640_Y_2560 3.284
R_MINT5_seg_3723 MINT5_X_8640_Y_2560 MINT5_X_8640_Y_2800 2.463
R_MINT5_seg_3724 MINT5_X_8640_Y_2800 MINT5_X_8640_Y_2880 821m
R_MINT5_seg_3725 MINT5_X_8640_Y_2880 MINT5_X_8640_Y_3200 3.284
R_MINT5_seg_3726 MINT5_X_8640_Y_3200 MINT5_X_8640_Y_3520 3.284
R_MINT5_seg_3727 MINT5_X_8640_Y_3520 MINT5_X_8640_Y_3840 3.284
R_MINT5_seg_3728 MINT5_X_8640_Y_3840 MINT5_X_8640_Y_3920 821m
R_MINT5_seg_3729 MINT5_X_8640_Y_3920 MINT5_X_8640_Y_4160 2.463
R_MINT5_seg_3730 MINT5_X_8640_Y_4160 MINT5_X_8640_Y_4480 3.284
R_MINT5_seg_3731 MINT5_X_8640_Y_4480 MINT5_X_8640_Y_4800 3.284
R_MINT5_seg_3732 MINT5_X_8640_Y_4800 MINT5_X_8640_Y_5040 2.463
R_MINT5_seg_3733 MINT5_X_8640_Y_5040 MINT5_X_8640_Y_5120 821m
R_MINT5_seg_3734 MINT5_X_8640_Y_5120 MINT5_X_8640_Y_5440 3.284
R_MINT5_seg_3735 MINT5_X_8640_Y_5440 MINT5_X_8640_Y_5760 3.284
R_MINT5_seg_3736 MINT5_X_8640_Y_5760 MINT5_X_8640_Y_6080 3.284
R_MINT5_seg_3737 MINT5_X_8640_Y_6080 MINT5_X_8640_Y_6160 821m
R_MINT5_seg_3738 MINT5_X_8640_Y_6160 MINT5_X_8640_Y_6400 2.463
R_MINT5_seg_3739 MINT5_X_8640_Y_6400 MINT5_X_8640_Y_6720 3.284
R_MINT5_seg_3740 MINT5_X_8640_Y_6720 MINT5_X_8640_Y_7040 3.284
R_MINT5_seg_3741 MINT5_X_8640_Y_7040 MINT5_X_8640_Y_7280 2.463
R_MINT5_seg_3742 MINT5_X_8640_Y_7280 MINT5_X_8640_Y_7360 821m
R_MINT5_seg_3743 MINT5_X_8640_Y_7360 MINT5_X_8640_Y_7680 3.284
R_MINT5_seg_3744 MINT5_X_8640_Y_7680 MINT5_X_8640_Y_8000 3.284
R_MINT5_seg_3745 MINT5_X_8640_Y_8000 MINT5_X_8640_Y_8320 3.284
R_MINT5_seg_3746 MINT5_X_8640_Y_8320 MINT5_X_8640_Y_8400 821m
R_MINT5_seg_3747 MINT5_X_8640_Y_8400 MINT5_X_8640_Y_8640 2.463
R_MINT5_seg_3748 MINT5_X_8640_Y_8640 MINT5_X_8640_Y_8960 3.284
R_MINT5_seg_3749 MINT5_X_8640_Y_8960 MINT5_X_8640_Y_9280 3.284
R_MINT5_seg_3750 MINT5_X_8640_Y_9280 MINT5_X_8640_Y_9520 2.463
R_MINT5_seg_3751 MINT5_X_8640_Y_9520 MINT5_X_8640_Y_9600 821m
R_MINT5_seg_3752 MINT5_X_8640_Y_9600 MINT5_X_8640_Y_9920 3.284
R_MINT5_seg_3753 MINT5_X_8640_Y_9920 MINT5_X_8640_Y_10000 821m
R_MINT5_seg_3754 MINT5_X_8960_Y_0 MINT5_X_8960_Y_320 3.284
R_MINT5_seg_3755 MINT5_X_8960_Y_320 MINT5_X_8960_Y_640 3.284
R_MINT5_seg_3756 MINT5_X_8960_Y_640 MINT5_X_8960_Y_960 3.284
R_MINT5_seg_3757 MINT5_X_8960_Y_960 MINT5_X_8960_Y_1120 1.642
R_MINT5_seg_3758 MINT5_X_8960_Y_1120 MINT5_X_8960_Y_1280 1.642
R_MINT5_seg_3759 MINT5_X_8960_Y_1280 MINT5_X_8960_Y_1600 3.284
R_MINT5_seg_3760 MINT5_X_8960_Y_1600 MINT5_X_8960_Y_1920 3.284
R_MINT5_seg_3761 MINT5_X_8960_Y_1920 MINT5_X_8960_Y_2240 3.284
R_MINT5_seg_3762 MINT5_X_8960_Y_2240 MINT5_X_8960_Y_2560 3.284
R_MINT5_seg_3763 MINT5_X_8960_Y_2560 MINT5_X_8960_Y_2880 3.284
R_MINT5_seg_3764 MINT5_X_8960_Y_2880 MINT5_X_8960_Y_3200 3.284
R_MINT5_seg_3765 MINT5_X_8960_Y_3200 MINT5_X_8960_Y_3360 1.642
R_MINT5_seg_3766 MINT5_X_8960_Y_3360 MINT5_X_8960_Y_3520 1.642
R_MINT5_seg_3767 MINT5_X_8960_Y_3520 MINT5_X_8960_Y_3840 3.284
R_MINT5_seg_3768 MINT5_X_8960_Y_3840 MINT5_X_8960_Y_4160 3.284
R_MINT5_seg_3769 MINT5_X_8960_Y_4160 MINT5_X_8960_Y_4480 3.284
R_MINT5_seg_3770 MINT5_X_8960_Y_4480 MINT5_X_8960_Y_4800 3.284
R_MINT5_seg_3771 MINT5_X_8960_Y_4800 MINT5_X_8960_Y_5120 3.284
R_MINT5_seg_3772 MINT5_X_8960_Y_5120 MINT5_X_8960_Y_5440 3.284
R_MINT5_seg_3773 MINT5_X_8960_Y_5440 MINT5_X_8960_Y_5600 1.642
R_MINT5_seg_3774 MINT5_X_8960_Y_5600 MINT5_X_8960_Y_5760 1.642
R_MINT5_seg_3775 MINT5_X_8960_Y_5760 MINT5_X_8960_Y_6080 3.284
R_MINT5_seg_3776 MINT5_X_8960_Y_6080 MINT5_X_8960_Y_6400 3.284
R_MINT5_seg_3777 MINT5_X_8960_Y_6400 MINT5_X_8960_Y_6720 3.284
R_MINT5_seg_3778 MINT5_X_8960_Y_6720 MINT5_X_8960_Y_7040 3.284
R_MINT5_seg_3779 MINT5_X_8960_Y_7040 MINT5_X_8960_Y_7360 3.284
R_MINT5_seg_3780 MINT5_X_8960_Y_7360 MINT5_X_8960_Y_7680 3.284
R_MINT5_seg_3781 MINT5_X_8960_Y_7680 MINT5_X_8960_Y_7840 1.642
R_MINT5_seg_3782 MINT5_X_8960_Y_7840 MINT5_X_8960_Y_8000 1.642
R_MINT5_seg_3783 MINT5_X_8960_Y_8000 MINT5_X_8960_Y_8320 3.284
R_MINT5_seg_3784 MINT5_X_8960_Y_8320 MINT5_X_8960_Y_8640 3.284
R_MINT5_seg_3785 MINT5_X_8960_Y_8640 MINT5_X_8960_Y_8960 3.284
R_MINT5_seg_3786 MINT5_X_8960_Y_8960 MINT5_X_8960_Y_9280 3.284
R_MINT5_seg_3787 MINT5_X_8960_Y_9280 MINT5_X_8960_Y_9600 3.284
R_MINT5_seg_3788 MINT5_X_8960_Y_9600 MINT5_X_8960_Y_9920 3.284
R_MINT5_seg_3789 MINT5_X_8960_Y_9920 MINT5_X_8960_Y_10000 821m
R_MINT5_seg_3790 MINT5_X_9280_Y_0 MINT5_X_9280_Y_320 3.284
R_MINT5_seg_3791 MINT5_X_9280_Y_320 MINT5_X_9280_Y_560 2.463
R_MINT5_seg_3792 MINT5_X_9280_Y_560 MINT5_X_9280_Y_640 821m
R_MINT5_seg_3793 MINT5_X_9280_Y_640 MINT5_X_9280_Y_960 3.284
R_MINT5_seg_3794 MINT5_X_9280_Y_960 MINT5_X_9280_Y_1280 3.284
R_MINT5_seg_3795 MINT5_X_9280_Y_1280 MINT5_X_9280_Y_1600 3.284
R_MINT5_seg_3796 MINT5_X_9280_Y_1600 MINT5_X_9280_Y_1680 821m
R_MINT5_seg_3797 MINT5_X_9280_Y_1680 MINT5_X_9280_Y_1920 2.463
R_MINT5_seg_3798 MINT5_X_9280_Y_1920 MINT5_X_9280_Y_2240 3.284
R_MINT5_seg_3799 MINT5_X_9280_Y_2240 MINT5_X_9280_Y_2560 3.284
R_MINT5_seg_3800 MINT5_X_9280_Y_2560 MINT5_X_9280_Y_2800 2.463
R_MINT5_seg_3801 MINT5_X_9280_Y_2800 MINT5_X_9280_Y_2880 821m
R_MINT5_seg_3802 MINT5_X_9280_Y_2880 MINT5_X_9280_Y_3200 3.284
R_MINT5_seg_3803 MINT5_X_9280_Y_3200 MINT5_X_9280_Y_3520 3.284
R_MINT5_seg_3804 MINT5_X_9280_Y_3520 MINT5_X_9280_Y_3840 3.284
R_MINT5_seg_3805 MINT5_X_9280_Y_3840 MINT5_X_9280_Y_3920 821m
R_MINT5_seg_3806 MINT5_X_9280_Y_3920 MINT5_X_9280_Y_4160 2.463
R_MINT5_seg_3807 MINT5_X_9280_Y_4160 MINT5_X_9280_Y_4480 3.284
R_MINT5_seg_3808 MINT5_X_9280_Y_4480 MINT5_X_9280_Y_4800 3.284
R_MINT5_seg_3809 MINT5_X_9280_Y_4800 MINT5_X_9280_Y_5040 2.463
R_MINT5_seg_3810 MINT5_X_9280_Y_5040 MINT5_X_9280_Y_5120 821m
R_MINT5_seg_3811 MINT5_X_9280_Y_5120 MINT5_X_9280_Y_5440 3.284
R_MINT5_seg_3812 MINT5_X_9280_Y_5440 MINT5_X_9280_Y_5760 3.284
R_MINT5_seg_3813 MINT5_X_9280_Y_5760 MINT5_X_9280_Y_6080 3.284
R_MINT5_seg_3814 MINT5_X_9280_Y_6080 MINT5_X_9280_Y_6160 821m
R_MINT5_seg_3815 MINT5_X_9280_Y_6160 MINT5_X_9280_Y_6400 2.463
R_MINT5_seg_3816 MINT5_X_9280_Y_6400 MINT5_X_9280_Y_6720 3.284
R_MINT5_seg_3817 MINT5_X_9280_Y_6720 MINT5_X_9280_Y_7040 3.284
R_MINT5_seg_3818 MINT5_X_9280_Y_7040 MINT5_X_9280_Y_7280 2.463
R_MINT5_seg_3819 MINT5_X_9280_Y_7280 MINT5_X_9280_Y_7360 821m
R_MINT5_seg_3820 MINT5_X_9280_Y_7360 MINT5_X_9280_Y_7680 3.284
R_MINT5_seg_3821 MINT5_X_9280_Y_7680 MINT5_X_9280_Y_8000 3.284
R_MINT5_seg_3822 MINT5_X_9280_Y_8000 MINT5_X_9280_Y_8320 3.284
R_MINT5_seg_3823 MINT5_X_9280_Y_8320 MINT5_X_9280_Y_8400 821m
R_MINT5_seg_3824 MINT5_X_9280_Y_8400 MINT5_X_9280_Y_8640 2.463
R_MINT5_seg_3825 MINT5_X_9280_Y_8640 MINT5_X_9280_Y_8960 3.284
R_MINT5_seg_3826 MINT5_X_9280_Y_8960 MINT5_X_9280_Y_9280 3.284
R_MINT5_seg_3827 MINT5_X_9280_Y_9280 MINT5_X_9280_Y_9520 2.463
R_MINT5_seg_3828 MINT5_X_9280_Y_9520 MINT5_X_9280_Y_9600 821m
R_MINT5_seg_3829 MINT5_X_9280_Y_9600 MINT5_X_9280_Y_9920 3.284
R_MINT5_seg_3830 MINT5_X_9280_Y_9920 MINT5_X_9280_Y_10000 821m
R_MINT5_seg_3831 MINT5_X_9600_Y_0 MINT5_X_9600_Y_320 3.284
R_MINT5_seg_3832 MINT5_X_9600_Y_320 MINT5_X_9600_Y_640 3.284
R_MINT5_seg_3833 MINT5_X_9600_Y_640 MINT5_X_9600_Y_960 3.284
R_MINT5_seg_3834 MINT5_X_9600_Y_960 MINT5_X_9600_Y_1120 1.642
R_MINT5_seg_3835 MINT5_X_9600_Y_1120 MINT5_X_9600_Y_1280 1.642
R_MINT5_seg_3836 MINT5_X_9600_Y_1280 MINT5_X_9600_Y_1600 3.284
R_MINT5_seg_3837 MINT5_X_9600_Y_1600 MINT5_X_9600_Y_1920 3.284
R_MINT5_seg_3838 MINT5_X_9600_Y_1920 MINT5_X_9600_Y_2240 3.284
R_MINT5_seg_3839 MINT5_X_9600_Y_2240 MINT5_X_9600_Y_2560 3.284
R_MINT5_seg_3840 MINT5_X_9600_Y_2560 MINT5_X_9600_Y_2880 3.284
R_MINT5_seg_3841 MINT5_X_9600_Y_2880 MINT5_X_9600_Y_3200 3.284
R_MINT5_seg_3842 MINT5_X_9600_Y_3200 MINT5_X_9600_Y_3360 1.642
R_MINT5_seg_3843 MINT5_X_9600_Y_3360 MINT5_X_9600_Y_3520 1.642
R_MINT5_seg_3844 MINT5_X_9600_Y_3520 MINT5_X_9600_Y_3840 3.284
R_MINT5_seg_3845 MINT5_X_9600_Y_3840 MINT5_X_9600_Y_4160 3.284
R_MINT5_seg_3846 MINT5_X_9600_Y_4160 MINT5_X_9600_Y_4480 3.284
R_MINT5_seg_3847 MINT5_X_9600_Y_4480 MINT5_X_9600_Y_4800 3.284
R_MINT5_seg_3848 MINT5_X_9600_Y_4800 MINT5_X_9600_Y_5120 3.284
R_MINT5_seg_3849 MINT5_X_9600_Y_5120 MINT5_X_9600_Y_5440 3.284
R_MINT5_seg_3850 MINT5_X_9600_Y_5440 MINT5_X_9600_Y_5600 1.642
R_MINT5_seg_3851 MINT5_X_9600_Y_5600 MINT5_X_9600_Y_5760 1.642
R_MINT5_seg_3852 MINT5_X_9600_Y_5760 MINT5_X_9600_Y_6080 3.284
R_MINT5_seg_3853 MINT5_X_9600_Y_6080 MINT5_X_9600_Y_6400 3.284
R_MINT5_seg_3854 MINT5_X_9600_Y_6400 MINT5_X_9600_Y_6720 3.284
R_MINT5_seg_3855 MINT5_X_9600_Y_6720 MINT5_X_9600_Y_7040 3.284
R_MINT5_seg_3856 MINT5_X_9600_Y_7040 MINT5_X_9600_Y_7360 3.284
R_MINT5_seg_3857 MINT5_X_9600_Y_7360 MINT5_X_9600_Y_7680 3.284
R_MINT5_seg_3858 MINT5_X_9600_Y_7680 MINT5_X_9600_Y_7840 1.642
R_MINT5_seg_3859 MINT5_X_9600_Y_7840 MINT5_X_9600_Y_8000 1.642
R_MINT5_seg_3860 MINT5_X_9600_Y_8000 MINT5_X_9600_Y_8320 3.284
R_MINT5_seg_3861 MINT5_X_9600_Y_8320 MINT5_X_9600_Y_8640 3.284
R_MINT5_seg_3862 MINT5_X_9600_Y_8640 MINT5_X_9600_Y_8960 3.284
R_MINT5_seg_3863 MINT5_X_9600_Y_8960 MINT5_X_9600_Y_9280 3.284
R_MINT5_seg_3864 MINT5_X_9600_Y_9280 MINT5_X_9600_Y_9600 3.284
R_MINT5_seg_3865 MINT5_X_9600_Y_9600 MINT5_X_9600_Y_9920 3.284
R_MINT5_seg_3866 MINT5_X_9600_Y_9920 MINT5_X_9600_Y_10000 821m
R_MINT5_seg_3867 MINT5_X_9920_Y_0 MINT5_X_9920_Y_320 3.284
R_MINT5_seg_3868 MINT5_X_9920_Y_320 MINT5_X_9920_Y_560 2.463
R_MINT5_seg_3869 MINT5_X_9920_Y_560 MINT5_X_9920_Y_640 821m
R_MINT5_seg_3870 MINT5_X_9920_Y_640 MINT5_X_9920_Y_960 3.284
R_MINT5_seg_3871 MINT5_X_9920_Y_960 MINT5_X_9920_Y_1280 3.284
R_MINT5_seg_3872 MINT5_X_9920_Y_1280 MINT5_X_9920_Y_1600 3.284
R_MINT5_seg_3873 MINT5_X_9920_Y_1600 MINT5_X_9920_Y_1680 821m
R_MINT5_seg_3874 MINT5_X_9920_Y_1680 MINT5_X_9920_Y_1920 2.463
R_MINT5_seg_3875 MINT5_X_9920_Y_1920 MINT5_X_9920_Y_2240 3.284
R_MINT5_seg_3876 MINT5_X_9920_Y_2240 MINT5_X_9920_Y_2560 3.284
R_MINT5_seg_3877 MINT5_X_9920_Y_2560 MINT5_X_9920_Y_2800 2.463
R_MINT5_seg_3878 MINT5_X_9920_Y_2800 MINT5_X_9920_Y_2880 821m
R_MINT5_seg_3879 MINT5_X_9920_Y_2880 MINT5_X_9920_Y_3200 3.284
R_MINT5_seg_3880 MINT5_X_9920_Y_3200 MINT5_X_9920_Y_3520 3.284
R_MINT5_seg_3881 MINT5_X_9920_Y_3520 MINT5_X_9920_Y_3840 3.284
R_MINT5_seg_3882 MINT5_X_9920_Y_3840 MINT5_X_9920_Y_3920 821m
R_MINT5_seg_3883 MINT5_X_9920_Y_3920 MINT5_X_9920_Y_4160 2.463
R_MINT5_seg_3884 MINT5_X_9920_Y_4160 MINT5_X_9920_Y_4480 3.284
R_MINT5_seg_3885 MINT5_X_9920_Y_4480 MINT5_X_9920_Y_4800 3.284
R_MINT5_seg_3886 MINT5_X_9920_Y_4800 MINT5_X_9920_Y_5040 2.463
R_MINT5_seg_3887 MINT5_X_9920_Y_5040 MINT5_X_9920_Y_5120 821m
R_MINT5_seg_3888 MINT5_X_9920_Y_5120 MINT5_X_9920_Y_5440 3.284
R_MINT5_seg_3889 MINT5_X_9920_Y_5440 MINT5_X_9920_Y_5760 3.284
R_MINT5_seg_3890 MINT5_X_9920_Y_5760 MINT5_X_9920_Y_6080 3.284
R_MINT5_seg_3891 MINT5_X_9920_Y_6080 MINT5_X_9920_Y_6160 821m
R_MINT5_seg_3892 MINT5_X_9920_Y_6160 MINT5_X_9920_Y_6400 2.463
R_MINT5_seg_3893 MINT5_X_9920_Y_6400 MINT5_X_9920_Y_6720 3.284
R_MINT5_seg_3894 MINT5_X_9920_Y_6720 MINT5_X_9920_Y_7040 3.284
R_MINT5_seg_3895 MINT5_X_9920_Y_7040 MINT5_X_9920_Y_7280 2.463
R_MINT5_seg_3896 MINT5_X_9920_Y_7280 MINT5_X_9920_Y_7360 821m
R_MINT5_seg_3897 MINT5_X_9920_Y_7360 MINT5_X_9920_Y_7680 3.284
R_MINT5_seg_3898 MINT5_X_9920_Y_7680 MINT5_X_9920_Y_8000 3.284
R_MINT5_seg_3899 MINT5_X_9920_Y_8000 MINT5_X_9920_Y_8320 3.284
R_MINT5_seg_3900 MINT5_X_9920_Y_8320 MINT5_X_9920_Y_8400 821m
R_MINT5_seg_3901 MINT5_X_9920_Y_8400 MINT5_X_9920_Y_8640 2.463
R_MINT5_seg_3902 MINT5_X_9920_Y_8640 MINT5_X_9920_Y_8960 3.284
R_MINT5_seg_3903 MINT5_X_9920_Y_8960 MINT5_X_9920_Y_9280 3.284
R_MINT5_seg_3904 MINT5_X_9920_Y_9280 MINT5_X_9920_Y_9520 2.463
R_MINT5_seg_3905 MINT5_X_9920_Y_9520 MINT5_X_9920_Y_9600 821m
R_MINT5_seg_3906 MINT5_X_9920_Y_9600 MINT5_X_9920_Y_9920 3.284
R_MINT5_seg_3907 MINT5_X_9920_Y_9920 MINT5_X_9920_Y_10000 821m
* Layer: MINT1
R_MINT1_seg_3908 MINT1_X_0_Y_0 MINT1_X_0_Y_320 3.284
R_MINT1_seg_3909 MINT1_X_0_Y_320 MINT1_X_0_Y_640 3.284
R_MINT1_seg_3910 MINT1_X_0_Y_640 MINT1_X_0_Y_960 3.284
R_MINT1_seg_3911 MINT1_X_0_Y_960 MINT1_X_0_Y_1024 656.8m
R_MINT1_seg_3912 MINT1_X_0_Y_1024 MINT1_X_0_Y_1280 2.627
R_MINT1_seg_3913 MINT1_X_0_Y_1280 MINT1_X_0_Y_1600 3.284
R_MINT1_seg_3914 MINT1_X_0_Y_1600 MINT1_X_0_Y_1920 3.284
R_MINT1_seg_3915 MINT1_X_0_Y_1920 MINT1_X_0_Y_2048 1.314
R_MINT1_seg_3916 MINT1_X_0_Y_2048 MINT1_X_0_Y_2240 1.97
R_MINT1_seg_3917 MINT1_X_0_Y_2240 MINT1_X_0_Y_2560 3.284
R_MINT1_seg_3918 MINT1_X_0_Y_2560 MINT1_X_0_Y_2880 3.284
R_MINT1_seg_3919 MINT1_X_0_Y_2880 MINT1_X_0_Y_3072 1.97
R_MINT1_seg_3920 MINT1_X_0_Y_3072 MINT1_X_0_Y_3200 1.314
R_MINT1_seg_3921 MINT1_X_0_Y_3200 MINT1_X_0_Y_3520 3.284
R_MINT1_seg_3922 MINT1_X_0_Y_3520 MINT1_X_0_Y_3840 3.284
R_MINT1_seg_3923 MINT1_X_0_Y_3840 MINT1_X_0_Y_4096 2.627
R_MINT1_seg_3924 MINT1_X_0_Y_4096 MINT1_X_0_Y_4160 656.8m
R_MINT1_seg_3925 MINT1_X_0_Y_4160 MINT1_X_0_Y_4480 3.284
R_MINT1_seg_3926 MINT1_X_0_Y_4480 MINT1_X_0_Y_4800 3.284
R_MINT1_seg_3927 MINT1_X_0_Y_4800 MINT1_X_0_Y_5120 3.284
R_MINT1_seg_3928 MINT1_X_0_Y_5120 MINT1_X_0_Y_5440 3.284
R_MINT1_seg_3929 MINT1_X_0_Y_5440 MINT1_X_0_Y_5760 3.284
R_MINT1_seg_3930 MINT1_X_0_Y_5760 MINT1_X_0_Y_6080 3.284
R_MINT1_seg_3931 MINT1_X_0_Y_6080 MINT1_X_0_Y_6144 656.8m
R_MINT1_seg_3932 MINT1_X_0_Y_6144 MINT1_X_0_Y_6400 2.627
R_MINT1_seg_3933 MINT1_X_0_Y_6400 MINT1_X_0_Y_6720 3.284
R_MINT1_seg_3934 MINT1_X_0_Y_6720 MINT1_X_0_Y_7040 3.284
R_MINT1_seg_3935 MINT1_X_0_Y_7040 MINT1_X_0_Y_7168 1.314
R_MINT1_seg_3936 MINT1_X_0_Y_7168 MINT1_X_0_Y_7360 1.97
R_MINT1_seg_3937 MINT1_X_0_Y_7360 MINT1_X_0_Y_7680 3.284
R_MINT1_seg_3938 MINT1_X_0_Y_7680 MINT1_X_0_Y_8000 3.284
R_MINT1_seg_3939 MINT1_X_0_Y_8000 MINT1_X_0_Y_8192 1.97
R_MINT1_seg_3940 MINT1_X_0_Y_8192 MINT1_X_0_Y_8320 1.314
R_MINT1_seg_3941 MINT1_X_0_Y_8320 MINT1_X_0_Y_8640 3.284
R_MINT1_seg_3942 MINT1_X_0_Y_8640 MINT1_X_0_Y_8960 3.284
R_MINT1_seg_3943 MINT1_X_0_Y_8960 MINT1_X_0_Y_9216 2.627
R_MINT1_seg_3944 MINT1_X_0_Y_9216 MINT1_X_0_Y_9280 656.8m
R_MINT1_seg_3945 MINT1_X_0_Y_9280 MINT1_X_0_Y_9600 3.284
R_MINT1_seg_3946 MINT1_X_0_Y_9600 MINT1_X_0_Y_9920 3.284
R_MINT1_seg_3947 MINT1_X_0_Y_9920 MINT1_X_0_Y_10000 821m
R_MINT1_seg_3948 MINT1_X_320_Y_0 MINT1_X_320_Y_320 3.284
R_MINT1_seg_3949 MINT1_X_320_Y_320 MINT1_X_320_Y_512 1.97
R_MINT1_seg_3950 MINT1_X_320_Y_512 MINT1_X_320_Y_640 1.314
R_MINT1_seg_3951 MINT1_X_320_Y_640 MINT1_X_320_Y_960 3.284
R_MINT1_seg_3952 MINT1_X_320_Y_960 MINT1_X_320_Y_1280 3.284
R_MINT1_seg_3953 MINT1_X_320_Y_1280 MINT1_X_320_Y_1536 2.627
R_MINT1_seg_3954 MINT1_X_320_Y_1536 MINT1_X_320_Y_1600 656.8m
R_MINT1_seg_3955 MINT1_X_320_Y_1600 MINT1_X_320_Y_1920 3.284
R_MINT1_seg_3956 MINT1_X_320_Y_1920 MINT1_X_320_Y_2240 3.284
R_MINT1_seg_3957 MINT1_X_320_Y_2240 MINT1_X_320_Y_2560 3.284
R_MINT1_seg_3958 MINT1_X_320_Y_2560 MINT1_X_320_Y_2880 3.284
R_MINT1_seg_3959 MINT1_X_320_Y_2880 MINT1_X_320_Y_3200 3.284
R_MINT1_seg_3960 MINT1_X_320_Y_3200 MINT1_X_320_Y_3520 3.284
R_MINT1_seg_3961 MINT1_X_320_Y_3520 MINT1_X_320_Y_3584 656.8m
R_MINT1_seg_3962 MINT1_X_320_Y_3584 MINT1_X_320_Y_3840 2.627
R_MINT1_seg_3963 MINT1_X_320_Y_3840 MINT1_X_320_Y_4160 3.284
R_MINT1_seg_3964 MINT1_X_320_Y_4160 MINT1_X_320_Y_4480 3.284
R_MINT1_seg_3965 MINT1_X_320_Y_4480 MINT1_X_320_Y_4608 1.314
R_MINT1_seg_3966 MINT1_X_320_Y_4608 MINT1_X_320_Y_4800 1.97
R_MINT1_seg_3967 MINT1_X_320_Y_4800 MINT1_X_320_Y_5120 3.284
R_MINT1_seg_3968 MINT1_X_320_Y_5120 MINT1_X_320_Y_5440 3.284
R_MINT1_seg_3969 MINT1_X_320_Y_5440 MINT1_X_320_Y_5632 1.97
R_MINT1_seg_3970 MINT1_X_320_Y_5632 MINT1_X_320_Y_5760 1.314
R_MINT1_seg_3971 MINT1_X_320_Y_5760 MINT1_X_320_Y_6080 3.284
R_MINT1_seg_3972 MINT1_X_320_Y_6080 MINT1_X_320_Y_6400 3.284
R_MINT1_seg_3973 MINT1_X_320_Y_6400 MINT1_X_320_Y_6656 2.627
R_MINT1_seg_3974 MINT1_X_320_Y_6656 MINT1_X_320_Y_6720 656.8m
R_MINT1_seg_3975 MINT1_X_320_Y_6720 MINT1_X_320_Y_7040 3.284
R_MINT1_seg_3976 MINT1_X_320_Y_7040 MINT1_X_320_Y_7360 3.284
R_MINT1_seg_3977 MINT1_X_320_Y_7360 MINT1_X_320_Y_7680 3.284
R_MINT1_seg_3978 MINT1_X_320_Y_7680 MINT1_X_320_Y_8000 3.284
R_MINT1_seg_3979 MINT1_X_320_Y_8000 MINT1_X_320_Y_8320 3.284
R_MINT1_seg_3980 MINT1_X_320_Y_8320 MINT1_X_320_Y_8640 3.284
R_MINT1_seg_3981 MINT1_X_320_Y_8640 MINT1_X_320_Y_8704 656.8m
R_MINT1_seg_3982 MINT1_X_320_Y_8704 MINT1_X_320_Y_8960 2.627
R_MINT1_seg_3983 MINT1_X_320_Y_8960 MINT1_X_320_Y_9280 3.284
R_MINT1_seg_3984 MINT1_X_320_Y_9280 MINT1_X_320_Y_9600 3.284
R_MINT1_seg_3985 MINT1_X_320_Y_9600 MINT1_X_320_Y_9728 1.314
R_MINT1_seg_3986 MINT1_X_320_Y_9728 MINT1_X_320_Y_9920 1.97
R_MINT1_seg_3987 MINT1_X_320_Y_9920 MINT1_X_320_Y_10000 821m
R_MINT1_seg_3988 MINT1_X_640_Y_0 MINT1_X_640_Y_320 3.284
R_MINT1_seg_3989 MINT1_X_640_Y_320 MINT1_X_640_Y_640 3.284
R_MINT1_seg_3990 MINT1_X_640_Y_640 MINT1_X_640_Y_960 3.284
R_MINT1_seg_3991 MINT1_X_640_Y_960 MINT1_X_640_Y_1024 656.8m
R_MINT1_seg_3992 MINT1_X_640_Y_1024 MINT1_X_640_Y_1280 2.627
R_MINT1_seg_3993 MINT1_X_640_Y_1280 MINT1_X_640_Y_1600 3.284
R_MINT1_seg_3994 MINT1_X_640_Y_1600 MINT1_X_640_Y_1920 3.284
R_MINT1_seg_3995 MINT1_X_640_Y_1920 MINT1_X_640_Y_2048 1.314
R_MINT1_seg_3996 MINT1_X_640_Y_2048 MINT1_X_640_Y_2240 1.97
R_MINT1_seg_3997 MINT1_X_640_Y_2240 MINT1_X_640_Y_2560 3.284
R_MINT1_seg_3998 MINT1_X_640_Y_2560 MINT1_X_640_Y_2880 3.284
R_MINT1_seg_3999 MINT1_X_640_Y_2880 MINT1_X_640_Y_3072 1.97
R_MINT1_seg_4000 MINT1_X_640_Y_3072 MINT1_X_640_Y_3200 1.314
R_MINT1_seg_4001 MINT1_X_640_Y_3200 MINT1_X_640_Y_3520 3.284
R_MINT1_seg_4002 MINT1_X_640_Y_3520 MINT1_X_640_Y_3840 3.284
R_MINT1_seg_4003 MINT1_X_640_Y_3840 MINT1_X_640_Y_4096 2.627
R_MINT1_seg_4004 MINT1_X_640_Y_4096 MINT1_X_640_Y_4160 656.8m
R_MINT1_seg_4005 MINT1_X_640_Y_4160 MINT1_X_640_Y_4480 3.284
R_MINT1_seg_4006 MINT1_X_640_Y_4480 MINT1_X_640_Y_4800 3.284
R_MINT1_seg_4007 MINT1_X_640_Y_4800 MINT1_X_640_Y_5120 3.284
R_MINT1_seg_4008 MINT1_X_640_Y_5120 MINT1_X_640_Y_5440 3.284
R_MINT1_seg_4009 MINT1_X_640_Y_5440 MINT1_X_640_Y_5760 3.284
R_MINT1_seg_4010 MINT1_X_640_Y_5760 MINT1_X_640_Y_6080 3.284
R_MINT1_seg_4011 MINT1_X_640_Y_6080 MINT1_X_640_Y_6144 656.8m
R_MINT1_seg_4012 MINT1_X_640_Y_6144 MINT1_X_640_Y_6400 2.627
R_MINT1_seg_4013 MINT1_X_640_Y_6400 MINT1_X_640_Y_6720 3.284
R_MINT1_seg_4014 MINT1_X_640_Y_6720 MINT1_X_640_Y_7040 3.284
R_MINT1_seg_4015 MINT1_X_640_Y_7040 MINT1_X_640_Y_7168 1.314
R_MINT1_seg_4016 MINT1_X_640_Y_7168 MINT1_X_640_Y_7360 1.97
R_MINT1_seg_4017 MINT1_X_640_Y_7360 MINT1_X_640_Y_7680 3.284
R_MINT1_seg_4018 MINT1_X_640_Y_7680 MINT1_X_640_Y_8000 3.284
R_MINT1_seg_4019 MINT1_X_640_Y_8000 MINT1_X_640_Y_8192 1.97
R_MINT1_seg_4020 MINT1_X_640_Y_8192 MINT1_X_640_Y_8320 1.314
R_MINT1_seg_4021 MINT1_X_640_Y_8320 MINT1_X_640_Y_8640 3.284
R_MINT1_seg_4022 MINT1_X_640_Y_8640 MINT1_X_640_Y_8960 3.284
R_MINT1_seg_4023 MINT1_X_640_Y_8960 MINT1_X_640_Y_9216 2.627
R_MINT1_seg_4024 MINT1_X_640_Y_9216 MINT1_X_640_Y_9280 656.8m
R_MINT1_seg_4025 MINT1_X_640_Y_9280 MINT1_X_640_Y_9600 3.284
R_MINT1_seg_4026 MINT1_X_640_Y_9600 MINT1_X_640_Y_9920 3.284
R_MINT1_seg_4027 MINT1_X_640_Y_9920 MINT1_X_640_Y_10000 821m
R_MINT1_seg_4028 MINT1_X_960_Y_0 MINT1_X_960_Y_320 3.284
R_MINT1_seg_4029 MINT1_X_960_Y_320 MINT1_X_960_Y_512 1.97
R_MINT1_seg_4030 MINT1_X_960_Y_512 MINT1_X_960_Y_640 1.314
R_MINT1_seg_4031 MINT1_X_960_Y_640 MINT1_X_960_Y_960 3.284
R_MINT1_seg_4032 MINT1_X_960_Y_960 MINT1_X_960_Y_1280 3.284
R_MINT1_seg_4033 MINT1_X_960_Y_1280 MINT1_X_960_Y_1536 2.627
R_MINT1_seg_4034 MINT1_X_960_Y_1536 MINT1_X_960_Y_1600 656.8m
R_MINT1_seg_4035 MINT1_X_960_Y_1600 MINT1_X_960_Y_1920 3.284
R_MINT1_seg_4036 MINT1_X_960_Y_1920 MINT1_X_960_Y_2240 3.284
R_MINT1_seg_4037 MINT1_X_960_Y_2240 MINT1_X_960_Y_2560 3.284
R_MINT1_seg_4038 MINT1_X_960_Y_2560 MINT1_X_960_Y_2880 3.284
R_MINT1_seg_4039 MINT1_X_960_Y_2880 MINT1_X_960_Y_3200 3.284
R_MINT1_seg_4040 MINT1_X_960_Y_3200 MINT1_X_960_Y_3520 3.284
R_MINT1_seg_4041 MINT1_X_960_Y_3520 MINT1_X_960_Y_3584 656.8m
R_MINT1_seg_4042 MINT1_X_960_Y_3584 MINT1_X_960_Y_3840 2.627
R_MINT1_seg_4043 MINT1_X_960_Y_3840 MINT1_X_960_Y_4160 3.284
R_MINT1_seg_4044 MINT1_X_960_Y_4160 MINT1_X_960_Y_4480 3.284
R_MINT1_seg_4045 MINT1_X_960_Y_4480 MINT1_X_960_Y_4608 1.314
R_MINT1_seg_4046 MINT1_X_960_Y_4608 MINT1_X_960_Y_4800 1.97
R_MINT1_seg_4047 MINT1_X_960_Y_4800 MINT1_X_960_Y_5120 3.284
R_MINT1_seg_4048 MINT1_X_960_Y_5120 MINT1_X_960_Y_5440 3.284
R_MINT1_seg_4049 MINT1_X_960_Y_5440 MINT1_X_960_Y_5632 1.97
R_MINT1_seg_4050 MINT1_X_960_Y_5632 MINT1_X_960_Y_5760 1.314
R_MINT1_seg_4051 MINT1_X_960_Y_5760 MINT1_X_960_Y_6080 3.284
R_MINT1_seg_4052 MINT1_X_960_Y_6080 MINT1_X_960_Y_6400 3.284
R_MINT1_seg_4053 MINT1_X_960_Y_6400 MINT1_X_960_Y_6656 2.627
R_MINT1_seg_4054 MINT1_X_960_Y_6656 MINT1_X_960_Y_6720 656.8m
R_MINT1_seg_4055 MINT1_X_960_Y_6720 MINT1_X_960_Y_7040 3.284
R_MINT1_seg_4056 MINT1_X_960_Y_7040 MINT1_X_960_Y_7360 3.284
R_MINT1_seg_4057 MINT1_X_960_Y_7360 MINT1_X_960_Y_7680 3.284
R_MINT1_seg_4058 MINT1_X_960_Y_7680 MINT1_X_960_Y_8000 3.284
R_MINT1_seg_4059 MINT1_X_960_Y_8000 MINT1_X_960_Y_8320 3.284
R_MINT1_seg_4060 MINT1_X_960_Y_8320 MINT1_X_960_Y_8640 3.284
R_MINT1_seg_4061 MINT1_X_960_Y_8640 MINT1_X_960_Y_8704 656.8m
R_MINT1_seg_4062 MINT1_X_960_Y_8704 MINT1_X_960_Y_8960 2.627
R_MINT1_seg_4063 MINT1_X_960_Y_8960 MINT1_X_960_Y_9280 3.284
R_MINT1_seg_4064 MINT1_X_960_Y_9280 MINT1_X_960_Y_9600 3.284
R_MINT1_seg_4065 MINT1_X_960_Y_9600 MINT1_X_960_Y_9728 1.314
R_MINT1_seg_4066 MINT1_X_960_Y_9728 MINT1_X_960_Y_9920 1.97
R_MINT1_seg_4067 MINT1_X_960_Y_9920 MINT1_X_960_Y_10000 821m
R_MINT1_seg_4068 MINT1_X_1280_Y_0 MINT1_X_1280_Y_320 3.284
R_MINT1_seg_4069 MINT1_X_1280_Y_320 MINT1_X_1280_Y_640 3.284
R_MINT1_seg_4070 MINT1_X_1280_Y_640 MINT1_X_1280_Y_960 3.284
R_MINT1_seg_4071 MINT1_X_1280_Y_960 MINT1_X_1280_Y_1024 656.8m
R_MINT1_seg_4072 MINT1_X_1280_Y_1024 MINT1_X_1280_Y_1280 2.627
R_MINT1_seg_4073 MINT1_X_1280_Y_1280 MINT1_X_1280_Y_1600 3.284
R_MINT1_seg_4074 MINT1_X_1280_Y_1600 MINT1_X_1280_Y_1920 3.284
R_MINT1_seg_4075 MINT1_X_1280_Y_1920 MINT1_X_1280_Y_2048 1.314
R_MINT1_seg_4076 MINT1_X_1280_Y_2048 MINT1_X_1280_Y_2240 1.97
R_MINT1_seg_4077 MINT1_X_1280_Y_2240 MINT1_X_1280_Y_2560 3.284
R_MINT1_seg_4078 MINT1_X_1280_Y_2560 MINT1_X_1280_Y_2880 3.284
R_MINT1_seg_4079 MINT1_X_1280_Y_2880 MINT1_X_1280_Y_3072 1.97
R_MINT1_seg_4080 MINT1_X_1280_Y_3072 MINT1_X_1280_Y_3200 1.314
R_MINT1_seg_4081 MINT1_X_1280_Y_3200 MINT1_X_1280_Y_3520 3.284
R_MINT1_seg_4082 MINT1_X_1280_Y_3520 MINT1_X_1280_Y_3840 3.284
R_MINT1_seg_4083 MINT1_X_1280_Y_3840 MINT1_X_1280_Y_4096 2.627
R_MINT1_seg_4084 MINT1_X_1280_Y_4096 MINT1_X_1280_Y_4160 656.8m
R_MINT1_seg_4085 MINT1_X_1280_Y_4160 MINT1_X_1280_Y_4480 3.284
R_MINT1_seg_4086 MINT1_X_1280_Y_4480 MINT1_X_1280_Y_4800 3.284
R_MINT1_seg_4087 MINT1_X_1280_Y_4800 MINT1_X_1280_Y_5120 3.284
R_MINT1_seg_4088 MINT1_X_1280_Y_5120 MINT1_X_1280_Y_5440 3.284
R_MINT1_seg_4089 MINT1_X_1280_Y_5440 MINT1_X_1280_Y_5760 3.284
R_MINT1_seg_4090 MINT1_X_1280_Y_5760 MINT1_X_1280_Y_6080 3.284
R_MINT1_seg_4091 MINT1_X_1280_Y_6080 MINT1_X_1280_Y_6144 656.8m
R_MINT1_seg_4092 MINT1_X_1280_Y_6144 MINT1_X_1280_Y_6400 2.627
R_MINT1_seg_4093 MINT1_X_1280_Y_6400 MINT1_X_1280_Y_6720 3.284
R_MINT1_seg_4094 MINT1_X_1280_Y_6720 MINT1_X_1280_Y_7040 3.284
R_MINT1_seg_4095 MINT1_X_1280_Y_7040 MINT1_X_1280_Y_7168 1.314
R_MINT1_seg_4096 MINT1_X_1280_Y_7168 MINT1_X_1280_Y_7360 1.97
R_MINT1_seg_4097 MINT1_X_1280_Y_7360 MINT1_X_1280_Y_7680 3.284
R_MINT1_seg_4098 MINT1_X_1280_Y_7680 MINT1_X_1280_Y_8000 3.284
R_MINT1_seg_4099 MINT1_X_1280_Y_8000 MINT1_X_1280_Y_8192 1.97
R_MINT1_seg_4100 MINT1_X_1280_Y_8192 MINT1_X_1280_Y_8320 1.314
R_MINT1_seg_4101 MINT1_X_1280_Y_8320 MINT1_X_1280_Y_8640 3.284
R_MINT1_seg_4102 MINT1_X_1280_Y_8640 MINT1_X_1280_Y_8960 3.284
R_MINT1_seg_4103 MINT1_X_1280_Y_8960 MINT1_X_1280_Y_9216 2.627
R_MINT1_seg_4104 MINT1_X_1280_Y_9216 MINT1_X_1280_Y_9280 656.8m
R_MINT1_seg_4105 MINT1_X_1280_Y_9280 MINT1_X_1280_Y_9600 3.284
R_MINT1_seg_4106 MINT1_X_1280_Y_9600 MINT1_X_1280_Y_9920 3.284
R_MINT1_seg_4107 MINT1_X_1280_Y_9920 MINT1_X_1280_Y_10000 821m
R_MINT1_seg_4108 MINT1_X_1600_Y_0 MINT1_X_1600_Y_320 3.284
R_MINT1_seg_4109 MINT1_X_1600_Y_320 MINT1_X_1600_Y_512 1.97
R_MINT1_seg_4110 MINT1_X_1600_Y_512 MINT1_X_1600_Y_640 1.314
R_MINT1_seg_4111 MINT1_X_1600_Y_640 MINT1_X_1600_Y_960 3.284
R_MINT1_seg_4112 MINT1_X_1600_Y_960 MINT1_X_1600_Y_1280 3.284
R_MINT1_seg_4113 MINT1_X_1600_Y_1280 MINT1_X_1600_Y_1536 2.627
R_MINT1_seg_4114 MINT1_X_1600_Y_1536 MINT1_X_1600_Y_1600 656.8m
R_MINT1_seg_4115 MINT1_X_1600_Y_1600 MINT1_X_1600_Y_1920 3.284
R_MINT1_seg_4116 MINT1_X_1600_Y_1920 MINT1_X_1600_Y_2240 3.284
R_MINT1_seg_4117 MINT1_X_1600_Y_2240 MINT1_X_1600_Y_2560 3.284
R_MINT1_seg_4118 MINT1_X_1600_Y_2560 MINT1_X_1600_Y_2880 3.284
R_MINT1_seg_4119 MINT1_X_1600_Y_2880 MINT1_X_1600_Y_3200 3.284
R_MINT1_seg_4120 MINT1_X_1600_Y_3200 MINT1_X_1600_Y_3520 3.284
R_MINT1_seg_4121 MINT1_X_1600_Y_3520 MINT1_X_1600_Y_3584 656.8m
R_MINT1_seg_4122 MINT1_X_1600_Y_3584 MINT1_X_1600_Y_3840 2.627
R_MINT1_seg_4123 MINT1_X_1600_Y_3840 MINT1_X_1600_Y_4160 3.284
R_MINT1_seg_4124 MINT1_X_1600_Y_4160 MINT1_X_1600_Y_4480 3.284
R_MINT1_seg_4125 MINT1_X_1600_Y_4480 MINT1_X_1600_Y_4608 1.314
R_MINT1_seg_4126 MINT1_X_1600_Y_4608 MINT1_X_1600_Y_4800 1.97
R_MINT1_seg_4127 MINT1_X_1600_Y_4800 MINT1_X_1600_Y_5120 3.284
R_MINT1_seg_4128 MINT1_X_1600_Y_5120 MINT1_X_1600_Y_5440 3.284
R_MINT1_seg_4129 MINT1_X_1600_Y_5440 MINT1_X_1600_Y_5632 1.97
R_MINT1_seg_4130 MINT1_X_1600_Y_5632 MINT1_X_1600_Y_5760 1.314
R_MINT1_seg_4131 MINT1_X_1600_Y_5760 MINT1_X_1600_Y_6080 3.284
R_MINT1_seg_4132 MINT1_X_1600_Y_6080 MINT1_X_1600_Y_6400 3.284
R_MINT1_seg_4133 MINT1_X_1600_Y_6400 MINT1_X_1600_Y_6656 2.627
R_MINT1_seg_4134 MINT1_X_1600_Y_6656 MINT1_X_1600_Y_6720 656.8m
R_MINT1_seg_4135 MINT1_X_1600_Y_6720 MINT1_X_1600_Y_7040 3.284
R_MINT1_seg_4136 MINT1_X_1600_Y_7040 MINT1_X_1600_Y_7360 3.284
R_MINT1_seg_4137 MINT1_X_1600_Y_7360 MINT1_X_1600_Y_7680 3.284
R_MINT1_seg_4138 MINT1_X_1600_Y_7680 MINT1_X_1600_Y_8000 3.284
R_MINT1_seg_4139 MINT1_X_1600_Y_8000 MINT1_X_1600_Y_8320 3.284
R_MINT1_seg_4140 MINT1_X_1600_Y_8320 MINT1_X_1600_Y_8640 3.284
R_MINT1_seg_4141 MINT1_X_1600_Y_8640 MINT1_X_1600_Y_8704 656.8m
R_MINT1_seg_4142 MINT1_X_1600_Y_8704 MINT1_X_1600_Y_8960 2.627
R_MINT1_seg_4143 MINT1_X_1600_Y_8960 MINT1_X_1600_Y_9280 3.284
R_MINT1_seg_4144 MINT1_X_1600_Y_9280 MINT1_X_1600_Y_9600 3.284
R_MINT1_seg_4145 MINT1_X_1600_Y_9600 MINT1_X_1600_Y_9728 1.314
R_MINT1_seg_4146 MINT1_X_1600_Y_9728 MINT1_X_1600_Y_9920 1.97
R_MINT1_seg_4147 MINT1_X_1600_Y_9920 MINT1_X_1600_Y_10000 821m
R_MINT1_seg_4148 MINT1_X_1920_Y_0 MINT1_X_1920_Y_320 3.284
R_MINT1_seg_4149 MINT1_X_1920_Y_320 MINT1_X_1920_Y_640 3.284
R_MINT1_seg_4150 MINT1_X_1920_Y_640 MINT1_X_1920_Y_960 3.284
R_MINT1_seg_4151 MINT1_X_1920_Y_960 MINT1_X_1920_Y_1024 656.8m
R_MINT1_seg_4152 MINT1_X_1920_Y_1024 MINT1_X_1920_Y_1280 2.627
R_MINT1_seg_4153 MINT1_X_1920_Y_1280 MINT1_X_1920_Y_1600 3.284
R_MINT1_seg_4154 MINT1_X_1920_Y_1600 MINT1_X_1920_Y_1920 3.284
R_MINT1_seg_4155 MINT1_X_1920_Y_1920 MINT1_X_1920_Y_2048 1.314
R_MINT1_seg_4156 MINT1_X_1920_Y_2048 MINT1_X_1920_Y_2240 1.97
R_MINT1_seg_4157 MINT1_X_1920_Y_2240 MINT1_X_1920_Y_2560 3.284
R_MINT1_seg_4158 MINT1_X_1920_Y_2560 MINT1_X_1920_Y_2880 3.284
R_MINT1_seg_4159 MINT1_X_1920_Y_2880 MINT1_X_1920_Y_3072 1.97
R_MINT1_seg_4160 MINT1_X_1920_Y_3072 MINT1_X_1920_Y_3200 1.314
R_MINT1_seg_4161 MINT1_X_1920_Y_3200 MINT1_X_1920_Y_3520 3.284
R_MINT1_seg_4162 MINT1_X_1920_Y_3520 MINT1_X_1920_Y_3840 3.284
R_MINT1_seg_4163 MINT1_X_1920_Y_3840 MINT1_X_1920_Y_4096 2.627
R_MINT1_seg_4164 MINT1_X_1920_Y_4096 MINT1_X_1920_Y_4160 656.8m
R_MINT1_seg_4165 MINT1_X_1920_Y_4160 MINT1_X_1920_Y_4480 3.284
R_MINT1_seg_4166 MINT1_X_1920_Y_4480 MINT1_X_1920_Y_4800 3.284
R_MINT1_seg_4167 MINT1_X_1920_Y_4800 MINT1_X_1920_Y_5120 3.284
R_MINT1_seg_4168 MINT1_X_1920_Y_5120 MINT1_X_1920_Y_5440 3.284
R_MINT1_seg_4169 MINT1_X_1920_Y_5440 MINT1_X_1920_Y_5760 3.284
R_MINT1_seg_4170 MINT1_X_1920_Y_5760 MINT1_X_1920_Y_6080 3.284
R_MINT1_seg_4171 MINT1_X_1920_Y_6080 MINT1_X_1920_Y_6144 656.8m
R_MINT1_seg_4172 MINT1_X_1920_Y_6144 MINT1_X_1920_Y_6400 2.627
R_MINT1_seg_4173 MINT1_X_1920_Y_6400 MINT1_X_1920_Y_6720 3.284
R_MINT1_seg_4174 MINT1_X_1920_Y_6720 MINT1_X_1920_Y_7040 3.284
R_MINT1_seg_4175 MINT1_X_1920_Y_7040 MINT1_X_1920_Y_7168 1.314
R_MINT1_seg_4176 MINT1_X_1920_Y_7168 MINT1_X_1920_Y_7360 1.97
R_MINT1_seg_4177 MINT1_X_1920_Y_7360 MINT1_X_1920_Y_7680 3.284
R_MINT1_seg_4178 MINT1_X_1920_Y_7680 MINT1_X_1920_Y_8000 3.284
R_MINT1_seg_4179 MINT1_X_1920_Y_8000 MINT1_X_1920_Y_8192 1.97
R_MINT1_seg_4180 MINT1_X_1920_Y_8192 MINT1_X_1920_Y_8320 1.314
R_MINT1_seg_4181 MINT1_X_1920_Y_8320 MINT1_X_1920_Y_8640 3.284
R_MINT1_seg_4182 MINT1_X_1920_Y_8640 MINT1_X_1920_Y_8960 3.284
R_MINT1_seg_4183 MINT1_X_1920_Y_8960 MINT1_X_1920_Y_9216 2.627
R_MINT1_seg_4184 MINT1_X_1920_Y_9216 MINT1_X_1920_Y_9280 656.8m
R_MINT1_seg_4185 MINT1_X_1920_Y_9280 MINT1_X_1920_Y_9600 3.284
R_MINT1_seg_4186 MINT1_X_1920_Y_9600 MINT1_X_1920_Y_9920 3.284
R_MINT1_seg_4187 MINT1_X_1920_Y_9920 MINT1_X_1920_Y_10000 821m
R_MINT1_seg_4188 MINT1_X_2240_Y_0 MINT1_X_2240_Y_320 3.284
R_MINT1_seg_4189 MINT1_X_2240_Y_320 MINT1_X_2240_Y_512 1.97
R_MINT1_seg_4190 MINT1_X_2240_Y_512 MINT1_X_2240_Y_640 1.314
R_MINT1_seg_4191 MINT1_X_2240_Y_640 MINT1_X_2240_Y_960 3.284
R_MINT1_seg_4192 MINT1_X_2240_Y_960 MINT1_X_2240_Y_1280 3.284
R_MINT1_seg_4193 MINT1_X_2240_Y_1280 MINT1_X_2240_Y_1536 2.627
R_MINT1_seg_4194 MINT1_X_2240_Y_1536 MINT1_X_2240_Y_1600 656.8m
R_MINT1_seg_4195 MINT1_X_2240_Y_1600 MINT1_X_2240_Y_1920 3.284
R_MINT1_seg_4196 MINT1_X_2240_Y_1920 MINT1_X_2240_Y_2240 3.284
R_MINT1_seg_4197 MINT1_X_2240_Y_2240 MINT1_X_2240_Y_2560 3.284
R_MINT1_seg_4198 MINT1_X_2240_Y_2560 MINT1_X_2240_Y_2880 3.284
R_MINT1_seg_4199 MINT1_X_2240_Y_2880 MINT1_X_2240_Y_3200 3.284
R_MINT1_seg_4200 MINT1_X_2240_Y_3200 MINT1_X_2240_Y_3520 3.284
R_MINT1_seg_4201 MINT1_X_2240_Y_3520 MINT1_X_2240_Y_3584 656.8m
R_MINT1_seg_4202 MINT1_X_2240_Y_3584 MINT1_X_2240_Y_3840 2.627
R_MINT1_seg_4203 MINT1_X_2240_Y_3840 MINT1_X_2240_Y_4160 3.284
R_MINT1_seg_4204 MINT1_X_2240_Y_4160 MINT1_X_2240_Y_4480 3.284
R_MINT1_seg_4205 MINT1_X_2240_Y_4480 MINT1_X_2240_Y_4608 1.314
R_MINT1_seg_4206 MINT1_X_2240_Y_4608 MINT1_X_2240_Y_4800 1.97
R_MINT1_seg_4207 MINT1_X_2240_Y_4800 MINT1_X_2240_Y_5120 3.284
R_MINT1_seg_4208 MINT1_X_2240_Y_5120 MINT1_X_2240_Y_5440 3.284
R_MINT1_seg_4209 MINT1_X_2240_Y_5440 MINT1_X_2240_Y_5632 1.97
R_MINT1_seg_4210 MINT1_X_2240_Y_5632 MINT1_X_2240_Y_5760 1.314
R_MINT1_seg_4211 MINT1_X_2240_Y_5760 MINT1_X_2240_Y_6080 3.284
R_MINT1_seg_4212 MINT1_X_2240_Y_6080 MINT1_X_2240_Y_6400 3.284
R_MINT1_seg_4213 MINT1_X_2240_Y_6400 MINT1_X_2240_Y_6656 2.627
R_MINT1_seg_4214 MINT1_X_2240_Y_6656 MINT1_X_2240_Y_6720 656.8m
R_MINT1_seg_4215 MINT1_X_2240_Y_6720 MINT1_X_2240_Y_7040 3.284
R_MINT1_seg_4216 MINT1_X_2240_Y_7040 MINT1_X_2240_Y_7360 3.284
R_MINT1_seg_4217 MINT1_X_2240_Y_7360 MINT1_X_2240_Y_7680 3.284
R_MINT1_seg_4218 MINT1_X_2240_Y_7680 MINT1_X_2240_Y_8000 3.284
R_MINT1_seg_4219 MINT1_X_2240_Y_8000 MINT1_X_2240_Y_8320 3.284
R_MINT1_seg_4220 MINT1_X_2240_Y_8320 MINT1_X_2240_Y_8640 3.284
R_MINT1_seg_4221 MINT1_X_2240_Y_8640 MINT1_X_2240_Y_8704 656.8m
R_MINT1_seg_4222 MINT1_X_2240_Y_8704 MINT1_X_2240_Y_8960 2.627
R_MINT1_seg_4223 MINT1_X_2240_Y_8960 MINT1_X_2240_Y_9280 3.284
R_MINT1_seg_4224 MINT1_X_2240_Y_9280 MINT1_X_2240_Y_9600 3.284
R_MINT1_seg_4225 MINT1_X_2240_Y_9600 MINT1_X_2240_Y_9728 1.314
R_MINT1_seg_4226 MINT1_X_2240_Y_9728 MINT1_X_2240_Y_9920 1.97
R_MINT1_seg_4227 MINT1_X_2240_Y_9920 MINT1_X_2240_Y_10000 821m
R_MINT1_seg_4228 MINT1_X_2560_Y_0 MINT1_X_2560_Y_320 3.284
R_MINT1_seg_4229 MINT1_X_2560_Y_320 MINT1_X_2560_Y_640 3.284
R_MINT1_seg_4230 MINT1_X_2560_Y_640 MINT1_X_2560_Y_960 3.284
R_MINT1_seg_4231 MINT1_X_2560_Y_960 MINT1_X_2560_Y_1024 656.8m
R_MINT1_seg_4232 MINT1_X_2560_Y_1024 MINT1_X_2560_Y_1280 2.627
R_MINT1_seg_4233 MINT1_X_2560_Y_1280 MINT1_X_2560_Y_1600 3.284
R_MINT1_seg_4234 MINT1_X_2560_Y_1600 MINT1_X_2560_Y_1920 3.284
R_MINT1_seg_4235 MINT1_X_2560_Y_1920 MINT1_X_2560_Y_2048 1.314
R_MINT1_seg_4236 MINT1_X_2560_Y_2048 MINT1_X_2560_Y_2240 1.97
R_MINT1_seg_4237 MINT1_X_2560_Y_2240 MINT1_X_2560_Y_2560 3.284
R_MINT1_seg_4238 MINT1_X_2560_Y_2560 MINT1_X_2560_Y_2880 3.284
R_MINT1_seg_4239 MINT1_X_2560_Y_2880 MINT1_X_2560_Y_3072 1.97
R_MINT1_seg_4240 MINT1_X_2560_Y_3072 MINT1_X_2560_Y_3200 1.314
R_MINT1_seg_4241 MINT1_X_2560_Y_3200 MINT1_X_2560_Y_3520 3.284
R_MINT1_seg_4242 MINT1_X_2560_Y_3520 MINT1_X_2560_Y_3840 3.284
R_MINT1_seg_4243 MINT1_X_2560_Y_3840 MINT1_X_2560_Y_4096 2.627
R_MINT1_seg_4244 MINT1_X_2560_Y_4096 MINT1_X_2560_Y_4160 656.8m
R_MINT1_seg_4245 MINT1_X_2560_Y_4160 MINT1_X_2560_Y_4480 3.284
R_MINT1_seg_4246 MINT1_X_2560_Y_4480 MINT1_X_2560_Y_4800 3.284
R_MINT1_seg_4247 MINT1_X_2560_Y_4800 MINT1_X_2560_Y_5120 3.284
R_MINT1_seg_4248 MINT1_X_2560_Y_5120 MINT1_X_2560_Y_5440 3.284
R_MINT1_seg_4249 MINT1_X_2560_Y_5440 MINT1_X_2560_Y_5760 3.284
R_MINT1_seg_4250 MINT1_X_2560_Y_5760 MINT1_X_2560_Y_6080 3.284
R_MINT1_seg_4251 MINT1_X_2560_Y_6080 MINT1_X_2560_Y_6144 656.8m
R_MINT1_seg_4252 MINT1_X_2560_Y_6144 MINT1_X_2560_Y_6400 2.627
R_MINT1_seg_4253 MINT1_X_2560_Y_6400 MINT1_X_2560_Y_6720 3.284
R_MINT1_seg_4254 MINT1_X_2560_Y_6720 MINT1_X_2560_Y_7040 3.284
R_MINT1_seg_4255 MINT1_X_2560_Y_7040 MINT1_X_2560_Y_7168 1.314
R_MINT1_seg_4256 MINT1_X_2560_Y_7168 MINT1_X_2560_Y_7360 1.97
R_MINT1_seg_4257 MINT1_X_2560_Y_7360 MINT1_X_2560_Y_7680 3.284
R_MINT1_seg_4258 MINT1_X_2560_Y_7680 MINT1_X_2560_Y_8000 3.284
R_MINT1_seg_4259 MINT1_X_2560_Y_8000 MINT1_X_2560_Y_8192 1.97
R_MINT1_seg_4260 MINT1_X_2560_Y_8192 MINT1_X_2560_Y_8320 1.314
R_MINT1_seg_4261 MINT1_X_2560_Y_8320 MINT1_X_2560_Y_8640 3.284
R_MINT1_seg_4262 MINT1_X_2560_Y_8640 MINT1_X_2560_Y_8960 3.284
R_MINT1_seg_4263 MINT1_X_2560_Y_8960 MINT1_X_2560_Y_9216 2.627
R_MINT1_seg_4264 MINT1_X_2560_Y_9216 MINT1_X_2560_Y_9280 656.8m
R_MINT1_seg_4265 MINT1_X_2560_Y_9280 MINT1_X_2560_Y_9600 3.284
R_MINT1_seg_4266 MINT1_X_2560_Y_9600 MINT1_X_2560_Y_9920 3.284
R_MINT1_seg_4267 MINT1_X_2560_Y_9920 MINT1_X_2560_Y_10000 821m
R_MINT1_seg_4268 MINT1_X_2880_Y_0 MINT1_X_2880_Y_320 3.284
R_MINT1_seg_4269 MINT1_X_2880_Y_320 MINT1_X_2880_Y_512 1.97
R_MINT1_seg_4270 MINT1_X_2880_Y_512 MINT1_X_2880_Y_640 1.314
R_MINT1_seg_4271 MINT1_X_2880_Y_640 MINT1_X_2880_Y_960 3.284
R_MINT1_seg_4272 MINT1_X_2880_Y_960 MINT1_X_2880_Y_1280 3.284
R_MINT1_seg_4273 MINT1_X_2880_Y_1280 MINT1_X_2880_Y_1536 2.627
R_MINT1_seg_4274 MINT1_X_2880_Y_1536 MINT1_X_2880_Y_1600 656.8m
R_MINT1_seg_4275 MINT1_X_2880_Y_1600 MINT1_X_2880_Y_1920 3.284
R_MINT1_seg_4276 MINT1_X_2880_Y_1920 MINT1_X_2880_Y_2240 3.284
R_MINT1_seg_4277 MINT1_X_2880_Y_2240 MINT1_X_2880_Y_2560 3.284
R_MINT1_seg_4278 MINT1_X_2880_Y_2560 MINT1_X_2880_Y_2880 3.284
R_MINT1_seg_4279 MINT1_X_2880_Y_2880 MINT1_X_2880_Y_3200 3.284
R_MINT1_seg_4280 MINT1_X_2880_Y_3200 MINT1_X_2880_Y_3520 3.284
R_MINT1_seg_4281 MINT1_X_2880_Y_3520 MINT1_X_2880_Y_3584 656.8m
R_MINT1_seg_4282 MINT1_X_2880_Y_3584 MINT1_X_2880_Y_3840 2.627
R_MINT1_seg_4283 MINT1_X_2880_Y_3840 MINT1_X_2880_Y_4160 3.284
R_MINT1_seg_4284 MINT1_X_2880_Y_4160 MINT1_X_2880_Y_4480 3.284
R_MINT1_seg_4285 MINT1_X_2880_Y_4480 MINT1_X_2880_Y_4608 1.314
R_MINT1_seg_4286 MINT1_X_2880_Y_4608 MINT1_X_2880_Y_4800 1.97
R_MINT1_seg_4287 MINT1_X_2880_Y_4800 MINT1_X_2880_Y_5120 3.284
R_MINT1_seg_4288 MINT1_X_2880_Y_5120 MINT1_X_2880_Y_5440 3.284
R_MINT1_seg_4289 MINT1_X_2880_Y_5440 MINT1_X_2880_Y_5632 1.97
R_MINT1_seg_4290 MINT1_X_2880_Y_5632 MINT1_X_2880_Y_5760 1.314
R_MINT1_seg_4291 MINT1_X_2880_Y_5760 MINT1_X_2880_Y_6080 3.284
R_MINT1_seg_4292 MINT1_X_2880_Y_6080 MINT1_X_2880_Y_6400 3.284
R_MINT1_seg_4293 MINT1_X_2880_Y_6400 MINT1_X_2880_Y_6656 2.627
R_MINT1_seg_4294 MINT1_X_2880_Y_6656 MINT1_X_2880_Y_6720 656.8m
R_MINT1_seg_4295 MINT1_X_2880_Y_6720 MINT1_X_2880_Y_7040 3.284
R_MINT1_seg_4296 MINT1_X_2880_Y_7040 MINT1_X_2880_Y_7360 3.284
R_MINT1_seg_4297 MINT1_X_2880_Y_7360 MINT1_X_2880_Y_7680 3.284
R_MINT1_seg_4298 MINT1_X_2880_Y_7680 MINT1_X_2880_Y_8000 3.284
R_MINT1_seg_4299 MINT1_X_2880_Y_8000 MINT1_X_2880_Y_8320 3.284
R_MINT1_seg_4300 MINT1_X_2880_Y_8320 MINT1_X_2880_Y_8640 3.284
R_MINT1_seg_4301 MINT1_X_2880_Y_8640 MINT1_X_2880_Y_8704 656.8m
R_MINT1_seg_4302 MINT1_X_2880_Y_8704 MINT1_X_2880_Y_8960 2.627
R_MINT1_seg_4303 MINT1_X_2880_Y_8960 MINT1_X_2880_Y_9280 3.284
R_MINT1_seg_4304 MINT1_X_2880_Y_9280 MINT1_X_2880_Y_9600 3.284
R_MINT1_seg_4305 MINT1_X_2880_Y_9600 MINT1_X_2880_Y_9728 1.314
R_MINT1_seg_4306 MINT1_X_2880_Y_9728 MINT1_X_2880_Y_9920 1.97
R_MINT1_seg_4307 MINT1_X_2880_Y_9920 MINT1_X_2880_Y_10000 821m
R_MINT1_seg_4308 MINT1_X_3200_Y_0 MINT1_X_3200_Y_320 3.284
R_MINT1_seg_4309 MINT1_X_3200_Y_320 MINT1_X_3200_Y_640 3.284
R_MINT1_seg_4310 MINT1_X_3200_Y_640 MINT1_X_3200_Y_960 3.284
R_MINT1_seg_4311 MINT1_X_3200_Y_960 MINT1_X_3200_Y_1024 656.8m
R_MINT1_seg_4312 MINT1_X_3200_Y_1024 MINT1_X_3200_Y_1280 2.627
R_MINT1_seg_4313 MINT1_X_3200_Y_1280 MINT1_X_3200_Y_1600 3.284
R_MINT1_seg_4314 MINT1_X_3200_Y_1600 MINT1_X_3200_Y_1920 3.284
R_MINT1_seg_4315 MINT1_X_3200_Y_1920 MINT1_X_3200_Y_2048 1.314
R_MINT1_seg_4316 MINT1_X_3200_Y_2048 MINT1_X_3200_Y_2240 1.97
R_MINT1_seg_4317 MINT1_X_3200_Y_2240 MINT1_X_3200_Y_2560 3.284
R_MINT1_seg_4318 MINT1_X_3200_Y_2560 MINT1_X_3200_Y_2880 3.284
R_MINT1_seg_4319 MINT1_X_3200_Y_2880 MINT1_X_3200_Y_3072 1.97
R_MINT1_seg_4320 MINT1_X_3200_Y_3072 MINT1_X_3200_Y_3200 1.314
R_MINT1_seg_4321 MINT1_X_3200_Y_3200 MINT1_X_3200_Y_3520 3.284
R_MINT1_seg_4322 MINT1_X_3200_Y_3520 MINT1_X_3200_Y_3840 3.284
R_MINT1_seg_4323 MINT1_X_3200_Y_3840 MINT1_X_3200_Y_4096 2.627
R_MINT1_seg_4324 MINT1_X_3200_Y_4096 MINT1_X_3200_Y_4160 656.8m
R_MINT1_seg_4325 MINT1_X_3200_Y_4160 MINT1_X_3200_Y_4480 3.284
R_MINT1_seg_4326 MINT1_X_3200_Y_4480 MINT1_X_3200_Y_4800 3.284
R_MINT1_seg_4327 MINT1_X_3200_Y_4800 MINT1_X_3200_Y_5120 3.284
R_MINT1_seg_4328 MINT1_X_3200_Y_5120 MINT1_X_3200_Y_5440 3.284
R_MINT1_seg_4329 MINT1_X_3200_Y_5440 MINT1_X_3200_Y_5760 3.284
R_MINT1_seg_4330 MINT1_X_3200_Y_5760 MINT1_X_3200_Y_6080 3.284
R_MINT1_seg_4331 MINT1_X_3200_Y_6080 MINT1_X_3200_Y_6144 656.8m
R_MINT1_seg_4332 MINT1_X_3200_Y_6144 MINT1_X_3200_Y_6400 2.627
R_MINT1_seg_4333 MINT1_X_3200_Y_6400 MINT1_X_3200_Y_6720 3.284
R_MINT1_seg_4334 MINT1_X_3200_Y_6720 MINT1_X_3200_Y_7040 3.284
R_MINT1_seg_4335 MINT1_X_3200_Y_7040 MINT1_X_3200_Y_7168 1.314
R_MINT1_seg_4336 MINT1_X_3200_Y_7168 MINT1_X_3200_Y_7360 1.97
R_MINT1_seg_4337 MINT1_X_3200_Y_7360 MINT1_X_3200_Y_7680 3.284
R_MINT1_seg_4338 MINT1_X_3200_Y_7680 MINT1_X_3200_Y_8000 3.284
R_MINT1_seg_4339 MINT1_X_3200_Y_8000 MINT1_X_3200_Y_8192 1.97
R_MINT1_seg_4340 MINT1_X_3200_Y_8192 MINT1_X_3200_Y_8320 1.314
R_MINT1_seg_4341 MINT1_X_3200_Y_8320 MINT1_X_3200_Y_8640 3.284
R_MINT1_seg_4342 MINT1_X_3200_Y_8640 MINT1_X_3200_Y_8960 3.284
R_MINT1_seg_4343 MINT1_X_3200_Y_8960 MINT1_X_3200_Y_9216 2.627
R_MINT1_seg_4344 MINT1_X_3200_Y_9216 MINT1_X_3200_Y_9280 656.8m
R_MINT1_seg_4345 MINT1_X_3200_Y_9280 MINT1_X_3200_Y_9600 3.284
R_MINT1_seg_4346 MINT1_X_3200_Y_9600 MINT1_X_3200_Y_9920 3.284
R_MINT1_seg_4347 MINT1_X_3200_Y_9920 MINT1_X_3200_Y_10000 821m
R_MINT1_seg_4348 MINT1_X_3520_Y_0 MINT1_X_3520_Y_320 3.284
R_MINT1_seg_4349 MINT1_X_3520_Y_320 MINT1_X_3520_Y_512 1.97
R_MINT1_seg_4350 MINT1_X_3520_Y_512 MINT1_X_3520_Y_640 1.314
R_MINT1_seg_4351 MINT1_X_3520_Y_640 MINT1_X_3520_Y_960 3.284
R_MINT1_seg_4352 MINT1_X_3520_Y_960 MINT1_X_3520_Y_1280 3.284
R_MINT1_seg_4353 MINT1_X_3520_Y_1280 MINT1_X_3520_Y_1536 2.627
R_MINT1_seg_4354 MINT1_X_3520_Y_1536 MINT1_X_3520_Y_1600 656.8m
R_MINT1_seg_4355 MINT1_X_3520_Y_1600 MINT1_X_3520_Y_1920 3.284
R_MINT1_seg_4356 MINT1_X_3520_Y_1920 MINT1_X_3520_Y_2240 3.284
R_MINT1_seg_4357 MINT1_X_3520_Y_2240 MINT1_X_3520_Y_2560 3.284
R_MINT1_seg_4358 MINT1_X_3520_Y_2560 MINT1_X_3520_Y_2880 3.284
R_MINT1_seg_4359 MINT1_X_3520_Y_2880 MINT1_X_3520_Y_3200 3.284
R_MINT1_seg_4360 MINT1_X_3520_Y_3200 MINT1_X_3520_Y_3520 3.284
R_MINT1_seg_4361 MINT1_X_3520_Y_3520 MINT1_X_3520_Y_3584 656.8m
R_MINT1_seg_4362 MINT1_X_3520_Y_3584 MINT1_X_3520_Y_3840 2.627
R_MINT1_seg_4363 MINT1_X_3520_Y_3840 MINT1_X_3520_Y_4160 3.284
R_MINT1_seg_4364 MINT1_X_3520_Y_4160 MINT1_X_3520_Y_4480 3.284
R_MINT1_seg_4365 MINT1_X_3520_Y_4480 MINT1_X_3520_Y_4608 1.314
R_MINT1_seg_4366 MINT1_X_3520_Y_4608 MINT1_X_3520_Y_4800 1.97
R_MINT1_seg_4367 MINT1_X_3520_Y_4800 MINT1_X_3520_Y_5120 3.284
R_MINT1_seg_4368 MINT1_X_3520_Y_5120 MINT1_X_3520_Y_5440 3.284
R_MINT1_seg_4369 MINT1_X_3520_Y_5440 MINT1_X_3520_Y_5632 1.97
R_MINT1_seg_4370 MINT1_X_3520_Y_5632 MINT1_X_3520_Y_5760 1.314
R_MINT1_seg_4371 MINT1_X_3520_Y_5760 MINT1_X_3520_Y_6080 3.284
R_MINT1_seg_4372 MINT1_X_3520_Y_6080 MINT1_X_3520_Y_6400 3.284
R_MINT1_seg_4373 MINT1_X_3520_Y_6400 MINT1_X_3520_Y_6656 2.627
R_MINT1_seg_4374 MINT1_X_3520_Y_6656 MINT1_X_3520_Y_6720 656.8m
R_MINT1_seg_4375 MINT1_X_3520_Y_6720 MINT1_X_3520_Y_7040 3.284
R_MINT1_seg_4376 MINT1_X_3520_Y_7040 MINT1_X_3520_Y_7360 3.284
R_MINT1_seg_4377 MINT1_X_3520_Y_7360 MINT1_X_3520_Y_7680 3.284
R_MINT1_seg_4378 MINT1_X_3520_Y_7680 MINT1_X_3520_Y_8000 3.284
R_MINT1_seg_4379 MINT1_X_3520_Y_8000 MINT1_X_3520_Y_8320 3.284
R_MINT1_seg_4380 MINT1_X_3520_Y_8320 MINT1_X_3520_Y_8640 3.284
R_MINT1_seg_4381 MINT1_X_3520_Y_8640 MINT1_X_3520_Y_8704 656.8m
R_MINT1_seg_4382 MINT1_X_3520_Y_8704 MINT1_X_3520_Y_8960 2.627
R_MINT1_seg_4383 MINT1_X_3520_Y_8960 MINT1_X_3520_Y_9280 3.284
R_MINT1_seg_4384 MINT1_X_3520_Y_9280 MINT1_X_3520_Y_9600 3.284
R_MINT1_seg_4385 MINT1_X_3520_Y_9600 MINT1_X_3520_Y_9728 1.314
R_MINT1_seg_4386 MINT1_X_3520_Y_9728 MINT1_X_3520_Y_9920 1.97
R_MINT1_seg_4387 MINT1_X_3520_Y_9920 MINT1_X_3520_Y_10000 821m
R_MINT1_seg_4388 MINT1_X_3840_Y_0 MINT1_X_3840_Y_320 3.284
R_MINT1_seg_4389 MINT1_X_3840_Y_320 MINT1_X_3840_Y_640 3.284
R_MINT1_seg_4390 MINT1_X_3840_Y_640 MINT1_X_3840_Y_960 3.284
R_MINT1_seg_4391 MINT1_X_3840_Y_960 MINT1_X_3840_Y_1024 656.8m
R_MINT1_seg_4392 MINT1_X_3840_Y_1024 MINT1_X_3840_Y_1280 2.627
R_MINT1_seg_4393 MINT1_X_3840_Y_1280 MINT1_X_3840_Y_1600 3.284
R_MINT1_seg_4394 MINT1_X_3840_Y_1600 MINT1_X_3840_Y_1920 3.284
R_MINT1_seg_4395 MINT1_X_3840_Y_1920 MINT1_X_3840_Y_2048 1.314
R_MINT1_seg_4396 MINT1_X_3840_Y_2048 MINT1_X_3840_Y_2240 1.97
R_MINT1_seg_4397 MINT1_X_3840_Y_2240 MINT1_X_3840_Y_2560 3.284
R_MINT1_seg_4398 MINT1_X_3840_Y_2560 MINT1_X_3840_Y_2880 3.284
R_MINT1_seg_4399 MINT1_X_3840_Y_2880 MINT1_X_3840_Y_3072 1.97
R_MINT1_seg_4400 MINT1_X_3840_Y_3072 MINT1_X_3840_Y_3200 1.314
R_MINT1_seg_4401 MINT1_X_3840_Y_3200 MINT1_X_3840_Y_3520 3.284
R_MINT1_seg_4402 MINT1_X_3840_Y_3520 MINT1_X_3840_Y_3840 3.284
R_MINT1_seg_4403 MINT1_X_3840_Y_3840 MINT1_X_3840_Y_4096 2.627
R_MINT1_seg_4404 MINT1_X_3840_Y_4096 MINT1_X_3840_Y_4160 656.8m
R_MINT1_seg_4405 MINT1_X_3840_Y_4160 MINT1_X_3840_Y_4480 3.284
R_MINT1_seg_4406 MINT1_X_3840_Y_4480 MINT1_X_3840_Y_4800 3.284
R_MINT1_seg_4407 MINT1_X_3840_Y_4800 MINT1_X_3840_Y_5120 3.284
R_MINT1_seg_4408 MINT1_X_3840_Y_5120 MINT1_X_3840_Y_5440 3.284
R_MINT1_seg_4409 MINT1_X_3840_Y_5440 MINT1_X_3840_Y_5760 3.284
R_MINT1_seg_4410 MINT1_X_3840_Y_5760 MINT1_X_3840_Y_6080 3.284
R_MINT1_seg_4411 MINT1_X_3840_Y_6080 MINT1_X_3840_Y_6144 656.8m
R_MINT1_seg_4412 MINT1_X_3840_Y_6144 MINT1_X_3840_Y_6400 2.627
R_MINT1_seg_4413 MINT1_X_3840_Y_6400 MINT1_X_3840_Y_6720 3.284
R_MINT1_seg_4414 MINT1_X_3840_Y_6720 MINT1_X_3840_Y_7040 3.284
R_MINT1_seg_4415 MINT1_X_3840_Y_7040 MINT1_X_3840_Y_7168 1.314
R_MINT1_seg_4416 MINT1_X_3840_Y_7168 MINT1_X_3840_Y_7360 1.97
R_MINT1_seg_4417 MINT1_X_3840_Y_7360 MINT1_X_3840_Y_7680 3.284
R_MINT1_seg_4418 MINT1_X_3840_Y_7680 MINT1_X_3840_Y_8000 3.284
R_MINT1_seg_4419 MINT1_X_3840_Y_8000 MINT1_X_3840_Y_8192 1.97
R_MINT1_seg_4420 MINT1_X_3840_Y_8192 MINT1_X_3840_Y_8320 1.314
R_MINT1_seg_4421 MINT1_X_3840_Y_8320 MINT1_X_3840_Y_8640 3.284
R_MINT1_seg_4422 MINT1_X_3840_Y_8640 MINT1_X_3840_Y_8960 3.284
R_MINT1_seg_4423 MINT1_X_3840_Y_8960 MINT1_X_3840_Y_9216 2.627
R_MINT1_seg_4424 MINT1_X_3840_Y_9216 MINT1_X_3840_Y_9280 656.8m
R_MINT1_seg_4425 MINT1_X_3840_Y_9280 MINT1_X_3840_Y_9600 3.284
R_MINT1_seg_4426 MINT1_X_3840_Y_9600 MINT1_X_3840_Y_9920 3.284
R_MINT1_seg_4427 MINT1_X_3840_Y_9920 MINT1_X_3840_Y_10000 821m
R_MINT1_seg_4428 MINT1_X_4160_Y_0 MINT1_X_4160_Y_320 3.284
R_MINT1_seg_4429 MINT1_X_4160_Y_320 MINT1_X_4160_Y_512 1.97
R_MINT1_seg_4430 MINT1_X_4160_Y_512 MINT1_X_4160_Y_640 1.314
R_MINT1_seg_4431 MINT1_X_4160_Y_640 MINT1_X_4160_Y_960 3.284
R_MINT1_seg_4432 MINT1_X_4160_Y_960 MINT1_X_4160_Y_1280 3.284
R_MINT1_seg_4433 MINT1_X_4160_Y_1280 MINT1_X_4160_Y_1536 2.627
R_MINT1_seg_4434 MINT1_X_4160_Y_1536 MINT1_X_4160_Y_1600 656.8m
R_MINT1_seg_4435 MINT1_X_4160_Y_1600 MINT1_X_4160_Y_1920 3.284
R_MINT1_seg_4436 MINT1_X_4160_Y_1920 MINT1_X_4160_Y_2240 3.284
R_MINT1_seg_4437 MINT1_X_4160_Y_2240 MINT1_X_4160_Y_2560 3.284
R_MINT1_seg_4438 MINT1_X_4160_Y_2560 MINT1_X_4160_Y_2880 3.284
R_MINT1_seg_4439 MINT1_X_4160_Y_2880 MINT1_X_4160_Y_3200 3.284
R_MINT1_seg_4440 MINT1_X_4160_Y_3200 MINT1_X_4160_Y_3520 3.284
R_MINT1_seg_4441 MINT1_X_4160_Y_3520 MINT1_X_4160_Y_3584 656.8m
R_MINT1_seg_4442 MINT1_X_4160_Y_3584 MINT1_X_4160_Y_3840 2.627
R_MINT1_seg_4443 MINT1_X_4160_Y_3840 MINT1_X_4160_Y_4160 3.284
R_MINT1_seg_4444 MINT1_X_4160_Y_4160 MINT1_X_4160_Y_4480 3.284
R_MINT1_seg_4445 MINT1_X_4160_Y_4480 MINT1_X_4160_Y_4608 1.314
R_MINT1_seg_4446 MINT1_X_4160_Y_4608 MINT1_X_4160_Y_4800 1.97
R_MINT1_seg_4447 MINT1_X_4160_Y_4800 MINT1_X_4160_Y_5120 3.284
R_MINT1_seg_4448 MINT1_X_4160_Y_5120 MINT1_X_4160_Y_5440 3.284
R_MINT1_seg_4449 MINT1_X_4160_Y_5440 MINT1_X_4160_Y_5632 1.97
R_MINT1_seg_4450 MINT1_X_4160_Y_5632 MINT1_X_4160_Y_5760 1.314
R_MINT1_seg_4451 MINT1_X_4160_Y_5760 MINT1_X_4160_Y_6080 3.284
R_MINT1_seg_4452 MINT1_X_4160_Y_6080 MINT1_X_4160_Y_6400 3.284
R_MINT1_seg_4453 MINT1_X_4160_Y_6400 MINT1_X_4160_Y_6656 2.627
R_MINT1_seg_4454 MINT1_X_4160_Y_6656 MINT1_X_4160_Y_6720 656.8m
R_MINT1_seg_4455 MINT1_X_4160_Y_6720 MINT1_X_4160_Y_7040 3.284
R_MINT1_seg_4456 MINT1_X_4160_Y_7040 MINT1_X_4160_Y_7360 3.284
R_MINT1_seg_4457 MINT1_X_4160_Y_7360 MINT1_X_4160_Y_7680 3.284
R_MINT1_seg_4458 MINT1_X_4160_Y_7680 MINT1_X_4160_Y_8000 3.284
R_MINT1_seg_4459 MINT1_X_4160_Y_8000 MINT1_X_4160_Y_8320 3.284
R_MINT1_seg_4460 MINT1_X_4160_Y_8320 MINT1_X_4160_Y_8640 3.284
R_MINT1_seg_4461 MINT1_X_4160_Y_8640 MINT1_X_4160_Y_8704 656.8m
R_MINT1_seg_4462 MINT1_X_4160_Y_8704 MINT1_X_4160_Y_8960 2.627
R_MINT1_seg_4463 MINT1_X_4160_Y_8960 MINT1_X_4160_Y_9280 3.284
R_MINT1_seg_4464 MINT1_X_4160_Y_9280 MINT1_X_4160_Y_9600 3.284
R_MINT1_seg_4465 MINT1_X_4160_Y_9600 MINT1_X_4160_Y_9728 1.314
R_MINT1_seg_4466 MINT1_X_4160_Y_9728 MINT1_X_4160_Y_9920 1.97
R_MINT1_seg_4467 MINT1_X_4160_Y_9920 MINT1_X_4160_Y_10000 821m
R_MINT1_seg_4468 MINT1_X_4480_Y_0 MINT1_X_4480_Y_320 3.284
R_MINT1_seg_4469 MINT1_X_4480_Y_320 MINT1_X_4480_Y_640 3.284
R_MINT1_seg_4470 MINT1_X_4480_Y_640 MINT1_X_4480_Y_960 3.284
R_MINT1_seg_4471 MINT1_X_4480_Y_960 MINT1_X_4480_Y_1024 656.8m
R_MINT1_seg_4472 MINT1_X_4480_Y_1024 MINT1_X_4480_Y_1280 2.627
R_MINT1_seg_4473 MINT1_X_4480_Y_1280 MINT1_X_4480_Y_1600 3.284
R_MINT1_seg_4474 MINT1_X_4480_Y_1600 MINT1_X_4480_Y_1920 3.284
R_MINT1_seg_4475 MINT1_X_4480_Y_1920 MINT1_X_4480_Y_2048 1.314
R_MINT1_seg_4476 MINT1_X_4480_Y_2048 MINT1_X_4480_Y_2240 1.97
R_MINT1_seg_4477 MINT1_X_4480_Y_2240 MINT1_X_4480_Y_2560 3.284
R_MINT1_seg_4478 MINT1_X_4480_Y_2560 MINT1_X_4480_Y_2880 3.284
R_MINT1_seg_4479 MINT1_X_4480_Y_2880 MINT1_X_4480_Y_3072 1.97
R_MINT1_seg_4480 MINT1_X_4480_Y_3072 MINT1_X_4480_Y_3200 1.314
R_MINT1_seg_4481 MINT1_X_4480_Y_3200 MINT1_X_4480_Y_3520 3.284
R_MINT1_seg_4482 MINT1_X_4480_Y_3520 MINT1_X_4480_Y_3840 3.284
R_MINT1_seg_4483 MINT1_X_4480_Y_3840 MINT1_X_4480_Y_4096 2.627
R_MINT1_seg_4484 MINT1_X_4480_Y_4096 MINT1_X_4480_Y_4160 656.8m
R_MINT1_seg_4485 MINT1_X_4480_Y_4160 MINT1_X_4480_Y_4480 3.284
R_MINT1_seg_4486 MINT1_X_4480_Y_4480 MINT1_X_4480_Y_4800 3.284
R_MINT1_seg_4487 MINT1_X_4480_Y_4800 MINT1_X_4480_Y_5120 3.284
R_MINT1_seg_4488 MINT1_X_4480_Y_5120 MINT1_X_4480_Y_5440 3.284
R_MINT1_seg_4489 MINT1_X_4480_Y_5440 MINT1_X_4480_Y_5760 3.284
R_MINT1_seg_4490 MINT1_X_4480_Y_5760 MINT1_X_4480_Y_6080 3.284
R_MINT1_seg_4491 MINT1_X_4480_Y_6080 MINT1_X_4480_Y_6144 656.8m
R_MINT1_seg_4492 MINT1_X_4480_Y_6144 MINT1_X_4480_Y_6400 2.627
R_MINT1_seg_4493 MINT1_X_4480_Y_6400 MINT1_X_4480_Y_6720 3.284
R_MINT1_seg_4494 MINT1_X_4480_Y_6720 MINT1_X_4480_Y_7040 3.284
R_MINT1_seg_4495 MINT1_X_4480_Y_7040 MINT1_X_4480_Y_7168 1.314
R_MINT1_seg_4496 MINT1_X_4480_Y_7168 MINT1_X_4480_Y_7360 1.97
R_MINT1_seg_4497 MINT1_X_4480_Y_7360 MINT1_X_4480_Y_7680 3.284
R_MINT1_seg_4498 MINT1_X_4480_Y_7680 MINT1_X_4480_Y_8000 3.284
R_MINT1_seg_4499 MINT1_X_4480_Y_8000 MINT1_X_4480_Y_8192 1.97
R_MINT1_seg_4500 MINT1_X_4480_Y_8192 MINT1_X_4480_Y_8320 1.314
R_MINT1_seg_4501 MINT1_X_4480_Y_8320 MINT1_X_4480_Y_8640 3.284
R_MINT1_seg_4502 MINT1_X_4480_Y_8640 MINT1_X_4480_Y_8960 3.284
R_MINT1_seg_4503 MINT1_X_4480_Y_8960 MINT1_X_4480_Y_9216 2.627
R_MINT1_seg_4504 MINT1_X_4480_Y_9216 MINT1_X_4480_Y_9280 656.8m
R_MINT1_seg_4505 MINT1_X_4480_Y_9280 MINT1_X_4480_Y_9600 3.284
R_MINT1_seg_4506 MINT1_X_4480_Y_9600 MINT1_X_4480_Y_9920 3.284
R_MINT1_seg_4507 MINT1_X_4480_Y_9920 MINT1_X_4480_Y_10000 821m
R_MINT1_seg_4508 MINT1_X_4800_Y_0 MINT1_X_4800_Y_320 3.284
R_MINT1_seg_4509 MINT1_X_4800_Y_320 MINT1_X_4800_Y_512 1.97
R_MINT1_seg_4510 MINT1_X_4800_Y_512 MINT1_X_4800_Y_640 1.314
R_MINT1_seg_4511 MINT1_X_4800_Y_640 MINT1_X_4800_Y_960 3.284
R_MINT1_seg_4512 MINT1_X_4800_Y_960 MINT1_X_4800_Y_1280 3.284
R_MINT1_seg_4513 MINT1_X_4800_Y_1280 MINT1_X_4800_Y_1536 2.627
R_MINT1_seg_4514 MINT1_X_4800_Y_1536 MINT1_X_4800_Y_1600 656.8m
R_MINT1_seg_4515 MINT1_X_4800_Y_1600 MINT1_X_4800_Y_1920 3.284
R_MINT1_seg_4516 MINT1_X_4800_Y_1920 MINT1_X_4800_Y_2240 3.284
R_MINT1_seg_4517 MINT1_X_4800_Y_2240 MINT1_X_4800_Y_2560 3.284
R_MINT1_seg_4518 MINT1_X_4800_Y_2560 MINT1_X_4800_Y_2880 3.284
R_MINT1_seg_4519 MINT1_X_4800_Y_2880 MINT1_X_4800_Y_3200 3.284
R_MINT1_seg_4520 MINT1_X_4800_Y_3200 MINT1_X_4800_Y_3520 3.284
R_MINT1_seg_4521 MINT1_X_4800_Y_3520 MINT1_X_4800_Y_3584 656.8m
R_MINT1_seg_4522 MINT1_X_4800_Y_3584 MINT1_X_4800_Y_3840 2.627
R_MINT1_seg_4523 MINT1_X_4800_Y_3840 MINT1_X_4800_Y_4160 3.284
R_MINT1_seg_4524 MINT1_X_4800_Y_4160 MINT1_X_4800_Y_4480 3.284
R_MINT1_seg_4525 MINT1_X_4800_Y_4480 MINT1_X_4800_Y_4608 1.314
R_MINT1_seg_4526 MINT1_X_4800_Y_4608 MINT1_X_4800_Y_4800 1.97
R_MINT1_seg_4527 MINT1_X_4800_Y_4800 MINT1_X_4800_Y_5120 3.284
R_MINT1_seg_4528 MINT1_X_4800_Y_5120 MINT1_X_4800_Y_5440 3.284
R_MINT1_seg_4529 MINT1_X_4800_Y_5440 MINT1_X_4800_Y_5632 1.97
R_MINT1_seg_4530 MINT1_X_4800_Y_5632 MINT1_X_4800_Y_5760 1.314
R_MINT1_seg_4531 MINT1_X_4800_Y_5760 MINT1_X_4800_Y_6080 3.284
R_MINT1_seg_4532 MINT1_X_4800_Y_6080 MINT1_X_4800_Y_6400 3.284
R_MINT1_seg_4533 MINT1_X_4800_Y_6400 MINT1_X_4800_Y_6656 2.627
R_MINT1_seg_4534 MINT1_X_4800_Y_6656 MINT1_X_4800_Y_6720 656.8m
R_MINT1_seg_4535 MINT1_X_4800_Y_6720 MINT1_X_4800_Y_7040 3.284
R_MINT1_seg_4536 MINT1_X_4800_Y_7040 MINT1_X_4800_Y_7360 3.284
R_MINT1_seg_4537 MINT1_X_4800_Y_7360 MINT1_X_4800_Y_7680 3.284
R_MINT1_seg_4538 MINT1_X_4800_Y_7680 MINT1_X_4800_Y_8000 3.284
R_MINT1_seg_4539 MINT1_X_4800_Y_8000 MINT1_X_4800_Y_8320 3.284
R_MINT1_seg_4540 MINT1_X_4800_Y_8320 MINT1_X_4800_Y_8640 3.284
R_MINT1_seg_4541 MINT1_X_4800_Y_8640 MINT1_X_4800_Y_8704 656.8m
R_MINT1_seg_4542 MINT1_X_4800_Y_8704 MINT1_X_4800_Y_8960 2.627
R_MINT1_seg_4543 MINT1_X_4800_Y_8960 MINT1_X_4800_Y_9280 3.284
R_MINT1_seg_4544 MINT1_X_4800_Y_9280 MINT1_X_4800_Y_9600 3.284
R_MINT1_seg_4545 MINT1_X_4800_Y_9600 MINT1_X_4800_Y_9728 1.314
R_MINT1_seg_4546 MINT1_X_4800_Y_9728 MINT1_X_4800_Y_9920 1.97
R_MINT1_seg_4547 MINT1_X_4800_Y_9920 MINT1_X_4800_Y_10000 821m
R_MINT1_seg_4548 MINT1_X_5120_Y_0 MINT1_X_5120_Y_320 3.284
R_MINT1_seg_4549 MINT1_X_5120_Y_320 MINT1_X_5120_Y_640 3.284
R_MINT1_seg_4550 MINT1_X_5120_Y_640 MINT1_X_5120_Y_960 3.284
R_MINT1_seg_4551 MINT1_X_5120_Y_960 MINT1_X_5120_Y_1024 656.8m
R_MINT1_seg_4552 MINT1_X_5120_Y_1024 MINT1_X_5120_Y_1280 2.627
R_MINT1_seg_4553 MINT1_X_5120_Y_1280 MINT1_X_5120_Y_1600 3.284
R_MINT1_seg_4554 MINT1_X_5120_Y_1600 MINT1_X_5120_Y_1920 3.284
R_MINT1_seg_4555 MINT1_X_5120_Y_1920 MINT1_X_5120_Y_2048 1.314
R_MINT1_seg_4556 MINT1_X_5120_Y_2048 MINT1_X_5120_Y_2240 1.97
R_MINT1_seg_4557 MINT1_X_5120_Y_2240 MINT1_X_5120_Y_2560 3.284
R_MINT1_seg_4558 MINT1_X_5120_Y_2560 MINT1_X_5120_Y_2880 3.284
R_MINT1_seg_4559 MINT1_X_5120_Y_2880 MINT1_X_5120_Y_3072 1.97
R_MINT1_seg_4560 MINT1_X_5120_Y_3072 MINT1_X_5120_Y_3200 1.314
R_MINT1_seg_4561 MINT1_X_5120_Y_3200 MINT1_X_5120_Y_3520 3.284
R_MINT1_seg_4562 MINT1_X_5120_Y_3520 MINT1_X_5120_Y_3840 3.284
R_MINT1_seg_4563 MINT1_X_5120_Y_3840 MINT1_X_5120_Y_4096 2.627
R_MINT1_seg_4564 MINT1_X_5120_Y_4096 MINT1_X_5120_Y_4160 656.8m
R_MINT1_seg_4565 MINT1_X_5120_Y_4160 MINT1_X_5120_Y_4480 3.284
R_MINT1_seg_4566 MINT1_X_5120_Y_4480 MINT1_X_5120_Y_4800 3.284
R_MINT1_seg_4567 MINT1_X_5120_Y_4800 MINT1_X_5120_Y_5120 3.284
R_MINT1_seg_4568 MINT1_X_5120_Y_5120 MINT1_X_5120_Y_5440 3.284
R_MINT1_seg_4569 MINT1_X_5120_Y_5440 MINT1_X_5120_Y_5760 3.284
R_MINT1_seg_4570 MINT1_X_5120_Y_5760 MINT1_X_5120_Y_6080 3.284
R_MINT1_seg_4571 MINT1_X_5120_Y_6080 MINT1_X_5120_Y_6144 656.8m
R_MINT1_seg_4572 MINT1_X_5120_Y_6144 MINT1_X_5120_Y_6400 2.627
R_MINT1_seg_4573 MINT1_X_5120_Y_6400 MINT1_X_5120_Y_6720 3.284
R_MINT1_seg_4574 MINT1_X_5120_Y_6720 MINT1_X_5120_Y_7040 3.284
R_MINT1_seg_4575 MINT1_X_5120_Y_7040 MINT1_X_5120_Y_7168 1.314
R_MINT1_seg_4576 MINT1_X_5120_Y_7168 MINT1_X_5120_Y_7360 1.97
R_MINT1_seg_4577 MINT1_X_5120_Y_7360 MINT1_X_5120_Y_7680 3.284
R_MINT1_seg_4578 MINT1_X_5120_Y_7680 MINT1_X_5120_Y_8000 3.284
R_MINT1_seg_4579 MINT1_X_5120_Y_8000 MINT1_X_5120_Y_8192 1.97
R_MINT1_seg_4580 MINT1_X_5120_Y_8192 MINT1_X_5120_Y_8320 1.314
R_MINT1_seg_4581 MINT1_X_5120_Y_8320 MINT1_X_5120_Y_8640 3.284
R_MINT1_seg_4582 MINT1_X_5120_Y_8640 MINT1_X_5120_Y_8960 3.284
R_MINT1_seg_4583 MINT1_X_5120_Y_8960 MINT1_X_5120_Y_9216 2.627
R_MINT1_seg_4584 MINT1_X_5120_Y_9216 MINT1_X_5120_Y_9280 656.8m
R_MINT1_seg_4585 MINT1_X_5120_Y_9280 MINT1_X_5120_Y_9600 3.284
R_MINT1_seg_4586 MINT1_X_5120_Y_9600 MINT1_X_5120_Y_9920 3.284
R_MINT1_seg_4587 MINT1_X_5120_Y_9920 MINT1_X_5120_Y_10000 821m
R_MINT1_seg_4588 MINT1_X_5440_Y_0 MINT1_X_5440_Y_320 3.284
R_MINT1_seg_4589 MINT1_X_5440_Y_320 MINT1_X_5440_Y_512 1.97
R_MINT1_seg_4590 MINT1_X_5440_Y_512 MINT1_X_5440_Y_640 1.314
R_MINT1_seg_4591 MINT1_X_5440_Y_640 MINT1_X_5440_Y_960 3.284
R_MINT1_seg_4592 MINT1_X_5440_Y_960 MINT1_X_5440_Y_1280 3.284
R_MINT1_seg_4593 MINT1_X_5440_Y_1280 MINT1_X_5440_Y_1536 2.627
R_MINT1_seg_4594 MINT1_X_5440_Y_1536 MINT1_X_5440_Y_1600 656.8m
R_MINT1_seg_4595 MINT1_X_5440_Y_1600 MINT1_X_5440_Y_1920 3.284
R_MINT1_seg_4596 MINT1_X_5440_Y_1920 MINT1_X_5440_Y_2240 3.284
R_MINT1_seg_4597 MINT1_X_5440_Y_2240 MINT1_X_5440_Y_2560 3.284
R_MINT1_seg_4598 MINT1_X_5440_Y_2560 MINT1_X_5440_Y_2880 3.284
R_MINT1_seg_4599 MINT1_X_5440_Y_2880 MINT1_X_5440_Y_3200 3.284
R_MINT1_seg_4600 MINT1_X_5440_Y_3200 MINT1_X_5440_Y_3520 3.284
R_MINT1_seg_4601 MINT1_X_5440_Y_3520 MINT1_X_5440_Y_3584 656.8m
R_MINT1_seg_4602 MINT1_X_5440_Y_3584 MINT1_X_5440_Y_3840 2.627
R_MINT1_seg_4603 MINT1_X_5440_Y_3840 MINT1_X_5440_Y_4160 3.284
R_MINT1_seg_4604 MINT1_X_5440_Y_4160 MINT1_X_5440_Y_4480 3.284
R_MINT1_seg_4605 MINT1_X_5440_Y_4480 MINT1_X_5440_Y_4608 1.314
R_MINT1_seg_4606 MINT1_X_5440_Y_4608 MINT1_X_5440_Y_4800 1.97
R_MINT1_seg_4607 MINT1_X_5440_Y_4800 MINT1_X_5440_Y_5120 3.284
R_MINT1_seg_4608 MINT1_X_5440_Y_5120 MINT1_X_5440_Y_5440 3.284
R_MINT1_seg_4609 MINT1_X_5440_Y_5440 MINT1_X_5440_Y_5632 1.97
R_MINT1_seg_4610 MINT1_X_5440_Y_5632 MINT1_X_5440_Y_5760 1.314
R_MINT1_seg_4611 MINT1_X_5440_Y_5760 MINT1_X_5440_Y_6080 3.284
R_MINT1_seg_4612 MINT1_X_5440_Y_6080 MINT1_X_5440_Y_6400 3.284
R_MINT1_seg_4613 MINT1_X_5440_Y_6400 MINT1_X_5440_Y_6656 2.627
R_MINT1_seg_4614 MINT1_X_5440_Y_6656 MINT1_X_5440_Y_6720 656.8m
R_MINT1_seg_4615 MINT1_X_5440_Y_6720 MINT1_X_5440_Y_7040 3.284
R_MINT1_seg_4616 MINT1_X_5440_Y_7040 MINT1_X_5440_Y_7360 3.284
R_MINT1_seg_4617 MINT1_X_5440_Y_7360 MINT1_X_5440_Y_7680 3.284
R_MINT1_seg_4618 MINT1_X_5440_Y_7680 MINT1_X_5440_Y_8000 3.284
R_MINT1_seg_4619 MINT1_X_5440_Y_8000 MINT1_X_5440_Y_8320 3.284
R_MINT1_seg_4620 MINT1_X_5440_Y_8320 MINT1_X_5440_Y_8640 3.284
R_MINT1_seg_4621 MINT1_X_5440_Y_8640 MINT1_X_5440_Y_8704 656.8m
R_MINT1_seg_4622 MINT1_X_5440_Y_8704 MINT1_X_5440_Y_8960 2.627
R_MINT1_seg_4623 MINT1_X_5440_Y_8960 MINT1_X_5440_Y_9280 3.284
R_MINT1_seg_4624 MINT1_X_5440_Y_9280 MINT1_X_5440_Y_9600 3.284
R_MINT1_seg_4625 MINT1_X_5440_Y_9600 MINT1_X_5440_Y_9728 1.314
R_MINT1_seg_4626 MINT1_X_5440_Y_9728 MINT1_X_5440_Y_9920 1.97
R_MINT1_seg_4627 MINT1_X_5440_Y_9920 MINT1_X_5440_Y_10000 821m
R_MINT1_seg_4628 MINT1_X_5760_Y_0 MINT1_X_5760_Y_320 3.284
R_MINT1_seg_4629 MINT1_X_5760_Y_320 MINT1_X_5760_Y_640 3.284
R_MINT1_seg_4630 MINT1_X_5760_Y_640 MINT1_X_5760_Y_960 3.284
R_MINT1_seg_4631 MINT1_X_5760_Y_960 MINT1_X_5760_Y_1024 656.8m
R_MINT1_seg_4632 MINT1_X_5760_Y_1024 MINT1_X_5760_Y_1280 2.627
R_MINT1_seg_4633 MINT1_X_5760_Y_1280 MINT1_X_5760_Y_1600 3.284
R_MINT1_seg_4634 MINT1_X_5760_Y_1600 MINT1_X_5760_Y_1920 3.284
R_MINT1_seg_4635 MINT1_X_5760_Y_1920 MINT1_X_5760_Y_2048 1.314
R_MINT1_seg_4636 MINT1_X_5760_Y_2048 MINT1_X_5760_Y_2240 1.97
R_MINT1_seg_4637 MINT1_X_5760_Y_2240 MINT1_X_5760_Y_2560 3.284
R_MINT1_seg_4638 MINT1_X_5760_Y_2560 MINT1_X_5760_Y_2880 3.284
R_MINT1_seg_4639 MINT1_X_5760_Y_2880 MINT1_X_5760_Y_3072 1.97
R_MINT1_seg_4640 MINT1_X_5760_Y_3072 MINT1_X_5760_Y_3200 1.314
R_MINT1_seg_4641 MINT1_X_5760_Y_3200 MINT1_X_5760_Y_3520 3.284
R_MINT1_seg_4642 MINT1_X_5760_Y_3520 MINT1_X_5760_Y_3840 3.284
R_MINT1_seg_4643 MINT1_X_5760_Y_3840 MINT1_X_5760_Y_4096 2.627
R_MINT1_seg_4644 MINT1_X_5760_Y_4096 MINT1_X_5760_Y_4160 656.8m
R_MINT1_seg_4645 MINT1_X_5760_Y_4160 MINT1_X_5760_Y_4480 3.284
R_MINT1_seg_4646 MINT1_X_5760_Y_4480 MINT1_X_5760_Y_4800 3.284
R_MINT1_seg_4647 MINT1_X_5760_Y_4800 MINT1_X_5760_Y_5120 3.284
R_MINT1_seg_4648 MINT1_X_5760_Y_5120 MINT1_X_5760_Y_5440 3.284
R_MINT1_seg_4649 MINT1_X_5760_Y_5440 MINT1_X_5760_Y_5760 3.284
R_MINT1_seg_4650 MINT1_X_5760_Y_5760 MINT1_X_5760_Y_6080 3.284
R_MINT1_seg_4651 MINT1_X_5760_Y_6080 MINT1_X_5760_Y_6144 656.8m
R_MINT1_seg_4652 MINT1_X_5760_Y_6144 MINT1_X_5760_Y_6400 2.627
R_MINT1_seg_4653 MINT1_X_5760_Y_6400 MINT1_X_5760_Y_6720 3.284
R_MINT1_seg_4654 MINT1_X_5760_Y_6720 MINT1_X_5760_Y_7040 3.284
R_MINT1_seg_4655 MINT1_X_5760_Y_7040 MINT1_X_5760_Y_7168 1.314
R_MINT1_seg_4656 MINT1_X_5760_Y_7168 MINT1_X_5760_Y_7360 1.97
R_MINT1_seg_4657 MINT1_X_5760_Y_7360 MINT1_X_5760_Y_7680 3.284
R_MINT1_seg_4658 MINT1_X_5760_Y_7680 MINT1_X_5760_Y_8000 3.284
R_MINT1_seg_4659 MINT1_X_5760_Y_8000 MINT1_X_5760_Y_8192 1.97
R_MINT1_seg_4660 MINT1_X_5760_Y_8192 MINT1_X_5760_Y_8320 1.314
R_MINT1_seg_4661 MINT1_X_5760_Y_8320 MINT1_X_5760_Y_8640 3.284
R_MINT1_seg_4662 MINT1_X_5760_Y_8640 MINT1_X_5760_Y_8960 3.284
R_MINT1_seg_4663 MINT1_X_5760_Y_8960 MINT1_X_5760_Y_9216 2.627
R_MINT1_seg_4664 MINT1_X_5760_Y_9216 MINT1_X_5760_Y_9280 656.8m
R_MINT1_seg_4665 MINT1_X_5760_Y_9280 MINT1_X_5760_Y_9600 3.284
R_MINT1_seg_4666 MINT1_X_5760_Y_9600 MINT1_X_5760_Y_9920 3.284
R_MINT1_seg_4667 MINT1_X_5760_Y_9920 MINT1_X_5760_Y_10000 821m
R_MINT1_seg_4668 MINT1_X_6080_Y_0 MINT1_X_6080_Y_320 3.284
R_MINT1_seg_4669 MINT1_X_6080_Y_320 MINT1_X_6080_Y_512 1.97
R_MINT1_seg_4670 MINT1_X_6080_Y_512 MINT1_X_6080_Y_640 1.314
R_MINT1_seg_4671 MINT1_X_6080_Y_640 MINT1_X_6080_Y_960 3.284
R_MINT1_seg_4672 MINT1_X_6080_Y_960 MINT1_X_6080_Y_1280 3.284
R_MINT1_seg_4673 MINT1_X_6080_Y_1280 MINT1_X_6080_Y_1536 2.627
R_MINT1_seg_4674 MINT1_X_6080_Y_1536 MINT1_X_6080_Y_1600 656.8m
R_MINT1_seg_4675 MINT1_X_6080_Y_1600 MINT1_X_6080_Y_1920 3.284
R_MINT1_seg_4676 MINT1_X_6080_Y_1920 MINT1_X_6080_Y_2240 3.284
R_MINT1_seg_4677 MINT1_X_6080_Y_2240 MINT1_X_6080_Y_2560 3.284
R_MINT1_seg_4678 MINT1_X_6080_Y_2560 MINT1_X_6080_Y_2880 3.284
R_MINT1_seg_4679 MINT1_X_6080_Y_2880 MINT1_X_6080_Y_3200 3.284
R_MINT1_seg_4680 MINT1_X_6080_Y_3200 MINT1_X_6080_Y_3520 3.284
R_MINT1_seg_4681 MINT1_X_6080_Y_3520 MINT1_X_6080_Y_3584 656.8m
R_MINT1_seg_4682 MINT1_X_6080_Y_3584 MINT1_X_6080_Y_3840 2.627
R_MINT1_seg_4683 MINT1_X_6080_Y_3840 MINT1_X_6080_Y_4160 3.284
R_MINT1_seg_4684 MINT1_X_6080_Y_4160 MINT1_X_6080_Y_4480 3.284
R_MINT1_seg_4685 MINT1_X_6080_Y_4480 MINT1_X_6080_Y_4608 1.314
R_MINT1_seg_4686 MINT1_X_6080_Y_4608 MINT1_X_6080_Y_4800 1.97
R_MINT1_seg_4687 MINT1_X_6080_Y_4800 MINT1_X_6080_Y_5120 3.284
R_MINT1_seg_4688 MINT1_X_6080_Y_5120 MINT1_X_6080_Y_5440 3.284
R_MINT1_seg_4689 MINT1_X_6080_Y_5440 MINT1_X_6080_Y_5632 1.97
R_MINT1_seg_4690 MINT1_X_6080_Y_5632 MINT1_X_6080_Y_5760 1.314
R_MINT1_seg_4691 MINT1_X_6080_Y_5760 MINT1_X_6080_Y_6080 3.284
R_MINT1_seg_4692 MINT1_X_6080_Y_6080 MINT1_X_6080_Y_6400 3.284
R_MINT1_seg_4693 MINT1_X_6080_Y_6400 MINT1_X_6080_Y_6656 2.627
R_MINT1_seg_4694 MINT1_X_6080_Y_6656 MINT1_X_6080_Y_6720 656.8m
R_MINT1_seg_4695 MINT1_X_6080_Y_6720 MINT1_X_6080_Y_7040 3.284
R_MINT1_seg_4696 MINT1_X_6080_Y_7040 MINT1_X_6080_Y_7360 3.284
R_MINT1_seg_4697 MINT1_X_6080_Y_7360 MINT1_X_6080_Y_7680 3.284
R_MINT1_seg_4698 MINT1_X_6080_Y_7680 MINT1_X_6080_Y_8000 3.284
R_MINT1_seg_4699 MINT1_X_6080_Y_8000 MINT1_X_6080_Y_8320 3.284
R_MINT1_seg_4700 MINT1_X_6080_Y_8320 MINT1_X_6080_Y_8640 3.284
R_MINT1_seg_4701 MINT1_X_6080_Y_8640 MINT1_X_6080_Y_8704 656.8m
R_MINT1_seg_4702 MINT1_X_6080_Y_8704 MINT1_X_6080_Y_8960 2.627
R_MINT1_seg_4703 MINT1_X_6080_Y_8960 MINT1_X_6080_Y_9280 3.284
R_MINT1_seg_4704 MINT1_X_6080_Y_9280 MINT1_X_6080_Y_9600 3.284
R_MINT1_seg_4705 MINT1_X_6080_Y_9600 MINT1_X_6080_Y_9728 1.314
R_MINT1_seg_4706 MINT1_X_6080_Y_9728 MINT1_X_6080_Y_9920 1.97
R_MINT1_seg_4707 MINT1_X_6080_Y_9920 MINT1_X_6080_Y_10000 821m
R_MINT1_seg_4708 MINT1_X_6400_Y_0 MINT1_X_6400_Y_320 3.284
R_MINT1_seg_4709 MINT1_X_6400_Y_320 MINT1_X_6400_Y_640 3.284
R_MINT1_seg_4710 MINT1_X_6400_Y_640 MINT1_X_6400_Y_960 3.284
R_MINT1_seg_4711 MINT1_X_6400_Y_960 MINT1_X_6400_Y_1024 656.8m
R_MINT1_seg_4712 MINT1_X_6400_Y_1024 MINT1_X_6400_Y_1280 2.627
R_MINT1_seg_4713 MINT1_X_6400_Y_1280 MINT1_X_6400_Y_1600 3.284
R_MINT1_seg_4714 MINT1_X_6400_Y_1600 MINT1_X_6400_Y_1920 3.284
R_MINT1_seg_4715 MINT1_X_6400_Y_1920 MINT1_X_6400_Y_2048 1.314
R_MINT1_seg_4716 MINT1_X_6400_Y_2048 MINT1_X_6400_Y_2240 1.97
R_MINT1_seg_4717 MINT1_X_6400_Y_2240 MINT1_X_6400_Y_2560 3.284
R_MINT1_seg_4718 MINT1_X_6400_Y_2560 MINT1_X_6400_Y_2880 3.284
R_MINT1_seg_4719 MINT1_X_6400_Y_2880 MINT1_X_6400_Y_3072 1.97
R_MINT1_seg_4720 MINT1_X_6400_Y_3072 MINT1_X_6400_Y_3200 1.314
R_MINT1_seg_4721 MINT1_X_6400_Y_3200 MINT1_X_6400_Y_3520 3.284
R_MINT1_seg_4722 MINT1_X_6400_Y_3520 MINT1_X_6400_Y_3840 3.284
R_MINT1_seg_4723 MINT1_X_6400_Y_3840 MINT1_X_6400_Y_4096 2.627
R_MINT1_seg_4724 MINT1_X_6400_Y_4096 MINT1_X_6400_Y_4160 656.8m
R_MINT1_seg_4725 MINT1_X_6400_Y_4160 MINT1_X_6400_Y_4480 3.284
R_MINT1_seg_4726 MINT1_X_6400_Y_4480 MINT1_X_6400_Y_4800 3.284
R_MINT1_seg_4727 MINT1_X_6400_Y_4800 MINT1_X_6400_Y_5120 3.284
R_MINT1_seg_4728 MINT1_X_6400_Y_5120 MINT1_X_6400_Y_5440 3.284
R_MINT1_seg_4729 MINT1_X_6400_Y_5440 MINT1_X_6400_Y_5760 3.284
R_MINT1_seg_4730 MINT1_X_6400_Y_5760 MINT1_X_6400_Y_6080 3.284
R_MINT1_seg_4731 MINT1_X_6400_Y_6080 MINT1_X_6400_Y_6144 656.8m
R_MINT1_seg_4732 MINT1_X_6400_Y_6144 MINT1_X_6400_Y_6400 2.627
R_MINT1_seg_4733 MINT1_X_6400_Y_6400 MINT1_X_6400_Y_6720 3.284
R_MINT1_seg_4734 MINT1_X_6400_Y_6720 MINT1_X_6400_Y_7040 3.284
R_MINT1_seg_4735 MINT1_X_6400_Y_7040 MINT1_X_6400_Y_7168 1.314
R_MINT1_seg_4736 MINT1_X_6400_Y_7168 MINT1_X_6400_Y_7360 1.97
R_MINT1_seg_4737 MINT1_X_6400_Y_7360 MINT1_X_6400_Y_7680 3.284
R_MINT1_seg_4738 MINT1_X_6400_Y_7680 MINT1_X_6400_Y_8000 3.284
R_MINT1_seg_4739 MINT1_X_6400_Y_8000 MINT1_X_6400_Y_8192 1.97
R_MINT1_seg_4740 MINT1_X_6400_Y_8192 MINT1_X_6400_Y_8320 1.314
R_MINT1_seg_4741 MINT1_X_6400_Y_8320 MINT1_X_6400_Y_8640 3.284
R_MINT1_seg_4742 MINT1_X_6400_Y_8640 MINT1_X_6400_Y_8960 3.284
R_MINT1_seg_4743 MINT1_X_6400_Y_8960 MINT1_X_6400_Y_9216 2.627
R_MINT1_seg_4744 MINT1_X_6400_Y_9216 MINT1_X_6400_Y_9280 656.8m
R_MINT1_seg_4745 MINT1_X_6400_Y_9280 MINT1_X_6400_Y_9600 3.284
R_MINT1_seg_4746 MINT1_X_6400_Y_9600 MINT1_X_6400_Y_9920 3.284
R_MINT1_seg_4747 MINT1_X_6400_Y_9920 MINT1_X_6400_Y_10000 821m
R_MINT1_seg_4748 MINT1_X_6720_Y_0 MINT1_X_6720_Y_320 3.284
R_MINT1_seg_4749 MINT1_X_6720_Y_320 MINT1_X_6720_Y_512 1.97
R_MINT1_seg_4750 MINT1_X_6720_Y_512 MINT1_X_6720_Y_640 1.314
R_MINT1_seg_4751 MINT1_X_6720_Y_640 MINT1_X_6720_Y_960 3.284
R_MINT1_seg_4752 MINT1_X_6720_Y_960 MINT1_X_6720_Y_1280 3.284
R_MINT1_seg_4753 MINT1_X_6720_Y_1280 MINT1_X_6720_Y_1536 2.627
R_MINT1_seg_4754 MINT1_X_6720_Y_1536 MINT1_X_6720_Y_1600 656.8m
R_MINT1_seg_4755 MINT1_X_6720_Y_1600 MINT1_X_6720_Y_1920 3.284
R_MINT1_seg_4756 MINT1_X_6720_Y_1920 MINT1_X_6720_Y_2240 3.284
R_MINT1_seg_4757 MINT1_X_6720_Y_2240 MINT1_X_6720_Y_2560 3.284
R_MINT1_seg_4758 MINT1_X_6720_Y_2560 MINT1_X_6720_Y_2880 3.284
R_MINT1_seg_4759 MINT1_X_6720_Y_2880 MINT1_X_6720_Y_3200 3.284
R_MINT1_seg_4760 MINT1_X_6720_Y_3200 MINT1_X_6720_Y_3520 3.284
R_MINT1_seg_4761 MINT1_X_6720_Y_3520 MINT1_X_6720_Y_3584 656.8m
R_MINT1_seg_4762 MINT1_X_6720_Y_3584 MINT1_X_6720_Y_3840 2.627
R_MINT1_seg_4763 MINT1_X_6720_Y_3840 MINT1_X_6720_Y_4160 3.284
R_MINT1_seg_4764 MINT1_X_6720_Y_4160 MINT1_X_6720_Y_4480 3.284
R_MINT1_seg_4765 MINT1_X_6720_Y_4480 MINT1_X_6720_Y_4608 1.314
R_MINT1_seg_4766 MINT1_X_6720_Y_4608 MINT1_X_6720_Y_4800 1.97
R_MINT1_seg_4767 MINT1_X_6720_Y_4800 MINT1_X_6720_Y_5120 3.284
R_MINT1_seg_4768 MINT1_X_6720_Y_5120 MINT1_X_6720_Y_5440 3.284
R_MINT1_seg_4769 MINT1_X_6720_Y_5440 MINT1_X_6720_Y_5632 1.97
R_MINT1_seg_4770 MINT1_X_6720_Y_5632 MINT1_X_6720_Y_5760 1.314
R_MINT1_seg_4771 MINT1_X_6720_Y_5760 MINT1_X_6720_Y_6080 3.284
R_MINT1_seg_4772 MINT1_X_6720_Y_6080 MINT1_X_6720_Y_6400 3.284
R_MINT1_seg_4773 MINT1_X_6720_Y_6400 MINT1_X_6720_Y_6656 2.627
R_MINT1_seg_4774 MINT1_X_6720_Y_6656 MINT1_X_6720_Y_6720 656.8m
R_MINT1_seg_4775 MINT1_X_6720_Y_6720 MINT1_X_6720_Y_7040 3.284
R_MINT1_seg_4776 MINT1_X_6720_Y_7040 MINT1_X_6720_Y_7360 3.284
R_MINT1_seg_4777 MINT1_X_6720_Y_7360 MINT1_X_6720_Y_7680 3.284
R_MINT1_seg_4778 MINT1_X_6720_Y_7680 MINT1_X_6720_Y_8000 3.284
R_MINT1_seg_4779 MINT1_X_6720_Y_8000 MINT1_X_6720_Y_8320 3.284
R_MINT1_seg_4780 MINT1_X_6720_Y_8320 MINT1_X_6720_Y_8640 3.284
R_MINT1_seg_4781 MINT1_X_6720_Y_8640 MINT1_X_6720_Y_8704 656.8m
R_MINT1_seg_4782 MINT1_X_6720_Y_8704 MINT1_X_6720_Y_8960 2.627
R_MINT1_seg_4783 MINT1_X_6720_Y_8960 MINT1_X_6720_Y_9280 3.284
R_MINT1_seg_4784 MINT1_X_6720_Y_9280 MINT1_X_6720_Y_9600 3.284
R_MINT1_seg_4785 MINT1_X_6720_Y_9600 MINT1_X_6720_Y_9728 1.314
R_MINT1_seg_4786 MINT1_X_6720_Y_9728 MINT1_X_6720_Y_9920 1.97
R_MINT1_seg_4787 MINT1_X_6720_Y_9920 MINT1_X_6720_Y_10000 821m
R_MINT1_seg_4788 MINT1_X_7040_Y_0 MINT1_X_7040_Y_320 3.284
R_MINT1_seg_4789 MINT1_X_7040_Y_320 MINT1_X_7040_Y_640 3.284
R_MINT1_seg_4790 MINT1_X_7040_Y_640 MINT1_X_7040_Y_960 3.284
R_MINT1_seg_4791 MINT1_X_7040_Y_960 MINT1_X_7040_Y_1024 656.8m
R_MINT1_seg_4792 MINT1_X_7040_Y_1024 MINT1_X_7040_Y_1280 2.627
R_MINT1_seg_4793 MINT1_X_7040_Y_1280 MINT1_X_7040_Y_1600 3.284
R_MINT1_seg_4794 MINT1_X_7040_Y_1600 MINT1_X_7040_Y_1920 3.284
R_MINT1_seg_4795 MINT1_X_7040_Y_1920 MINT1_X_7040_Y_2048 1.314
R_MINT1_seg_4796 MINT1_X_7040_Y_2048 MINT1_X_7040_Y_2240 1.97
R_MINT1_seg_4797 MINT1_X_7040_Y_2240 MINT1_X_7040_Y_2560 3.284
R_MINT1_seg_4798 MINT1_X_7040_Y_2560 MINT1_X_7040_Y_2880 3.284
R_MINT1_seg_4799 MINT1_X_7040_Y_2880 MINT1_X_7040_Y_3072 1.97
R_MINT1_seg_4800 MINT1_X_7040_Y_3072 MINT1_X_7040_Y_3200 1.314
R_MINT1_seg_4801 MINT1_X_7040_Y_3200 MINT1_X_7040_Y_3520 3.284
R_MINT1_seg_4802 MINT1_X_7040_Y_3520 MINT1_X_7040_Y_3840 3.284
R_MINT1_seg_4803 MINT1_X_7040_Y_3840 MINT1_X_7040_Y_4096 2.627
R_MINT1_seg_4804 MINT1_X_7040_Y_4096 MINT1_X_7040_Y_4160 656.8m
R_MINT1_seg_4805 MINT1_X_7040_Y_4160 MINT1_X_7040_Y_4480 3.284
R_MINT1_seg_4806 MINT1_X_7040_Y_4480 MINT1_X_7040_Y_4800 3.284
R_MINT1_seg_4807 MINT1_X_7040_Y_4800 MINT1_X_7040_Y_5120 3.284
R_MINT1_seg_4808 MINT1_X_7040_Y_5120 MINT1_X_7040_Y_5440 3.284
R_MINT1_seg_4809 MINT1_X_7040_Y_5440 MINT1_X_7040_Y_5760 3.284
R_MINT1_seg_4810 MINT1_X_7040_Y_5760 MINT1_X_7040_Y_6080 3.284
R_MINT1_seg_4811 MINT1_X_7040_Y_6080 MINT1_X_7040_Y_6144 656.8m
R_MINT1_seg_4812 MINT1_X_7040_Y_6144 MINT1_X_7040_Y_6400 2.627
R_MINT1_seg_4813 MINT1_X_7040_Y_6400 MINT1_X_7040_Y_6720 3.284
R_MINT1_seg_4814 MINT1_X_7040_Y_6720 MINT1_X_7040_Y_7040 3.284
R_MINT1_seg_4815 MINT1_X_7040_Y_7040 MINT1_X_7040_Y_7168 1.314
R_MINT1_seg_4816 MINT1_X_7040_Y_7168 MINT1_X_7040_Y_7360 1.97
R_MINT1_seg_4817 MINT1_X_7040_Y_7360 MINT1_X_7040_Y_7680 3.284
R_MINT1_seg_4818 MINT1_X_7040_Y_7680 MINT1_X_7040_Y_8000 3.284
R_MINT1_seg_4819 MINT1_X_7040_Y_8000 MINT1_X_7040_Y_8192 1.97
R_MINT1_seg_4820 MINT1_X_7040_Y_8192 MINT1_X_7040_Y_8320 1.314
R_MINT1_seg_4821 MINT1_X_7040_Y_8320 MINT1_X_7040_Y_8640 3.284
R_MINT1_seg_4822 MINT1_X_7040_Y_8640 MINT1_X_7040_Y_8960 3.284
R_MINT1_seg_4823 MINT1_X_7040_Y_8960 MINT1_X_7040_Y_9216 2.627
R_MINT1_seg_4824 MINT1_X_7040_Y_9216 MINT1_X_7040_Y_9280 656.8m
R_MINT1_seg_4825 MINT1_X_7040_Y_9280 MINT1_X_7040_Y_9600 3.284
R_MINT1_seg_4826 MINT1_X_7040_Y_9600 MINT1_X_7040_Y_9920 3.284
R_MINT1_seg_4827 MINT1_X_7040_Y_9920 MINT1_X_7040_Y_10000 821m
R_MINT1_seg_4828 MINT1_X_7360_Y_0 MINT1_X_7360_Y_320 3.284
R_MINT1_seg_4829 MINT1_X_7360_Y_320 MINT1_X_7360_Y_512 1.97
R_MINT1_seg_4830 MINT1_X_7360_Y_512 MINT1_X_7360_Y_640 1.314
R_MINT1_seg_4831 MINT1_X_7360_Y_640 MINT1_X_7360_Y_960 3.284
R_MINT1_seg_4832 MINT1_X_7360_Y_960 MINT1_X_7360_Y_1280 3.284
R_MINT1_seg_4833 MINT1_X_7360_Y_1280 MINT1_X_7360_Y_1536 2.627
R_MINT1_seg_4834 MINT1_X_7360_Y_1536 MINT1_X_7360_Y_1600 656.8m
R_MINT1_seg_4835 MINT1_X_7360_Y_1600 MINT1_X_7360_Y_1920 3.284
R_MINT1_seg_4836 MINT1_X_7360_Y_1920 MINT1_X_7360_Y_2240 3.284
R_MINT1_seg_4837 MINT1_X_7360_Y_2240 MINT1_X_7360_Y_2560 3.284
R_MINT1_seg_4838 MINT1_X_7360_Y_2560 MINT1_X_7360_Y_2880 3.284
R_MINT1_seg_4839 MINT1_X_7360_Y_2880 MINT1_X_7360_Y_3200 3.284
R_MINT1_seg_4840 MINT1_X_7360_Y_3200 MINT1_X_7360_Y_3520 3.284
R_MINT1_seg_4841 MINT1_X_7360_Y_3520 MINT1_X_7360_Y_3584 656.8m
R_MINT1_seg_4842 MINT1_X_7360_Y_3584 MINT1_X_7360_Y_3840 2.627
R_MINT1_seg_4843 MINT1_X_7360_Y_3840 MINT1_X_7360_Y_4160 3.284
R_MINT1_seg_4844 MINT1_X_7360_Y_4160 MINT1_X_7360_Y_4480 3.284
R_MINT1_seg_4845 MINT1_X_7360_Y_4480 MINT1_X_7360_Y_4608 1.314
R_MINT1_seg_4846 MINT1_X_7360_Y_4608 MINT1_X_7360_Y_4800 1.97
R_MINT1_seg_4847 MINT1_X_7360_Y_4800 MINT1_X_7360_Y_5120 3.284
R_MINT1_seg_4848 MINT1_X_7360_Y_5120 MINT1_X_7360_Y_5440 3.284
R_MINT1_seg_4849 MINT1_X_7360_Y_5440 MINT1_X_7360_Y_5632 1.97
R_MINT1_seg_4850 MINT1_X_7360_Y_5632 MINT1_X_7360_Y_5760 1.314
R_MINT1_seg_4851 MINT1_X_7360_Y_5760 MINT1_X_7360_Y_6080 3.284
R_MINT1_seg_4852 MINT1_X_7360_Y_6080 MINT1_X_7360_Y_6400 3.284
R_MINT1_seg_4853 MINT1_X_7360_Y_6400 MINT1_X_7360_Y_6656 2.627
R_MINT1_seg_4854 MINT1_X_7360_Y_6656 MINT1_X_7360_Y_6720 656.8m
R_MINT1_seg_4855 MINT1_X_7360_Y_6720 MINT1_X_7360_Y_7040 3.284
R_MINT1_seg_4856 MINT1_X_7360_Y_7040 MINT1_X_7360_Y_7360 3.284
R_MINT1_seg_4857 MINT1_X_7360_Y_7360 MINT1_X_7360_Y_7680 3.284
R_MINT1_seg_4858 MINT1_X_7360_Y_7680 MINT1_X_7360_Y_8000 3.284
R_MINT1_seg_4859 MINT1_X_7360_Y_8000 MINT1_X_7360_Y_8320 3.284
R_MINT1_seg_4860 MINT1_X_7360_Y_8320 MINT1_X_7360_Y_8640 3.284
R_MINT1_seg_4861 MINT1_X_7360_Y_8640 MINT1_X_7360_Y_8704 656.8m
R_MINT1_seg_4862 MINT1_X_7360_Y_8704 MINT1_X_7360_Y_8960 2.627
R_MINT1_seg_4863 MINT1_X_7360_Y_8960 MINT1_X_7360_Y_9280 3.284
R_MINT1_seg_4864 MINT1_X_7360_Y_9280 MINT1_X_7360_Y_9600 3.284
R_MINT1_seg_4865 MINT1_X_7360_Y_9600 MINT1_X_7360_Y_9728 1.314
R_MINT1_seg_4866 MINT1_X_7360_Y_9728 MINT1_X_7360_Y_9920 1.97
R_MINT1_seg_4867 MINT1_X_7360_Y_9920 MINT1_X_7360_Y_10000 821m
R_MINT1_seg_4868 MINT1_X_7680_Y_0 MINT1_X_7680_Y_320 3.284
R_MINT1_seg_4869 MINT1_X_7680_Y_320 MINT1_X_7680_Y_640 3.284
R_MINT1_seg_4870 MINT1_X_7680_Y_640 MINT1_X_7680_Y_960 3.284
R_MINT1_seg_4871 MINT1_X_7680_Y_960 MINT1_X_7680_Y_1024 656.8m
R_MINT1_seg_4872 MINT1_X_7680_Y_1024 MINT1_X_7680_Y_1280 2.627
R_MINT1_seg_4873 MINT1_X_7680_Y_1280 MINT1_X_7680_Y_1600 3.284
R_MINT1_seg_4874 MINT1_X_7680_Y_1600 MINT1_X_7680_Y_1920 3.284
R_MINT1_seg_4875 MINT1_X_7680_Y_1920 MINT1_X_7680_Y_2048 1.314
R_MINT1_seg_4876 MINT1_X_7680_Y_2048 MINT1_X_7680_Y_2240 1.97
R_MINT1_seg_4877 MINT1_X_7680_Y_2240 MINT1_X_7680_Y_2560 3.284
R_MINT1_seg_4878 MINT1_X_7680_Y_2560 MINT1_X_7680_Y_2880 3.284
R_MINT1_seg_4879 MINT1_X_7680_Y_2880 MINT1_X_7680_Y_3072 1.97
R_MINT1_seg_4880 MINT1_X_7680_Y_3072 MINT1_X_7680_Y_3200 1.314
R_MINT1_seg_4881 MINT1_X_7680_Y_3200 MINT1_X_7680_Y_3520 3.284
R_MINT1_seg_4882 MINT1_X_7680_Y_3520 MINT1_X_7680_Y_3840 3.284
R_MINT1_seg_4883 MINT1_X_7680_Y_3840 MINT1_X_7680_Y_4096 2.627
R_MINT1_seg_4884 MINT1_X_7680_Y_4096 MINT1_X_7680_Y_4160 656.8m
R_MINT1_seg_4885 MINT1_X_7680_Y_4160 MINT1_X_7680_Y_4480 3.284
R_MINT1_seg_4886 MINT1_X_7680_Y_4480 MINT1_X_7680_Y_4800 3.284
R_MINT1_seg_4887 MINT1_X_7680_Y_4800 MINT1_X_7680_Y_5120 3.284
R_MINT1_seg_4888 MINT1_X_7680_Y_5120 MINT1_X_7680_Y_5440 3.284
R_MINT1_seg_4889 MINT1_X_7680_Y_5440 MINT1_X_7680_Y_5760 3.284
R_MINT1_seg_4890 MINT1_X_7680_Y_5760 MINT1_X_7680_Y_6080 3.284
R_MINT1_seg_4891 MINT1_X_7680_Y_6080 MINT1_X_7680_Y_6144 656.8m
R_MINT1_seg_4892 MINT1_X_7680_Y_6144 MINT1_X_7680_Y_6400 2.627
R_MINT1_seg_4893 MINT1_X_7680_Y_6400 MINT1_X_7680_Y_6720 3.284
R_MINT1_seg_4894 MINT1_X_7680_Y_6720 MINT1_X_7680_Y_7040 3.284
R_MINT1_seg_4895 MINT1_X_7680_Y_7040 MINT1_X_7680_Y_7168 1.314
R_MINT1_seg_4896 MINT1_X_7680_Y_7168 MINT1_X_7680_Y_7360 1.97
R_MINT1_seg_4897 MINT1_X_7680_Y_7360 MINT1_X_7680_Y_7680 3.284
R_MINT1_seg_4898 MINT1_X_7680_Y_7680 MINT1_X_7680_Y_8000 3.284
R_MINT1_seg_4899 MINT1_X_7680_Y_8000 MINT1_X_7680_Y_8192 1.97
R_MINT1_seg_4900 MINT1_X_7680_Y_8192 MINT1_X_7680_Y_8320 1.314
R_MINT1_seg_4901 MINT1_X_7680_Y_8320 MINT1_X_7680_Y_8640 3.284
R_MINT1_seg_4902 MINT1_X_7680_Y_8640 MINT1_X_7680_Y_8960 3.284
R_MINT1_seg_4903 MINT1_X_7680_Y_8960 MINT1_X_7680_Y_9216 2.627
R_MINT1_seg_4904 MINT1_X_7680_Y_9216 MINT1_X_7680_Y_9280 656.8m
R_MINT1_seg_4905 MINT1_X_7680_Y_9280 MINT1_X_7680_Y_9600 3.284
R_MINT1_seg_4906 MINT1_X_7680_Y_9600 MINT1_X_7680_Y_9920 3.284
R_MINT1_seg_4907 MINT1_X_7680_Y_9920 MINT1_X_7680_Y_10000 821m
R_MINT1_seg_4908 MINT1_X_8000_Y_0 MINT1_X_8000_Y_320 3.284
R_MINT1_seg_4909 MINT1_X_8000_Y_320 MINT1_X_8000_Y_512 1.97
R_MINT1_seg_4910 MINT1_X_8000_Y_512 MINT1_X_8000_Y_640 1.314
R_MINT1_seg_4911 MINT1_X_8000_Y_640 MINT1_X_8000_Y_960 3.284
R_MINT1_seg_4912 MINT1_X_8000_Y_960 MINT1_X_8000_Y_1280 3.284
R_MINT1_seg_4913 MINT1_X_8000_Y_1280 MINT1_X_8000_Y_1536 2.627
R_MINT1_seg_4914 MINT1_X_8000_Y_1536 MINT1_X_8000_Y_1600 656.8m
R_MINT1_seg_4915 MINT1_X_8000_Y_1600 MINT1_X_8000_Y_1920 3.284
R_MINT1_seg_4916 MINT1_X_8000_Y_1920 MINT1_X_8000_Y_2240 3.284
R_MINT1_seg_4917 MINT1_X_8000_Y_2240 MINT1_X_8000_Y_2560 3.284
R_MINT1_seg_4918 MINT1_X_8000_Y_2560 MINT1_X_8000_Y_2880 3.284
R_MINT1_seg_4919 MINT1_X_8000_Y_2880 MINT1_X_8000_Y_3200 3.284
R_MINT1_seg_4920 MINT1_X_8000_Y_3200 MINT1_X_8000_Y_3520 3.284
R_MINT1_seg_4921 MINT1_X_8000_Y_3520 MINT1_X_8000_Y_3584 656.8m
R_MINT1_seg_4922 MINT1_X_8000_Y_3584 MINT1_X_8000_Y_3840 2.627
R_MINT1_seg_4923 MINT1_X_8000_Y_3840 MINT1_X_8000_Y_4160 3.284
R_MINT1_seg_4924 MINT1_X_8000_Y_4160 MINT1_X_8000_Y_4480 3.284
R_MINT1_seg_4925 MINT1_X_8000_Y_4480 MINT1_X_8000_Y_4608 1.314
R_MINT1_seg_4926 MINT1_X_8000_Y_4608 MINT1_X_8000_Y_4800 1.97
R_MINT1_seg_4927 MINT1_X_8000_Y_4800 MINT1_X_8000_Y_5120 3.284
R_MINT1_seg_4928 MINT1_X_8000_Y_5120 MINT1_X_8000_Y_5440 3.284
R_MINT1_seg_4929 MINT1_X_8000_Y_5440 MINT1_X_8000_Y_5632 1.97
R_MINT1_seg_4930 MINT1_X_8000_Y_5632 MINT1_X_8000_Y_5760 1.314
R_MINT1_seg_4931 MINT1_X_8000_Y_5760 MINT1_X_8000_Y_6080 3.284
R_MINT1_seg_4932 MINT1_X_8000_Y_6080 MINT1_X_8000_Y_6400 3.284
R_MINT1_seg_4933 MINT1_X_8000_Y_6400 MINT1_X_8000_Y_6656 2.627
R_MINT1_seg_4934 MINT1_X_8000_Y_6656 MINT1_X_8000_Y_6720 656.8m
R_MINT1_seg_4935 MINT1_X_8000_Y_6720 MINT1_X_8000_Y_7040 3.284
R_MINT1_seg_4936 MINT1_X_8000_Y_7040 MINT1_X_8000_Y_7360 3.284
R_MINT1_seg_4937 MINT1_X_8000_Y_7360 MINT1_X_8000_Y_7680 3.284
R_MINT1_seg_4938 MINT1_X_8000_Y_7680 MINT1_X_8000_Y_8000 3.284
R_MINT1_seg_4939 MINT1_X_8000_Y_8000 MINT1_X_8000_Y_8320 3.284
R_MINT1_seg_4940 MINT1_X_8000_Y_8320 MINT1_X_8000_Y_8640 3.284
R_MINT1_seg_4941 MINT1_X_8000_Y_8640 MINT1_X_8000_Y_8704 656.8m
R_MINT1_seg_4942 MINT1_X_8000_Y_8704 MINT1_X_8000_Y_8960 2.627
R_MINT1_seg_4943 MINT1_X_8000_Y_8960 MINT1_X_8000_Y_9280 3.284
R_MINT1_seg_4944 MINT1_X_8000_Y_9280 MINT1_X_8000_Y_9600 3.284
R_MINT1_seg_4945 MINT1_X_8000_Y_9600 MINT1_X_8000_Y_9728 1.314
R_MINT1_seg_4946 MINT1_X_8000_Y_9728 MINT1_X_8000_Y_9920 1.97
R_MINT1_seg_4947 MINT1_X_8000_Y_9920 MINT1_X_8000_Y_10000 821m
R_MINT1_seg_4948 MINT1_X_8320_Y_0 MINT1_X_8320_Y_320 3.284
R_MINT1_seg_4949 MINT1_X_8320_Y_320 MINT1_X_8320_Y_640 3.284
R_MINT1_seg_4950 MINT1_X_8320_Y_640 MINT1_X_8320_Y_960 3.284
R_MINT1_seg_4951 MINT1_X_8320_Y_960 MINT1_X_8320_Y_1024 656.8m
R_MINT1_seg_4952 MINT1_X_8320_Y_1024 MINT1_X_8320_Y_1280 2.627
R_MINT1_seg_4953 MINT1_X_8320_Y_1280 MINT1_X_8320_Y_1600 3.284
R_MINT1_seg_4954 MINT1_X_8320_Y_1600 MINT1_X_8320_Y_1920 3.284
R_MINT1_seg_4955 MINT1_X_8320_Y_1920 MINT1_X_8320_Y_2048 1.314
R_MINT1_seg_4956 MINT1_X_8320_Y_2048 MINT1_X_8320_Y_2240 1.97
R_MINT1_seg_4957 MINT1_X_8320_Y_2240 MINT1_X_8320_Y_2560 3.284
R_MINT1_seg_4958 MINT1_X_8320_Y_2560 MINT1_X_8320_Y_2880 3.284
R_MINT1_seg_4959 MINT1_X_8320_Y_2880 MINT1_X_8320_Y_3072 1.97
R_MINT1_seg_4960 MINT1_X_8320_Y_3072 MINT1_X_8320_Y_3200 1.314
R_MINT1_seg_4961 MINT1_X_8320_Y_3200 MINT1_X_8320_Y_3520 3.284
R_MINT1_seg_4962 MINT1_X_8320_Y_3520 MINT1_X_8320_Y_3840 3.284
R_MINT1_seg_4963 MINT1_X_8320_Y_3840 MINT1_X_8320_Y_4096 2.627
R_MINT1_seg_4964 MINT1_X_8320_Y_4096 MINT1_X_8320_Y_4160 656.8m
R_MINT1_seg_4965 MINT1_X_8320_Y_4160 MINT1_X_8320_Y_4480 3.284
R_MINT1_seg_4966 MINT1_X_8320_Y_4480 MINT1_X_8320_Y_4800 3.284
R_MINT1_seg_4967 MINT1_X_8320_Y_4800 MINT1_X_8320_Y_5120 3.284
R_MINT1_seg_4968 MINT1_X_8320_Y_5120 MINT1_X_8320_Y_5440 3.284
R_MINT1_seg_4969 MINT1_X_8320_Y_5440 MINT1_X_8320_Y_5760 3.284
R_MINT1_seg_4970 MINT1_X_8320_Y_5760 MINT1_X_8320_Y_6080 3.284
R_MINT1_seg_4971 MINT1_X_8320_Y_6080 MINT1_X_8320_Y_6144 656.8m
R_MINT1_seg_4972 MINT1_X_8320_Y_6144 MINT1_X_8320_Y_6400 2.627
R_MINT1_seg_4973 MINT1_X_8320_Y_6400 MINT1_X_8320_Y_6720 3.284
R_MINT1_seg_4974 MINT1_X_8320_Y_6720 MINT1_X_8320_Y_7040 3.284
R_MINT1_seg_4975 MINT1_X_8320_Y_7040 MINT1_X_8320_Y_7168 1.314
R_MINT1_seg_4976 MINT1_X_8320_Y_7168 MINT1_X_8320_Y_7360 1.97
R_MINT1_seg_4977 MINT1_X_8320_Y_7360 MINT1_X_8320_Y_7680 3.284
R_MINT1_seg_4978 MINT1_X_8320_Y_7680 MINT1_X_8320_Y_8000 3.284
R_MINT1_seg_4979 MINT1_X_8320_Y_8000 MINT1_X_8320_Y_8192 1.97
R_MINT1_seg_4980 MINT1_X_8320_Y_8192 MINT1_X_8320_Y_8320 1.314
R_MINT1_seg_4981 MINT1_X_8320_Y_8320 MINT1_X_8320_Y_8640 3.284
R_MINT1_seg_4982 MINT1_X_8320_Y_8640 MINT1_X_8320_Y_8960 3.284
R_MINT1_seg_4983 MINT1_X_8320_Y_8960 MINT1_X_8320_Y_9216 2.627
R_MINT1_seg_4984 MINT1_X_8320_Y_9216 MINT1_X_8320_Y_9280 656.8m
R_MINT1_seg_4985 MINT1_X_8320_Y_9280 MINT1_X_8320_Y_9600 3.284
R_MINT1_seg_4986 MINT1_X_8320_Y_9600 MINT1_X_8320_Y_9920 3.284
R_MINT1_seg_4987 MINT1_X_8320_Y_9920 MINT1_X_8320_Y_10000 821m
R_MINT1_seg_4988 MINT1_X_8640_Y_0 MINT1_X_8640_Y_320 3.284
R_MINT1_seg_4989 MINT1_X_8640_Y_320 MINT1_X_8640_Y_512 1.97
R_MINT1_seg_4990 MINT1_X_8640_Y_512 MINT1_X_8640_Y_640 1.314
R_MINT1_seg_4991 MINT1_X_8640_Y_640 MINT1_X_8640_Y_960 3.284
R_MINT1_seg_4992 MINT1_X_8640_Y_960 MINT1_X_8640_Y_1280 3.284
R_MINT1_seg_4993 MINT1_X_8640_Y_1280 MINT1_X_8640_Y_1536 2.627
R_MINT1_seg_4994 MINT1_X_8640_Y_1536 MINT1_X_8640_Y_1600 656.8m
R_MINT1_seg_4995 MINT1_X_8640_Y_1600 MINT1_X_8640_Y_1920 3.284
R_MINT1_seg_4996 MINT1_X_8640_Y_1920 MINT1_X_8640_Y_2240 3.284
R_MINT1_seg_4997 MINT1_X_8640_Y_2240 MINT1_X_8640_Y_2560 3.284
R_MINT1_seg_4998 MINT1_X_8640_Y_2560 MINT1_X_8640_Y_2880 3.284
R_MINT1_seg_4999 MINT1_X_8640_Y_2880 MINT1_X_8640_Y_3200 3.284
R_MINT1_seg_5000 MINT1_X_8640_Y_3200 MINT1_X_8640_Y_3520 3.284
R_MINT1_seg_5001 MINT1_X_8640_Y_3520 MINT1_X_8640_Y_3584 656.8m
R_MINT1_seg_5002 MINT1_X_8640_Y_3584 MINT1_X_8640_Y_3840 2.627
R_MINT1_seg_5003 MINT1_X_8640_Y_3840 MINT1_X_8640_Y_4160 3.284
R_MINT1_seg_5004 MINT1_X_8640_Y_4160 MINT1_X_8640_Y_4480 3.284
R_MINT1_seg_5005 MINT1_X_8640_Y_4480 MINT1_X_8640_Y_4608 1.314
R_MINT1_seg_5006 MINT1_X_8640_Y_4608 MINT1_X_8640_Y_4800 1.97
R_MINT1_seg_5007 MINT1_X_8640_Y_4800 MINT1_X_8640_Y_5120 3.284
R_MINT1_seg_5008 MINT1_X_8640_Y_5120 MINT1_X_8640_Y_5440 3.284
R_MINT1_seg_5009 MINT1_X_8640_Y_5440 MINT1_X_8640_Y_5632 1.97
R_MINT1_seg_5010 MINT1_X_8640_Y_5632 MINT1_X_8640_Y_5760 1.314
R_MINT1_seg_5011 MINT1_X_8640_Y_5760 MINT1_X_8640_Y_6080 3.284
R_MINT1_seg_5012 MINT1_X_8640_Y_6080 MINT1_X_8640_Y_6400 3.284
R_MINT1_seg_5013 MINT1_X_8640_Y_6400 MINT1_X_8640_Y_6656 2.627
R_MINT1_seg_5014 MINT1_X_8640_Y_6656 MINT1_X_8640_Y_6720 656.8m
R_MINT1_seg_5015 MINT1_X_8640_Y_6720 MINT1_X_8640_Y_7040 3.284
R_MINT1_seg_5016 MINT1_X_8640_Y_7040 MINT1_X_8640_Y_7360 3.284
R_MINT1_seg_5017 MINT1_X_8640_Y_7360 MINT1_X_8640_Y_7680 3.284
R_MINT1_seg_5018 MINT1_X_8640_Y_7680 MINT1_X_8640_Y_8000 3.284
R_MINT1_seg_5019 MINT1_X_8640_Y_8000 MINT1_X_8640_Y_8320 3.284
R_MINT1_seg_5020 MINT1_X_8640_Y_8320 MINT1_X_8640_Y_8640 3.284
R_MINT1_seg_5021 MINT1_X_8640_Y_8640 MINT1_X_8640_Y_8704 656.8m
R_MINT1_seg_5022 MINT1_X_8640_Y_8704 MINT1_X_8640_Y_8960 2.627
R_MINT1_seg_5023 MINT1_X_8640_Y_8960 MINT1_X_8640_Y_9280 3.284
R_MINT1_seg_5024 MINT1_X_8640_Y_9280 MINT1_X_8640_Y_9600 3.284
R_MINT1_seg_5025 MINT1_X_8640_Y_9600 MINT1_X_8640_Y_9728 1.314
R_MINT1_seg_5026 MINT1_X_8640_Y_9728 MINT1_X_8640_Y_9920 1.97
R_MINT1_seg_5027 MINT1_X_8640_Y_9920 MINT1_X_8640_Y_10000 821m
R_MINT1_seg_5028 MINT1_X_8960_Y_0 MINT1_X_8960_Y_320 3.284
R_MINT1_seg_5029 MINT1_X_8960_Y_320 MINT1_X_8960_Y_640 3.284
R_MINT1_seg_5030 MINT1_X_8960_Y_640 MINT1_X_8960_Y_960 3.284
R_MINT1_seg_5031 MINT1_X_8960_Y_960 MINT1_X_8960_Y_1024 656.8m
R_MINT1_seg_5032 MINT1_X_8960_Y_1024 MINT1_X_8960_Y_1280 2.627
R_MINT1_seg_5033 MINT1_X_8960_Y_1280 MINT1_X_8960_Y_1600 3.284
R_MINT1_seg_5034 MINT1_X_8960_Y_1600 MINT1_X_8960_Y_1920 3.284
R_MINT1_seg_5035 MINT1_X_8960_Y_1920 MINT1_X_8960_Y_2048 1.314
R_MINT1_seg_5036 MINT1_X_8960_Y_2048 MINT1_X_8960_Y_2240 1.97
R_MINT1_seg_5037 MINT1_X_8960_Y_2240 MINT1_X_8960_Y_2560 3.284
R_MINT1_seg_5038 MINT1_X_8960_Y_2560 MINT1_X_8960_Y_2880 3.284
R_MINT1_seg_5039 MINT1_X_8960_Y_2880 MINT1_X_8960_Y_3072 1.97
R_MINT1_seg_5040 MINT1_X_8960_Y_3072 MINT1_X_8960_Y_3200 1.314
R_MINT1_seg_5041 MINT1_X_8960_Y_3200 MINT1_X_8960_Y_3520 3.284
R_MINT1_seg_5042 MINT1_X_8960_Y_3520 MINT1_X_8960_Y_3840 3.284
R_MINT1_seg_5043 MINT1_X_8960_Y_3840 MINT1_X_8960_Y_4096 2.627
R_MINT1_seg_5044 MINT1_X_8960_Y_4096 MINT1_X_8960_Y_4160 656.8m
R_MINT1_seg_5045 MINT1_X_8960_Y_4160 MINT1_X_8960_Y_4480 3.284
R_MINT1_seg_5046 MINT1_X_8960_Y_4480 MINT1_X_8960_Y_4800 3.284
R_MINT1_seg_5047 MINT1_X_8960_Y_4800 MINT1_X_8960_Y_5120 3.284
R_MINT1_seg_5048 MINT1_X_8960_Y_5120 MINT1_X_8960_Y_5440 3.284
R_MINT1_seg_5049 MINT1_X_8960_Y_5440 MINT1_X_8960_Y_5760 3.284
R_MINT1_seg_5050 MINT1_X_8960_Y_5760 MINT1_X_8960_Y_6080 3.284
R_MINT1_seg_5051 MINT1_X_8960_Y_6080 MINT1_X_8960_Y_6144 656.8m
R_MINT1_seg_5052 MINT1_X_8960_Y_6144 MINT1_X_8960_Y_6400 2.627
R_MINT1_seg_5053 MINT1_X_8960_Y_6400 MINT1_X_8960_Y_6720 3.284
R_MINT1_seg_5054 MINT1_X_8960_Y_6720 MINT1_X_8960_Y_7040 3.284
R_MINT1_seg_5055 MINT1_X_8960_Y_7040 MINT1_X_8960_Y_7168 1.314
R_MINT1_seg_5056 MINT1_X_8960_Y_7168 MINT1_X_8960_Y_7360 1.97
R_MINT1_seg_5057 MINT1_X_8960_Y_7360 MINT1_X_8960_Y_7680 3.284
R_MINT1_seg_5058 MINT1_X_8960_Y_7680 MINT1_X_8960_Y_8000 3.284
R_MINT1_seg_5059 MINT1_X_8960_Y_8000 MINT1_X_8960_Y_8192 1.97
R_MINT1_seg_5060 MINT1_X_8960_Y_8192 MINT1_X_8960_Y_8320 1.314
R_MINT1_seg_5061 MINT1_X_8960_Y_8320 MINT1_X_8960_Y_8640 3.284
R_MINT1_seg_5062 MINT1_X_8960_Y_8640 MINT1_X_8960_Y_8960 3.284
R_MINT1_seg_5063 MINT1_X_8960_Y_8960 MINT1_X_8960_Y_9216 2.627
R_MINT1_seg_5064 MINT1_X_8960_Y_9216 MINT1_X_8960_Y_9280 656.8m
R_MINT1_seg_5065 MINT1_X_8960_Y_9280 MINT1_X_8960_Y_9600 3.284
R_MINT1_seg_5066 MINT1_X_8960_Y_9600 MINT1_X_8960_Y_9920 3.284
R_MINT1_seg_5067 MINT1_X_8960_Y_9920 MINT1_X_8960_Y_10000 821m
R_MINT1_seg_5068 MINT1_X_9280_Y_0 MINT1_X_9280_Y_320 3.284
R_MINT1_seg_5069 MINT1_X_9280_Y_320 MINT1_X_9280_Y_512 1.97
R_MINT1_seg_5070 MINT1_X_9280_Y_512 MINT1_X_9280_Y_640 1.314
R_MINT1_seg_5071 MINT1_X_9280_Y_640 MINT1_X_9280_Y_960 3.284
R_MINT1_seg_5072 MINT1_X_9280_Y_960 MINT1_X_9280_Y_1280 3.284
R_MINT1_seg_5073 MINT1_X_9280_Y_1280 MINT1_X_9280_Y_1536 2.627
R_MINT1_seg_5074 MINT1_X_9280_Y_1536 MINT1_X_9280_Y_1600 656.8m
R_MINT1_seg_5075 MINT1_X_9280_Y_1600 MINT1_X_9280_Y_1920 3.284
R_MINT1_seg_5076 MINT1_X_9280_Y_1920 MINT1_X_9280_Y_2240 3.284
R_MINT1_seg_5077 MINT1_X_9280_Y_2240 MINT1_X_9280_Y_2560 3.284
R_MINT1_seg_5078 MINT1_X_9280_Y_2560 MINT1_X_9280_Y_2880 3.284
R_MINT1_seg_5079 MINT1_X_9280_Y_2880 MINT1_X_9280_Y_3200 3.284
R_MINT1_seg_5080 MINT1_X_9280_Y_3200 MINT1_X_9280_Y_3520 3.284
R_MINT1_seg_5081 MINT1_X_9280_Y_3520 MINT1_X_9280_Y_3584 656.8m
R_MINT1_seg_5082 MINT1_X_9280_Y_3584 MINT1_X_9280_Y_3840 2.627
R_MINT1_seg_5083 MINT1_X_9280_Y_3840 MINT1_X_9280_Y_4160 3.284
R_MINT1_seg_5084 MINT1_X_9280_Y_4160 MINT1_X_9280_Y_4480 3.284
R_MINT1_seg_5085 MINT1_X_9280_Y_4480 MINT1_X_9280_Y_4608 1.314
R_MINT1_seg_5086 MINT1_X_9280_Y_4608 MINT1_X_9280_Y_4800 1.97
R_MINT1_seg_5087 MINT1_X_9280_Y_4800 MINT1_X_9280_Y_5120 3.284
R_MINT1_seg_5088 MINT1_X_9280_Y_5120 MINT1_X_9280_Y_5440 3.284
R_MINT1_seg_5089 MINT1_X_9280_Y_5440 MINT1_X_9280_Y_5632 1.97
R_MINT1_seg_5090 MINT1_X_9280_Y_5632 MINT1_X_9280_Y_5760 1.314
R_MINT1_seg_5091 MINT1_X_9280_Y_5760 MINT1_X_9280_Y_6080 3.284
R_MINT1_seg_5092 MINT1_X_9280_Y_6080 MINT1_X_9280_Y_6400 3.284
R_MINT1_seg_5093 MINT1_X_9280_Y_6400 MINT1_X_9280_Y_6656 2.627
R_MINT1_seg_5094 MINT1_X_9280_Y_6656 MINT1_X_9280_Y_6720 656.8m
R_MINT1_seg_5095 MINT1_X_9280_Y_6720 MINT1_X_9280_Y_7040 3.284
R_MINT1_seg_5096 MINT1_X_9280_Y_7040 MINT1_X_9280_Y_7360 3.284
R_MINT1_seg_5097 MINT1_X_9280_Y_7360 MINT1_X_9280_Y_7680 3.284
R_MINT1_seg_5098 MINT1_X_9280_Y_7680 MINT1_X_9280_Y_8000 3.284
R_MINT1_seg_5099 MINT1_X_9280_Y_8000 MINT1_X_9280_Y_8320 3.284
R_MINT1_seg_5100 MINT1_X_9280_Y_8320 MINT1_X_9280_Y_8640 3.284
R_MINT1_seg_5101 MINT1_X_9280_Y_8640 MINT1_X_9280_Y_8704 656.8m
R_MINT1_seg_5102 MINT1_X_9280_Y_8704 MINT1_X_9280_Y_8960 2.627
R_MINT1_seg_5103 MINT1_X_9280_Y_8960 MINT1_X_9280_Y_9280 3.284
R_MINT1_seg_5104 MINT1_X_9280_Y_9280 MINT1_X_9280_Y_9600 3.284
R_MINT1_seg_5105 MINT1_X_9280_Y_9600 MINT1_X_9280_Y_9728 1.314
R_MINT1_seg_5106 MINT1_X_9280_Y_9728 MINT1_X_9280_Y_9920 1.97
R_MINT1_seg_5107 MINT1_X_9280_Y_9920 MINT1_X_9280_Y_10000 821m
R_MINT1_seg_5108 MINT1_X_9600_Y_0 MINT1_X_9600_Y_320 3.284
R_MINT1_seg_5109 MINT1_X_9600_Y_320 MINT1_X_9600_Y_640 3.284
R_MINT1_seg_5110 MINT1_X_9600_Y_640 MINT1_X_9600_Y_960 3.284
R_MINT1_seg_5111 MINT1_X_9600_Y_960 MINT1_X_9600_Y_1024 656.8m
R_MINT1_seg_5112 MINT1_X_9600_Y_1024 MINT1_X_9600_Y_1280 2.627
R_MINT1_seg_5113 MINT1_X_9600_Y_1280 MINT1_X_9600_Y_1600 3.284
R_MINT1_seg_5114 MINT1_X_9600_Y_1600 MINT1_X_9600_Y_1920 3.284
R_MINT1_seg_5115 MINT1_X_9600_Y_1920 MINT1_X_9600_Y_2048 1.314
R_MINT1_seg_5116 MINT1_X_9600_Y_2048 MINT1_X_9600_Y_2240 1.97
R_MINT1_seg_5117 MINT1_X_9600_Y_2240 MINT1_X_9600_Y_2560 3.284
R_MINT1_seg_5118 MINT1_X_9600_Y_2560 MINT1_X_9600_Y_2880 3.284
R_MINT1_seg_5119 MINT1_X_9600_Y_2880 MINT1_X_9600_Y_3072 1.97
R_MINT1_seg_5120 MINT1_X_9600_Y_3072 MINT1_X_9600_Y_3200 1.314
R_MINT1_seg_5121 MINT1_X_9600_Y_3200 MINT1_X_9600_Y_3520 3.284
R_MINT1_seg_5122 MINT1_X_9600_Y_3520 MINT1_X_9600_Y_3840 3.284
R_MINT1_seg_5123 MINT1_X_9600_Y_3840 MINT1_X_9600_Y_4096 2.627
R_MINT1_seg_5124 MINT1_X_9600_Y_4096 MINT1_X_9600_Y_4160 656.8m
R_MINT1_seg_5125 MINT1_X_9600_Y_4160 MINT1_X_9600_Y_4480 3.284
R_MINT1_seg_5126 MINT1_X_9600_Y_4480 MINT1_X_9600_Y_4800 3.284
R_MINT1_seg_5127 MINT1_X_9600_Y_4800 MINT1_X_9600_Y_5120 3.284
R_MINT1_seg_5128 MINT1_X_9600_Y_5120 MINT1_X_9600_Y_5440 3.284
R_MINT1_seg_5129 MINT1_X_9600_Y_5440 MINT1_X_9600_Y_5760 3.284
R_MINT1_seg_5130 MINT1_X_9600_Y_5760 MINT1_X_9600_Y_6080 3.284
R_MINT1_seg_5131 MINT1_X_9600_Y_6080 MINT1_X_9600_Y_6144 656.8m
R_MINT1_seg_5132 MINT1_X_9600_Y_6144 MINT1_X_9600_Y_6400 2.627
R_MINT1_seg_5133 MINT1_X_9600_Y_6400 MINT1_X_9600_Y_6720 3.284
R_MINT1_seg_5134 MINT1_X_9600_Y_6720 MINT1_X_9600_Y_7040 3.284
R_MINT1_seg_5135 MINT1_X_9600_Y_7040 MINT1_X_9600_Y_7168 1.314
R_MINT1_seg_5136 MINT1_X_9600_Y_7168 MINT1_X_9600_Y_7360 1.97
R_MINT1_seg_5137 MINT1_X_9600_Y_7360 MINT1_X_9600_Y_7680 3.284
R_MINT1_seg_5138 MINT1_X_9600_Y_7680 MINT1_X_9600_Y_8000 3.284
R_MINT1_seg_5139 MINT1_X_9600_Y_8000 MINT1_X_9600_Y_8192 1.97
R_MINT1_seg_5140 MINT1_X_9600_Y_8192 MINT1_X_9600_Y_8320 1.314
R_MINT1_seg_5141 MINT1_X_9600_Y_8320 MINT1_X_9600_Y_8640 3.284
R_MINT1_seg_5142 MINT1_X_9600_Y_8640 MINT1_X_9600_Y_8960 3.284
R_MINT1_seg_5143 MINT1_X_9600_Y_8960 MINT1_X_9600_Y_9216 2.627
R_MINT1_seg_5144 MINT1_X_9600_Y_9216 MINT1_X_9600_Y_9280 656.8m
R_MINT1_seg_5145 MINT1_X_9600_Y_9280 MINT1_X_9600_Y_9600 3.284
R_MINT1_seg_5146 MINT1_X_9600_Y_9600 MINT1_X_9600_Y_9920 3.284
R_MINT1_seg_5147 MINT1_X_9600_Y_9920 MINT1_X_9600_Y_10000 821m
R_MINT1_seg_5148 MINT1_X_9920_Y_0 MINT1_X_9920_Y_320 3.284
R_MINT1_seg_5149 MINT1_X_9920_Y_320 MINT1_X_9920_Y_512 1.97
R_MINT1_seg_5150 MINT1_X_9920_Y_512 MINT1_X_9920_Y_640 1.314
R_MINT1_seg_5151 MINT1_X_9920_Y_640 MINT1_X_9920_Y_960 3.284
R_MINT1_seg_5152 MINT1_X_9920_Y_960 MINT1_X_9920_Y_1280 3.284
R_MINT1_seg_5153 MINT1_X_9920_Y_1280 MINT1_X_9920_Y_1536 2.627
R_MINT1_seg_5154 MINT1_X_9920_Y_1536 MINT1_X_9920_Y_1600 656.8m
R_MINT1_seg_5155 MINT1_X_9920_Y_1600 MINT1_X_9920_Y_1920 3.284
R_MINT1_seg_5156 MINT1_X_9920_Y_1920 MINT1_X_9920_Y_2240 3.284
R_MINT1_seg_5157 MINT1_X_9920_Y_2240 MINT1_X_9920_Y_2560 3.284
R_MINT1_seg_5158 MINT1_X_9920_Y_2560 MINT1_X_9920_Y_2880 3.284
R_MINT1_seg_5159 MINT1_X_9920_Y_2880 MINT1_X_9920_Y_3200 3.284
R_MINT1_seg_5160 MINT1_X_9920_Y_3200 MINT1_X_9920_Y_3520 3.284
R_MINT1_seg_5161 MINT1_X_9920_Y_3520 MINT1_X_9920_Y_3584 656.8m
R_MINT1_seg_5162 MINT1_X_9920_Y_3584 MINT1_X_9920_Y_3840 2.627
R_MINT1_seg_5163 MINT1_X_9920_Y_3840 MINT1_X_9920_Y_4160 3.284
R_MINT1_seg_5164 MINT1_X_9920_Y_4160 MINT1_X_9920_Y_4480 3.284
R_MINT1_seg_5165 MINT1_X_9920_Y_4480 MINT1_X_9920_Y_4608 1.314
R_MINT1_seg_5166 MINT1_X_9920_Y_4608 MINT1_X_9920_Y_4800 1.97
R_MINT1_seg_5167 MINT1_X_9920_Y_4800 MINT1_X_9920_Y_5120 3.284
R_MINT1_seg_5168 MINT1_X_9920_Y_5120 MINT1_X_9920_Y_5440 3.284
R_MINT1_seg_5169 MINT1_X_9920_Y_5440 MINT1_X_9920_Y_5632 1.97
R_MINT1_seg_5170 MINT1_X_9920_Y_5632 MINT1_X_9920_Y_5760 1.314
R_MINT1_seg_5171 MINT1_X_9920_Y_5760 MINT1_X_9920_Y_6080 3.284
R_MINT1_seg_5172 MINT1_X_9920_Y_6080 MINT1_X_9920_Y_6400 3.284
R_MINT1_seg_5173 MINT1_X_9920_Y_6400 MINT1_X_9920_Y_6656 2.627
R_MINT1_seg_5174 MINT1_X_9920_Y_6656 MINT1_X_9920_Y_6720 656.8m
R_MINT1_seg_5175 MINT1_X_9920_Y_6720 MINT1_X_9920_Y_7040 3.284
R_MINT1_seg_5176 MINT1_X_9920_Y_7040 MINT1_X_9920_Y_7360 3.284
R_MINT1_seg_5177 MINT1_X_9920_Y_7360 MINT1_X_9920_Y_7680 3.284
R_MINT1_seg_5178 MINT1_X_9920_Y_7680 MINT1_X_9920_Y_8000 3.284
R_MINT1_seg_5179 MINT1_X_9920_Y_8000 MINT1_X_9920_Y_8320 3.284
R_MINT1_seg_5180 MINT1_X_9920_Y_8320 MINT1_X_9920_Y_8640 3.284
R_MINT1_seg_5181 MINT1_X_9920_Y_8640 MINT1_X_9920_Y_8704 656.8m
R_MINT1_seg_5182 MINT1_X_9920_Y_8704 MINT1_X_9920_Y_8960 2.627
R_MINT1_seg_5183 MINT1_X_9920_Y_8960 MINT1_X_9920_Y_9280 3.284
R_MINT1_seg_5184 MINT1_X_9920_Y_9280 MINT1_X_9920_Y_9600 3.284
R_MINT1_seg_5185 MINT1_X_9920_Y_9600 MINT1_X_9920_Y_9728 1.314
R_MINT1_seg_5186 MINT1_X_9920_Y_9728 MINT1_X_9920_Y_9920 1.97
R_MINT1_seg_5187 MINT1_X_9920_Y_9920 MINT1_X_9920_Y_10000 821m
* Layer: M1
R_M1_seg_5188 M1_X_0_Y_0 M1_X_640_Y_0 6.568
R_M1_seg_5189 M1_X_640_Y_0 M1_X_1280_Y_0 6.568
R_M1_seg_5190 M1_X_1280_Y_0 M1_X_1920_Y_0 6.568
R_M1_seg_5191 M1_X_1920_Y_0 M1_X_2560_Y_0 6.568
R_M1_seg_5192 M1_X_2560_Y_0 M1_X_3200_Y_0 6.568
R_M1_seg_5193 M1_X_3200_Y_0 M1_X_3840_Y_0 6.568
R_M1_seg_5194 M1_X_3840_Y_0 M1_X_4480_Y_0 6.568
R_M1_seg_5195 M1_X_4480_Y_0 M1_X_5120_Y_0 6.568
R_M1_seg_5196 M1_X_5120_Y_0 M1_X_5760_Y_0 6.568
R_M1_seg_5197 M1_X_5760_Y_0 M1_X_6400_Y_0 6.568
R_M1_seg_5198 M1_X_6400_Y_0 M1_X_7040_Y_0 6.568
R_M1_seg_5199 M1_X_7040_Y_0 M1_X_7680_Y_0 6.568
R_M1_seg_5200 M1_X_7680_Y_0 M1_X_8320_Y_0 6.568
R_M1_seg_5201 M1_X_8320_Y_0 M1_X_8960_Y_0 6.568
R_M1_seg_5202 M1_X_8960_Y_0 M1_X_9600_Y_0 6.568
R_M1_seg_5203 M1_X_9600_Y_0 M1_X_10000_Y_0 4.105
R_M1_seg_5204 M1_X_0_Y_512 M1_X_320_Y_512 3.284
R_M1_seg_5205 M1_X_320_Y_512 M1_X_960_Y_512 6.568
R_M1_seg_5206 M1_X_960_Y_512 M1_X_1600_Y_512 6.568
R_M1_seg_5207 M1_X_1600_Y_512 M1_X_2240_Y_512 6.568
R_M1_seg_5208 M1_X_2240_Y_512 M1_X_2880_Y_512 6.568
R_M1_seg_5209 M1_X_2880_Y_512 M1_X_3520_Y_512 6.568
R_M1_seg_5210 M1_X_3520_Y_512 M1_X_4160_Y_512 6.568
R_M1_seg_5211 M1_X_4160_Y_512 M1_X_4800_Y_512 6.568
R_M1_seg_5212 M1_X_4800_Y_512 M1_X_5440_Y_512 6.568
R_M1_seg_5213 M1_X_5440_Y_512 M1_X_6080_Y_512 6.568
R_M1_seg_5214 M1_X_6080_Y_512 M1_X_6720_Y_512 6.568
R_M1_seg_5215 M1_X_6720_Y_512 M1_X_7360_Y_512 6.568
R_M1_seg_5216 M1_X_7360_Y_512 M1_X_8000_Y_512 6.568
R_M1_seg_5217 M1_X_8000_Y_512 M1_X_8640_Y_512 6.568
R_M1_seg_5218 M1_X_8640_Y_512 M1_X_9280_Y_512 6.568
R_M1_seg_5219 M1_X_9280_Y_512 M1_X_9920_Y_512 6.568
R_M1_seg_5220 M1_X_9920_Y_512 M1_X_10000_Y_512 821m
R_M1_seg_5221 M1_X_0_Y_1024 M1_X_640_Y_1024 6.568
R_M1_seg_5222 M1_X_640_Y_1024 M1_X_1280_Y_1024 6.568
R_M1_seg_5223 M1_X_1280_Y_1024 M1_X_1920_Y_1024 6.568
R_M1_seg_5224 M1_X_1920_Y_1024 M1_X_2560_Y_1024 6.568
R_M1_seg_5225 M1_X_2560_Y_1024 M1_X_3200_Y_1024 6.568
R_M1_seg_5226 M1_X_3200_Y_1024 M1_X_3840_Y_1024 6.568
R_M1_seg_5227 M1_X_3840_Y_1024 M1_X_4480_Y_1024 6.568
R_M1_seg_5228 M1_X_4480_Y_1024 M1_X_5120_Y_1024 6.568
R_M1_seg_5229 M1_X_5120_Y_1024 M1_X_5760_Y_1024 6.568
R_M1_seg_5230 M1_X_5760_Y_1024 M1_X_6400_Y_1024 6.568
R_M1_seg_5231 M1_X_6400_Y_1024 M1_X_7040_Y_1024 6.568
R_M1_seg_5232 M1_X_7040_Y_1024 M1_X_7680_Y_1024 6.568
R_M1_seg_5233 M1_X_7680_Y_1024 M1_X_8320_Y_1024 6.568
R_M1_seg_5234 M1_X_8320_Y_1024 M1_X_8960_Y_1024 6.568
R_M1_seg_5235 M1_X_8960_Y_1024 M1_X_9600_Y_1024 6.568
R_M1_seg_5236 M1_X_9600_Y_1024 M1_X_10000_Y_1024 4.105
R_M1_seg_5237 M1_X_0_Y_1536 M1_X_320_Y_1536 3.284
R_M1_seg_5238 M1_X_320_Y_1536 M1_X_960_Y_1536 6.568
R_M1_seg_5239 M1_X_960_Y_1536 M1_X_1600_Y_1536 6.568
R_M1_seg_5240 M1_X_1600_Y_1536 M1_X_2240_Y_1536 6.568
R_M1_seg_5241 M1_X_2240_Y_1536 M1_X_2880_Y_1536 6.568
R_M1_seg_5242 M1_X_2880_Y_1536 M1_X_3520_Y_1536 6.568
R_M1_seg_5243 M1_X_3520_Y_1536 M1_X_4160_Y_1536 6.568
R_M1_seg_5244 M1_X_4160_Y_1536 M1_X_4800_Y_1536 6.568
R_M1_seg_5245 M1_X_4800_Y_1536 M1_X_5440_Y_1536 6.568
R_M1_seg_5246 M1_X_5440_Y_1536 M1_X_6080_Y_1536 6.568
R_M1_seg_5247 M1_X_6080_Y_1536 M1_X_6720_Y_1536 6.568
R_M1_seg_5248 M1_X_6720_Y_1536 M1_X_7360_Y_1536 6.568
R_M1_seg_5249 M1_X_7360_Y_1536 M1_X_8000_Y_1536 6.568
R_M1_seg_5250 M1_X_8000_Y_1536 M1_X_8640_Y_1536 6.568
R_M1_seg_5251 M1_X_8640_Y_1536 M1_X_9280_Y_1536 6.568
R_M1_seg_5252 M1_X_9280_Y_1536 M1_X_9920_Y_1536 6.568
R_M1_seg_5253 M1_X_9920_Y_1536 M1_X_10000_Y_1536 821m
R_M1_seg_5254 M1_X_0_Y_2048 M1_X_640_Y_2048 6.568
R_M1_seg_5255 M1_X_640_Y_2048 M1_X_1280_Y_2048 6.568
R_M1_seg_5256 M1_X_1280_Y_2048 M1_X_1920_Y_2048 6.568
R_M1_seg_5257 M1_X_1920_Y_2048 M1_X_2560_Y_2048 6.568
R_M1_seg_5258 M1_X_2560_Y_2048 M1_X_3200_Y_2048 6.568
R_M1_seg_5259 M1_X_3200_Y_2048 M1_X_3840_Y_2048 6.568
R_M1_seg_5260 M1_X_3840_Y_2048 M1_X_4480_Y_2048 6.568
R_M1_seg_5261 M1_X_4480_Y_2048 M1_X_5120_Y_2048 6.568
R_M1_seg_5262 M1_X_5120_Y_2048 M1_X_5760_Y_2048 6.568
R_M1_seg_5263 M1_X_5760_Y_2048 M1_X_6400_Y_2048 6.568
R_M1_seg_5264 M1_X_6400_Y_2048 M1_X_7040_Y_2048 6.568
R_M1_seg_5265 M1_X_7040_Y_2048 M1_X_7680_Y_2048 6.568
R_M1_seg_5266 M1_X_7680_Y_2048 M1_X_8320_Y_2048 6.568
R_M1_seg_5267 M1_X_8320_Y_2048 M1_X_8960_Y_2048 6.568
R_M1_seg_5268 M1_X_8960_Y_2048 M1_X_9600_Y_2048 6.568
R_M1_seg_5269 M1_X_9600_Y_2048 M1_X_10000_Y_2048 4.105
R_M1_seg_5270 M1_X_0_Y_2560 M1_X_320_Y_2560 3.284
R_M1_seg_5271 M1_X_320_Y_2560 M1_X_960_Y_2560 6.568
R_M1_seg_5272 M1_X_960_Y_2560 M1_X_1600_Y_2560 6.568
R_M1_seg_5273 M1_X_1600_Y_2560 M1_X_2240_Y_2560 6.568
R_M1_seg_5274 M1_X_2240_Y_2560 M1_X_2880_Y_2560 6.568
R_M1_seg_5275 M1_X_2880_Y_2560 M1_X_3520_Y_2560 6.568
R_M1_seg_5276 M1_X_3520_Y_2560 M1_X_4160_Y_2560 6.568
R_M1_seg_5277 M1_X_4160_Y_2560 M1_X_4800_Y_2560 6.568
R_M1_seg_5278 M1_X_4800_Y_2560 M1_X_5440_Y_2560 6.568
R_M1_seg_5279 M1_X_5440_Y_2560 M1_X_6080_Y_2560 6.568
R_M1_seg_5280 M1_X_6080_Y_2560 M1_X_6720_Y_2560 6.568
R_M1_seg_5281 M1_X_6720_Y_2560 M1_X_7360_Y_2560 6.568
R_M1_seg_5282 M1_X_7360_Y_2560 M1_X_8000_Y_2560 6.568
R_M1_seg_5283 M1_X_8000_Y_2560 M1_X_8640_Y_2560 6.568
R_M1_seg_5284 M1_X_8640_Y_2560 M1_X_9280_Y_2560 6.568
R_M1_seg_5285 M1_X_9280_Y_2560 M1_X_9920_Y_2560 6.568
R_M1_seg_5286 M1_X_9920_Y_2560 M1_X_10000_Y_2560 821m
R_M1_seg_5287 M1_X_0_Y_3072 M1_X_640_Y_3072 6.568
R_M1_seg_5288 M1_X_640_Y_3072 M1_X_1280_Y_3072 6.568
R_M1_seg_5289 M1_X_1280_Y_3072 M1_X_1920_Y_3072 6.568
R_M1_seg_5290 M1_X_1920_Y_3072 M1_X_2560_Y_3072 6.568
R_M1_seg_5291 M1_X_2560_Y_3072 M1_X_3200_Y_3072 6.568
R_M1_seg_5292 M1_X_3200_Y_3072 M1_X_3840_Y_3072 6.568
R_M1_seg_5293 M1_X_3840_Y_3072 M1_X_4480_Y_3072 6.568
R_M1_seg_5294 M1_X_4480_Y_3072 M1_X_5120_Y_3072 6.568
R_M1_seg_5295 M1_X_5120_Y_3072 M1_X_5760_Y_3072 6.568
R_M1_seg_5296 M1_X_5760_Y_3072 M1_X_6400_Y_3072 6.568
R_M1_seg_5297 M1_X_6400_Y_3072 M1_X_7040_Y_3072 6.568
R_M1_seg_5298 M1_X_7040_Y_3072 M1_X_7680_Y_3072 6.568
R_M1_seg_5299 M1_X_7680_Y_3072 M1_X_8320_Y_3072 6.568
R_M1_seg_5300 M1_X_8320_Y_3072 M1_X_8960_Y_3072 6.568
R_M1_seg_5301 M1_X_8960_Y_3072 M1_X_9600_Y_3072 6.568
R_M1_seg_5302 M1_X_9600_Y_3072 M1_X_10000_Y_3072 4.105
R_M1_seg_5303 M1_X_0_Y_3584 M1_X_320_Y_3584 3.284
R_M1_seg_5304 M1_X_320_Y_3584 M1_X_960_Y_3584 6.568
R_M1_seg_5305 M1_X_960_Y_3584 M1_X_1600_Y_3584 6.568
R_M1_seg_5306 M1_X_1600_Y_3584 M1_X_2240_Y_3584 6.568
R_M1_seg_5307 M1_X_2240_Y_3584 M1_X_2880_Y_3584 6.568
R_M1_seg_5308 M1_X_2880_Y_3584 M1_X_3520_Y_3584 6.568
R_M1_seg_5309 M1_X_3520_Y_3584 M1_X_4160_Y_3584 6.568
R_M1_seg_5310 M1_X_4160_Y_3584 M1_X_4800_Y_3584 6.568
R_M1_seg_5311 M1_X_4800_Y_3584 M1_X_5440_Y_3584 6.568
R_M1_seg_5312 M1_X_5440_Y_3584 M1_X_6080_Y_3584 6.568
R_M1_seg_5313 M1_X_6080_Y_3584 M1_X_6720_Y_3584 6.568
R_M1_seg_5314 M1_X_6720_Y_3584 M1_X_7360_Y_3584 6.568
R_M1_seg_5315 M1_X_7360_Y_3584 M1_X_8000_Y_3584 6.568
R_M1_seg_5316 M1_X_8000_Y_3584 M1_X_8640_Y_3584 6.568
R_M1_seg_5317 M1_X_8640_Y_3584 M1_X_9280_Y_3584 6.568
R_M1_seg_5318 M1_X_9280_Y_3584 M1_X_9920_Y_3584 6.568
R_M1_seg_5319 M1_X_9920_Y_3584 M1_X_10000_Y_3584 821m
R_M1_seg_5320 M1_X_0_Y_4096 M1_X_640_Y_4096 6.568
R_M1_seg_5321 M1_X_640_Y_4096 M1_X_1280_Y_4096 6.568
R_M1_seg_5322 M1_X_1280_Y_4096 M1_X_1920_Y_4096 6.568
R_M1_seg_5323 M1_X_1920_Y_4096 M1_X_2560_Y_4096 6.568
R_M1_seg_5324 M1_X_2560_Y_4096 M1_X_3200_Y_4096 6.568
R_M1_seg_5325 M1_X_3200_Y_4096 M1_X_3840_Y_4096 6.568
R_M1_seg_5326 M1_X_3840_Y_4096 M1_X_4480_Y_4096 6.568
R_M1_seg_5327 M1_X_4480_Y_4096 M1_X_5120_Y_4096 6.568
R_M1_seg_5328 M1_X_5120_Y_4096 M1_X_5760_Y_4096 6.568
R_M1_seg_5329 M1_X_5760_Y_4096 M1_X_6400_Y_4096 6.568
R_M1_seg_5330 M1_X_6400_Y_4096 M1_X_7040_Y_4096 6.568
R_M1_seg_5331 M1_X_7040_Y_4096 M1_X_7680_Y_4096 6.568
R_M1_seg_5332 M1_X_7680_Y_4096 M1_X_8320_Y_4096 6.568
R_M1_seg_5333 M1_X_8320_Y_4096 M1_X_8960_Y_4096 6.568
R_M1_seg_5334 M1_X_8960_Y_4096 M1_X_9600_Y_4096 6.568
R_M1_seg_5335 M1_X_9600_Y_4096 M1_X_10000_Y_4096 4.105
R_M1_seg_5336 M1_X_0_Y_4608 M1_X_320_Y_4608 3.284
R_M1_seg_5337 M1_X_320_Y_4608 M1_X_960_Y_4608 6.568
R_M1_seg_5338 M1_X_960_Y_4608 M1_X_1600_Y_4608 6.568
R_M1_seg_5339 M1_X_1600_Y_4608 M1_X_2240_Y_4608 6.568
R_M1_seg_5340 M1_X_2240_Y_4608 M1_X_2880_Y_4608 6.568
R_M1_seg_5341 M1_X_2880_Y_4608 M1_X_3520_Y_4608 6.568
R_M1_seg_5342 M1_X_3520_Y_4608 M1_X_4160_Y_4608 6.568
R_M1_seg_5343 M1_X_4160_Y_4608 M1_X_4800_Y_4608 6.568
R_M1_seg_5344 M1_X_4800_Y_4608 M1_X_5440_Y_4608 6.568
R_M1_seg_5345 M1_X_5440_Y_4608 M1_X_6080_Y_4608 6.568
R_M1_seg_5346 M1_X_6080_Y_4608 M1_X_6720_Y_4608 6.568
R_M1_seg_5347 M1_X_6720_Y_4608 M1_X_7360_Y_4608 6.568
R_M1_seg_5348 M1_X_7360_Y_4608 M1_X_8000_Y_4608 6.568
R_M1_seg_5349 M1_X_8000_Y_4608 M1_X_8640_Y_4608 6.568
R_M1_seg_5350 M1_X_8640_Y_4608 M1_X_9280_Y_4608 6.568
R_M1_seg_5351 M1_X_9280_Y_4608 M1_X_9920_Y_4608 6.568
R_M1_seg_5352 M1_X_9920_Y_4608 M1_X_10000_Y_4608 821m
R_M1_seg_5353 M1_X_0_Y_5120 M1_X_640_Y_5120 6.568
R_M1_seg_5354 M1_X_640_Y_5120 M1_X_1280_Y_5120 6.568
R_M1_seg_5355 M1_X_1280_Y_5120 M1_X_1920_Y_5120 6.568
R_M1_seg_5356 M1_X_1920_Y_5120 M1_X_2560_Y_5120 6.568
R_M1_seg_5357 M1_X_2560_Y_5120 M1_X_3200_Y_5120 6.568
R_M1_seg_5358 M1_X_3200_Y_5120 M1_X_3840_Y_5120 6.568
R_M1_seg_5359 M1_X_3840_Y_5120 M1_X_4480_Y_5120 6.568
R_M1_seg_5360 M1_X_4480_Y_5120 M1_X_5120_Y_5120 6.568
R_M1_seg_5361 M1_X_5120_Y_5120 M1_X_5760_Y_5120 6.568
R_M1_seg_5362 M1_X_5760_Y_5120 M1_X_6400_Y_5120 6.568
R_M1_seg_5363 M1_X_6400_Y_5120 M1_X_7040_Y_5120 6.568
R_M1_seg_5364 M1_X_7040_Y_5120 M1_X_7680_Y_5120 6.568
R_M1_seg_5365 M1_X_7680_Y_5120 M1_X_8320_Y_5120 6.568
R_M1_seg_5366 M1_X_8320_Y_5120 M1_X_8960_Y_5120 6.568
R_M1_seg_5367 M1_X_8960_Y_5120 M1_X_9600_Y_5120 6.568
R_M1_seg_5368 M1_X_9600_Y_5120 M1_X_10000_Y_5120 4.105
R_M1_seg_5369 M1_X_0_Y_5632 M1_X_320_Y_5632 3.284
R_M1_seg_5370 M1_X_320_Y_5632 M1_X_960_Y_5632 6.568
R_M1_seg_5371 M1_X_960_Y_5632 M1_X_1600_Y_5632 6.568
R_M1_seg_5372 M1_X_1600_Y_5632 M1_X_2240_Y_5632 6.568
R_M1_seg_5373 M1_X_2240_Y_5632 M1_X_2880_Y_5632 6.568
R_M1_seg_5374 M1_X_2880_Y_5632 M1_X_3520_Y_5632 6.568
R_M1_seg_5375 M1_X_3520_Y_5632 M1_X_4160_Y_5632 6.568
R_M1_seg_5376 M1_X_4160_Y_5632 M1_X_4800_Y_5632 6.568
R_M1_seg_5377 M1_X_4800_Y_5632 M1_X_5440_Y_5632 6.568
R_M1_seg_5378 M1_X_5440_Y_5632 M1_X_6080_Y_5632 6.568
R_M1_seg_5379 M1_X_6080_Y_5632 M1_X_6720_Y_5632 6.568
R_M1_seg_5380 M1_X_6720_Y_5632 M1_X_7360_Y_5632 6.568
R_M1_seg_5381 M1_X_7360_Y_5632 M1_X_8000_Y_5632 6.568
R_M1_seg_5382 M1_X_8000_Y_5632 M1_X_8640_Y_5632 6.568
R_M1_seg_5383 M1_X_8640_Y_5632 M1_X_9280_Y_5632 6.568
R_M1_seg_5384 M1_X_9280_Y_5632 M1_X_9920_Y_5632 6.568
R_M1_seg_5385 M1_X_9920_Y_5632 M1_X_10000_Y_5632 821m
R_M1_seg_5386 M1_X_0_Y_6144 M1_X_640_Y_6144 6.568
R_M1_seg_5387 M1_X_640_Y_6144 M1_X_1280_Y_6144 6.568
R_M1_seg_5388 M1_X_1280_Y_6144 M1_X_1920_Y_6144 6.568
R_M1_seg_5389 M1_X_1920_Y_6144 M1_X_2560_Y_6144 6.568
R_M1_seg_5390 M1_X_2560_Y_6144 M1_X_3200_Y_6144 6.568
R_M1_seg_5391 M1_X_3200_Y_6144 M1_X_3840_Y_6144 6.568
R_M1_seg_5392 M1_X_3840_Y_6144 M1_X_4480_Y_6144 6.568
R_M1_seg_5393 M1_X_4480_Y_6144 M1_X_5120_Y_6144 6.568
R_M1_seg_5394 M1_X_5120_Y_6144 M1_X_5760_Y_6144 6.568
R_M1_seg_5395 M1_X_5760_Y_6144 M1_X_6400_Y_6144 6.568
R_M1_seg_5396 M1_X_6400_Y_6144 M1_X_7040_Y_6144 6.568
R_M1_seg_5397 M1_X_7040_Y_6144 M1_X_7680_Y_6144 6.568
R_M1_seg_5398 M1_X_7680_Y_6144 M1_X_8320_Y_6144 6.568
R_M1_seg_5399 M1_X_8320_Y_6144 M1_X_8960_Y_6144 6.568
R_M1_seg_5400 M1_X_8960_Y_6144 M1_X_9600_Y_6144 6.568
R_M1_seg_5401 M1_X_9600_Y_6144 M1_X_10000_Y_6144 4.105
R_M1_seg_5402 M1_X_0_Y_6656 M1_X_320_Y_6656 3.284
R_M1_seg_5403 M1_X_320_Y_6656 M1_X_960_Y_6656 6.568
R_M1_seg_5404 M1_X_960_Y_6656 M1_X_1600_Y_6656 6.568
R_M1_seg_5405 M1_X_1600_Y_6656 M1_X_2240_Y_6656 6.568
R_M1_seg_5406 M1_X_2240_Y_6656 M1_X_2880_Y_6656 6.568
R_M1_seg_5407 M1_X_2880_Y_6656 M1_X_3520_Y_6656 6.568
R_M1_seg_5408 M1_X_3520_Y_6656 M1_X_4160_Y_6656 6.568
R_M1_seg_5409 M1_X_4160_Y_6656 M1_X_4800_Y_6656 6.568
R_M1_seg_5410 M1_X_4800_Y_6656 M1_X_5440_Y_6656 6.568
R_M1_seg_5411 M1_X_5440_Y_6656 M1_X_6080_Y_6656 6.568
R_M1_seg_5412 M1_X_6080_Y_6656 M1_X_6720_Y_6656 6.568
R_M1_seg_5413 M1_X_6720_Y_6656 M1_X_7360_Y_6656 6.568
R_M1_seg_5414 M1_X_7360_Y_6656 M1_X_8000_Y_6656 6.568
R_M1_seg_5415 M1_X_8000_Y_6656 M1_X_8640_Y_6656 6.568
R_M1_seg_5416 M1_X_8640_Y_6656 M1_X_9280_Y_6656 6.568
R_M1_seg_5417 M1_X_9280_Y_6656 M1_X_9920_Y_6656 6.568
R_M1_seg_5418 M1_X_9920_Y_6656 M1_X_10000_Y_6656 821m
R_M1_seg_5419 M1_X_0_Y_7168 M1_X_640_Y_7168 6.568
R_M1_seg_5420 M1_X_640_Y_7168 M1_X_1280_Y_7168 6.568
R_M1_seg_5421 M1_X_1280_Y_7168 M1_X_1920_Y_7168 6.568
R_M1_seg_5422 M1_X_1920_Y_7168 M1_X_2560_Y_7168 6.568
R_M1_seg_5423 M1_X_2560_Y_7168 M1_X_3200_Y_7168 6.568
R_M1_seg_5424 M1_X_3200_Y_7168 M1_X_3840_Y_7168 6.568
R_M1_seg_5425 M1_X_3840_Y_7168 M1_X_4480_Y_7168 6.568
R_M1_seg_5426 M1_X_4480_Y_7168 M1_X_5120_Y_7168 6.568
R_M1_seg_5427 M1_X_5120_Y_7168 M1_X_5760_Y_7168 6.568
R_M1_seg_5428 M1_X_5760_Y_7168 M1_X_6400_Y_7168 6.568
R_M1_seg_5429 M1_X_6400_Y_7168 M1_X_7040_Y_7168 6.568
R_M1_seg_5430 M1_X_7040_Y_7168 M1_X_7680_Y_7168 6.568
R_M1_seg_5431 M1_X_7680_Y_7168 M1_X_8320_Y_7168 6.568
R_M1_seg_5432 M1_X_8320_Y_7168 M1_X_8960_Y_7168 6.568
R_M1_seg_5433 M1_X_8960_Y_7168 M1_X_9600_Y_7168 6.568
R_M1_seg_5434 M1_X_9600_Y_7168 M1_X_10000_Y_7168 4.105
R_M1_seg_5435 M1_X_0_Y_7680 M1_X_320_Y_7680 3.284
R_M1_seg_5436 M1_X_320_Y_7680 M1_X_960_Y_7680 6.568
R_M1_seg_5437 M1_X_960_Y_7680 M1_X_1600_Y_7680 6.568
R_M1_seg_5438 M1_X_1600_Y_7680 M1_X_2240_Y_7680 6.568
R_M1_seg_5439 M1_X_2240_Y_7680 M1_X_2880_Y_7680 6.568
R_M1_seg_5440 M1_X_2880_Y_7680 M1_X_3520_Y_7680 6.568
R_M1_seg_5441 M1_X_3520_Y_7680 M1_X_4160_Y_7680 6.568
R_M1_seg_5442 M1_X_4160_Y_7680 M1_X_4800_Y_7680 6.568
R_M1_seg_5443 M1_X_4800_Y_7680 M1_X_5440_Y_7680 6.568
R_M1_seg_5444 M1_X_5440_Y_7680 M1_X_6080_Y_7680 6.568
R_M1_seg_5445 M1_X_6080_Y_7680 M1_X_6720_Y_7680 6.568
R_M1_seg_5446 M1_X_6720_Y_7680 M1_X_7360_Y_7680 6.568
R_M1_seg_5447 M1_X_7360_Y_7680 M1_X_8000_Y_7680 6.568
R_M1_seg_5448 M1_X_8000_Y_7680 M1_X_8640_Y_7680 6.568
R_M1_seg_5449 M1_X_8640_Y_7680 M1_X_9280_Y_7680 6.568
R_M1_seg_5450 M1_X_9280_Y_7680 M1_X_9920_Y_7680 6.568
R_M1_seg_5451 M1_X_9920_Y_7680 M1_X_10000_Y_7680 821m
R_M1_seg_5452 M1_X_0_Y_8192 M1_X_640_Y_8192 6.568
R_M1_seg_5453 M1_X_640_Y_8192 M1_X_1280_Y_8192 6.568
R_M1_seg_5454 M1_X_1280_Y_8192 M1_X_1920_Y_8192 6.568
R_M1_seg_5455 M1_X_1920_Y_8192 M1_X_2560_Y_8192 6.568
R_M1_seg_5456 M1_X_2560_Y_8192 M1_X_3200_Y_8192 6.568
R_M1_seg_5457 M1_X_3200_Y_8192 M1_X_3840_Y_8192 6.568
R_M1_seg_5458 M1_X_3840_Y_8192 M1_X_4480_Y_8192 6.568
R_M1_seg_5459 M1_X_4480_Y_8192 M1_X_5120_Y_8192 6.568
R_M1_seg_5460 M1_X_5120_Y_8192 M1_X_5760_Y_8192 6.568
R_M1_seg_5461 M1_X_5760_Y_8192 M1_X_6400_Y_8192 6.568
R_M1_seg_5462 M1_X_6400_Y_8192 M1_X_7040_Y_8192 6.568
R_M1_seg_5463 M1_X_7040_Y_8192 M1_X_7680_Y_8192 6.568
R_M1_seg_5464 M1_X_7680_Y_8192 M1_X_8320_Y_8192 6.568
R_M1_seg_5465 M1_X_8320_Y_8192 M1_X_8960_Y_8192 6.568
R_M1_seg_5466 M1_X_8960_Y_8192 M1_X_9600_Y_8192 6.568
R_M1_seg_5467 M1_X_9600_Y_8192 M1_X_10000_Y_8192 4.105
R_M1_seg_5468 M1_X_0_Y_8704 M1_X_320_Y_8704 3.284
R_M1_seg_5469 M1_X_320_Y_8704 M1_X_960_Y_8704 6.568
R_M1_seg_5470 M1_X_960_Y_8704 M1_X_1600_Y_8704 6.568
R_M1_seg_5471 M1_X_1600_Y_8704 M1_X_2240_Y_8704 6.568
R_M1_seg_5472 M1_X_2240_Y_8704 M1_X_2880_Y_8704 6.568
R_M1_seg_5473 M1_X_2880_Y_8704 M1_X_3520_Y_8704 6.568
R_M1_seg_5474 M1_X_3520_Y_8704 M1_X_4160_Y_8704 6.568
R_M1_seg_5475 M1_X_4160_Y_8704 M1_X_4800_Y_8704 6.568
R_M1_seg_5476 M1_X_4800_Y_8704 M1_X_5440_Y_8704 6.568
R_M1_seg_5477 M1_X_5440_Y_8704 M1_X_6080_Y_8704 6.568
R_M1_seg_5478 M1_X_6080_Y_8704 M1_X_6720_Y_8704 6.568
R_M1_seg_5479 M1_X_6720_Y_8704 M1_X_7360_Y_8704 6.568
R_M1_seg_5480 M1_X_7360_Y_8704 M1_X_8000_Y_8704 6.568
R_M1_seg_5481 M1_X_8000_Y_8704 M1_X_8640_Y_8704 6.568
R_M1_seg_5482 M1_X_8640_Y_8704 M1_X_9280_Y_8704 6.568
R_M1_seg_5483 M1_X_9280_Y_8704 M1_X_9920_Y_8704 6.568
R_M1_seg_5484 M1_X_9920_Y_8704 M1_X_10000_Y_8704 821m
R_M1_seg_5485 M1_X_0_Y_9216 M1_X_640_Y_9216 6.568
R_M1_seg_5486 M1_X_640_Y_9216 M1_X_1280_Y_9216 6.568
R_M1_seg_5487 M1_X_1280_Y_9216 M1_X_1920_Y_9216 6.568
R_M1_seg_5488 M1_X_1920_Y_9216 M1_X_2560_Y_9216 6.568
R_M1_seg_5489 M1_X_2560_Y_9216 M1_X_3200_Y_9216 6.568
R_M1_seg_5490 M1_X_3200_Y_9216 M1_X_3840_Y_9216 6.568
R_M1_seg_5491 M1_X_3840_Y_9216 M1_X_4480_Y_9216 6.568
R_M1_seg_5492 M1_X_4480_Y_9216 M1_X_5120_Y_9216 6.568
R_M1_seg_5493 M1_X_5120_Y_9216 M1_X_5760_Y_9216 6.568
R_M1_seg_5494 M1_X_5760_Y_9216 M1_X_6400_Y_9216 6.568
R_M1_seg_5495 M1_X_6400_Y_9216 M1_X_7040_Y_9216 6.568
R_M1_seg_5496 M1_X_7040_Y_9216 M1_X_7680_Y_9216 6.568
R_M1_seg_5497 M1_X_7680_Y_9216 M1_X_8320_Y_9216 6.568
R_M1_seg_5498 M1_X_8320_Y_9216 M1_X_8960_Y_9216 6.568
R_M1_seg_5499 M1_X_8960_Y_9216 M1_X_9600_Y_9216 6.568
R_M1_seg_5500 M1_X_9600_Y_9216 M1_X_10000_Y_9216 4.105
R_M1_seg_5501 M1_X_0_Y_9728 M1_X_320_Y_9728 3.284
R_M1_seg_5502 M1_X_320_Y_9728 M1_X_960_Y_9728 6.568
R_M1_seg_5503 M1_X_960_Y_9728 M1_X_1600_Y_9728 6.568
R_M1_seg_5504 M1_X_1600_Y_9728 M1_X_2240_Y_9728 6.568
R_M1_seg_5505 M1_X_2240_Y_9728 M1_X_2880_Y_9728 6.568
R_M1_seg_5506 M1_X_2880_Y_9728 M1_X_3520_Y_9728 6.568
R_M1_seg_5507 M1_X_3520_Y_9728 M1_X_4160_Y_9728 6.568
R_M1_seg_5508 M1_X_4160_Y_9728 M1_X_4800_Y_9728 6.568
R_M1_seg_5509 M1_X_4800_Y_9728 M1_X_5440_Y_9728 6.568
R_M1_seg_5510 M1_X_5440_Y_9728 M1_X_6080_Y_9728 6.568
R_M1_seg_5511 M1_X_6080_Y_9728 M1_X_6720_Y_9728 6.568
R_M1_seg_5512 M1_X_6720_Y_9728 M1_X_7360_Y_9728 6.568
R_M1_seg_5513 M1_X_7360_Y_9728 M1_X_8000_Y_9728 6.568
R_M1_seg_5514 M1_X_8000_Y_9728 M1_X_8640_Y_9728 6.568
R_M1_seg_5515 M1_X_8640_Y_9728 M1_X_9280_Y_9728 6.568
R_M1_seg_5516 M1_X_9280_Y_9728 M1_X_9920_Y_9728 6.568
R_M1_seg_5517 M1_X_9920_Y_9728 M1_X_10000_Y_9728 821m

* === Via Resistances ===
R_VG1_0 MG2_X_0_Y_0 MG1_X_0_Y_0 357.4m
R_VG1_1 MG2_X_537_Y_0 MG1_X_537_Y_0 357.4m
R_VG1_2 MG2_X_1075_Y_0 MG1_X_1075_Y_0 357.4m
R_VG1_3 MG2_X_1612_Y_0 MG1_X_1612_Y_0 357.4m
R_VG1_4 MG2_X_2150_Y_0 MG1_X_2150_Y_0 357.4m
R_VG1_5 MG2_X_2688_Y_0 MG1_X_2688_Y_0 357.4m
R_VG1_6 MG2_X_3225_Y_0 MG1_X_3225_Y_0 357.4m
R_VG1_7 MG2_X_3763_Y_0 MG1_X_3763_Y_0 357.4m
R_VG1_8 MG2_X_4300_Y_0 MG1_X_4300_Y_0 357.4m
R_VG1_9 MG2_X_4838_Y_0 MG1_X_4838_Y_0 357.4m
R_VG1_10 MG2_X_5376_Y_0 MG1_X_5376_Y_0 357.4m
R_VG1_11 MG2_X_5913_Y_0 MG1_X_5913_Y_0 357.4m
R_VG1_12 MG2_X_6451_Y_0 MG1_X_6451_Y_0 357.4m
R_VG1_13 MG2_X_6988_Y_0 MG1_X_6988_Y_0 357.4m
R_VG1_14 MG2_X_7526_Y_0 MG1_X_7526_Y_0 357.4m
R_VG1_15 MG2_X_8064_Y_0 MG1_X_8064_Y_0 357.4m
R_VG1_16 MG2_X_8601_Y_0 MG1_X_8601_Y_0 357.4m
R_VG1_17 MG2_X_9139_Y_0 MG1_X_9139_Y_0 357.4m
R_VG1_18 MG2_X_9676_Y_0 MG1_X_9676_Y_0 357.4m
R_VG1_19 MG2_X_268_Y_268 MG1_X_268_Y_268 357.4m
R_VG1_20 MG2_X_806_Y_268 MG1_X_806_Y_268 357.4m
R_VG1_21 MG2_X_1344_Y_268 MG1_X_1344_Y_268 357.4m
R_VG1_22 MG2_X_1881_Y_268 MG1_X_1881_Y_268 357.4m
R_VG1_23 MG2_X_2419_Y_268 MG1_X_2419_Y_268 357.4m
R_VG1_24 MG2_X_2956_Y_268 MG1_X_2956_Y_268 357.4m
R_VG1_25 MG2_X_3494_Y_268 MG1_X_3494_Y_268 357.4m
R_VG1_26 MG2_X_4032_Y_268 MG1_X_4032_Y_268 357.4m
R_VG1_27 MG2_X_4569_Y_268 MG1_X_4569_Y_268 357.4m
R_VG1_28 MG2_X_5107_Y_268 MG1_X_5107_Y_268 357.4m
R_VG1_29 MG2_X_5644_Y_268 MG1_X_5644_Y_268 357.4m
R_VG1_30 MG2_X_6182_Y_268 MG1_X_6182_Y_268 357.4m
R_VG1_31 MG2_X_6720_Y_268 MG1_X_6720_Y_268 357.4m
R_VG1_32 MG2_X_7257_Y_268 MG1_X_7257_Y_268 357.4m
R_VG1_33 MG2_X_7795_Y_268 MG1_X_7795_Y_268 357.4m
R_VG1_34 MG2_X_8332_Y_268 MG1_X_8332_Y_268 357.4m
R_VG1_35 MG2_X_8870_Y_268 MG1_X_8870_Y_268 357.4m
R_VG1_36 MG2_X_9408_Y_268 MG1_X_9408_Y_268 357.4m
R_VG1_37 MG2_X_9945_Y_268 MG1_X_9945_Y_268 357.4m
R_VG1_38 MG2_X_0_Y_537 MG1_X_0_Y_537 357.4m
R_VG1_39 MG2_X_537_Y_537 MG1_X_537_Y_537 357.4m
R_VG1_40 MG2_X_1075_Y_537 MG1_X_1075_Y_537 357.4m
R_VG1_41 MG2_X_1612_Y_537 MG1_X_1612_Y_537 357.4m
R_VG1_42 MG2_X_2150_Y_537 MG1_X_2150_Y_537 357.4m
R_VG1_43 MG2_X_2688_Y_537 MG1_X_2688_Y_537 357.4m
R_VG1_44 MG2_X_3225_Y_537 MG1_X_3225_Y_537 357.4m
R_VG1_45 MG2_X_3763_Y_537 MG1_X_3763_Y_537 357.4m
R_VG1_46 MG2_X_4300_Y_537 MG1_X_4300_Y_537 357.4m
R_VG1_47 MG2_X_4838_Y_537 MG1_X_4838_Y_537 357.4m
R_VG1_48 MG2_X_5376_Y_537 MG1_X_5376_Y_537 357.4m
R_VG1_49 MG2_X_5913_Y_537 MG1_X_5913_Y_537 357.4m
R_VG1_50 MG2_X_6451_Y_537 MG1_X_6451_Y_537 357.4m
R_VG1_51 MG2_X_6988_Y_537 MG1_X_6988_Y_537 357.4m
R_VG1_52 MG2_X_7526_Y_537 MG1_X_7526_Y_537 357.4m
R_VG1_53 MG2_X_8064_Y_537 MG1_X_8064_Y_537 357.4m
R_VG1_54 MG2_X_8601_Y_537 MG1_X_8601_Y_537 357.4m
R_VG1_55 MG2_X_9139_Y_537 MG1_X_9139_Y_537 357.4m
R_VG1_56 MG2_X_9676_Y_537 MG1_X_9676_Y_537 357.4m
R_VG1_57 MG2_X_268_Y_806 MG1_X_268_Y_806 357.4m
R_VG1_58 MG2_X_806_Y_806 MG1_X_806_Y_806 357.4m
R_VG1_59 MG2_X_1344_Y_806 MG1_X_1344_Y_806 357.4m
R_VG1_60 MG2_X_1881_Y_806 MG1_X_1881_Y_806 357.4m
R_VG1_61 MG2_X_2419_Y_806 MG1_X_2419_Y_806 357.4m
R_VG1_62 MG2_X_2956_Y_806 MG1_X_2956_Y_806 357.4m
R_VG1_63 MG2_X_3494_Y_806 MG1_X_3494_Y_806 357.4m
R_VG1_64 MG2_X_4032_Y_806 MG1_X_4032_Y_806 357.4m
R_VG1_65 MG2_X_4569_Y_806 MG1_X_4569_Y_806 357.4m
R_VG1_66 MG2_X_5107_Y_806 MG1_X_5107_Y_806 357.4m
R_VG1_67 MG2_X_5644_Y_806 MG1_X_5644_Y_806 357.4m
R_VG1_68 MG2_X_6182_Y_806 MG1_X_6182_Y_806 357.4m
R_VG1_69 MG2_X_6720_Y_806 MG1_X_6720_Y_806 357.4m
R_VG1_70 MG2_X_7257_Y_806 MG1_X_7257_Y_806 357.4m
R_VG1_71 MG2_X_7795_Y_806 MG1_X_7795_Y_806 357.4m
R_VG1_72 MG2_X_8332_Y_806 MG1_X_8332_Y_806 357.4m
R_VG1_73 MG2_X_8870_Y_806 MG1_X_8870_Y_806 357.4m
R_VG1_74 MG2_X_9408_Y_806 MG1_X_9408_Y_806 357.4m
R_VG1_75 MG2_X_9945_Y_806 MG1_X_9945_Y_806 357.4m
R_VG1_76 MG2_X_0_Y_1075 MG1_X_0_Y_1075 357.4m
R_VG1_77 MG2_X_537_Y_1075 MG1_X_537_Y_1075 357.4m
R_VG1_78 MG2_X_1075_Y_1075 MG1_X_1075_Y_1075 357.4m
R_VG1_79 MG2_X_1612_Y_1075 MG1_X_1612_Y_1075 357.4m
R_VG1_80 MG2_X_2150_Y_1075 MG1_X_2150_Y_1075 357.4m
R_VG1_81 MG2_X_2688_Y_1075 MG1_X_2688_Y_1075 357.4m
R_VG1_82 MG2_X_3225_Y_1075 MG1_X_3225_Y_1075 357.4m
R_VG1_83 MG2_X_3763_Y_1075 MG1_X_3763_Y_1075 357.4m
R_VG1_84 MG2_X_4300_Y_1075 MG1_X_4300_Y_1075 357.4m
R_VG1_85 MG2_X_4838_Y_1075 MG1_X_4838_Y_1075 357.4m
R_VG1_86 MG2_X_5376_Y_1075 MG1_X_5376_Y_1075 357.4m
R_VG1_87 MG2_X_5913_Y_1075 MG1_X_5913_Y_1075 357.4m
R_VG1_88 MG2_X_6451_Y_1075 MG1_X_6451_Y_1075 357.4m
R_VG1_89 MG2_X_6988_Y_1075 MG1_X_6988_Y_1075 357.4m
R_VG1_90 MG2_X_7526_Y_1075 MG1_X_7526_Y_1075 357.4m
R_VG1_91 MG2_X_8064_Y_1075 MG1_X_8064_Y_1075 357.4m
R_VG1_92 MG2_X_8601_Y_1075 MG1_X_8601_Y_1075 357.4m
R_VG1_93 MG2_X_9139_Y_1075 MG1_X_9139_Y_1075 357.4m
R_VG1_94 MG2_X_9676_Y_1075 MG1_X_9676_Y_1075 357.4m
R_VG1_95 MG2_X_268_Y_1344 MG1_X_268_Y_1344 357.4m
R_VG1_96 MG2_X_806_Y_1344 MG1_X_806_Y_1344 357.4m
R_VG1_97 MG2_X_1344_Y_1344 MG1_X_1344_Y_1344 357.4m
R_VG1_98 MG2_X_1881_Y_1344 MG1_X_1881_Y_1344 357.4m
R_VG1_99 MG2_X_2419_Y_1344 MG1_X_2419_Y_1344 357.4m
R_VG1_100 MG2_X_2956_Y_1344 MG1_X_2956_Y_1344 357.4m
R_VG1_101 MG2_X_3494_Y_1344 MG1_X_3494_Y_1344 357.4m
R_VG1_102 MG2_X_4032_Y_1344 MG1_X_4032_Y_1344 357.4m
R_VG1_103 MG2_X_4569_Y_1344 MG1_X_4569_Y_1344 357.4m
R_VG1_104 MG2_X_5107_Y_1344 MG1_X_5107_Y_1344 357.4m
R_VG1_105 MG2_X_5644_Y_1344 MG1_X_5644_Y_1344 357.4m
R_VG1_106 MG2_X_6182_Y_1344 MG1_X_6182_Y_1344 357.4m
R_VG1_107 MG2_X_6720_Y_1344 MG1_X_6720_Y_1344 357.4m
R_VG1_108 MG2_X_7257_Y_1344 MG1_X_7257_Y_1344 357.4m
R_VG1_109 MG2_X_7795_Y_1344 MG1_X_7795_Y_1344 357.4m
R_VG1_110 MG2_X_8332_Y_1344 MG1_X_8332_Y_1344 357.4m
R_VG1_111 MG2_X_8870_Y_1344 MG1_X_8870_Y_1344 357.4m
R_VG1_112 MG2_X_9408_Y_1344 MG1_X_9408_Y_1344 357.4m
R_VG1_113 MG2_X_9945_Y_1344 MG1_X_9945_Y_1344 357.4m
R_VG1_114 MG2_X_0_Y_1612 MG1_X_0_Y_1612 357.4m
R_VG1_115 MG2_X_537_Y_1612 MG1_X_537_Y_1612 357.4m
R_VG1_116 MG2_X_1075_Y_1612 MG1_X_1075_Y_1612 357.4m
R_VG1_117 MG2_X_1612_Y_1612 MG1_X_1612_Y_1612 357.4m
R_VG1_118 MG2_X_2150_Y_1612 MG1_X_2150_Y_1612 357.4m
R_VG1_119 MG2_X_2688_Y_1612 MG1_X_2688_Y_1612 357.4m
R_VG1_120 MG2_X_3225_Y_1612 MG1_X_3225_Y_1612 357.4m
R_VG1_121 MG2_X_3763_Y_1612 MG1_X_3763_Y_1612 357.4m
R_VG1_122 MG2_X_4300_Y_1612 MG1_X_4300_Y_1612 357.4m
R_VG1_123 MG2_X_4838_Y_1612 MG1_X_4838_Y_1612 357.4m
R_VG1_124 MG2_X_5376_Y_1612 MG1_X_5376_Y_1612 357.4m
R_VG1_125 MG2_X_5913_Y_1612 MG1_X_5913_Y_1612 357.4m
R_VG1_126 MG2_X_6451_Y_1612 MG1_X_6451_Y_1612 357.4m
R_VG1_127 MG2_X_6988_Y_1612 MG1_X_6988_Y_1612 357.4m
R_VG1_128 MG2_X_7526_Y_1612 MG1_X_7526_Y_1612 357.4m
R_VG1_129 MG2_X_8064_Y_1612 MG1_X_8064_Y_1612 357.4m
R_VG1_130 MG2_X_8601_Y_1612 MG1_X_8601_Y_1612 357.4m
R_VG1_131 MG2_X_9139_Y_1612 MG1_X_9139_Y_1612 357.4m
R_VG1_132 MG2_X_9676_Y_1612 MG1_X_9676_Y_1612 357.4m
R_VG1_133 MG2_X_268_Y_1881 MG1_X_268_Y_1881 357.4m
R_VG1_134 MG2_X_806_Y_1881 MG1_X_806_Y_1881 357.4m
R_VG1_135 MG2_X_1344_Y_1881 MG1_X_1344_Y_1881 357.4m
R_VG1_136 MG2_X_1881_Y_1881 MG1_X_1881_Y_1881 357.4m
R_VG1_137 MG2_X_2419_Y_1881 MG1_X_2419_Y_1881 357.4m
R_VG1_138 MG2_X_2956_Y_1881 MG1_X_2956_Y_1881 357.4m
R_VG1_139 MG2_X_3494_Y_1881 MG1_X_3494_Y_1881 357.4m
R_VG1_140 MG2_X_4032_Y_1881 MG1_X_4032_Y_1881 357.4m
R_VG1_141 MG2_X_4569_Y_1881 MG1_X_4569_Y_1881 357.4m
R_VG1_142 MG2_X_5107_Y_1881 MG1_X_5107_Y_1881 357.4m
R_VG1_143 MG2_X_5644_Y_1881 MG1_X_5644_Y_1881 357.4m
R_VG1_144 MG2_X_6182_Y_1881 MG1_X_6182_Y_1881 357.4m
R_VG1_145 MG2_X_6720_Y_1881 MG1_X_6720_Y_1881 357.4m
R_VG1_146 MG2_X_7257_Y_1881 MG1_X_7257_Y_1881 357.4m
R_VG1_147 MG2_X_7795_Y_1881 MG1_X_7795_Y_1881 357.4m
R_VG1_148 MG2_X_8332_Y_1881 MG1_X_8332_Y_1881 357.4m
R_VG1_149 MG2_X_8870_Y_1881 MG1_X_8870_Y_1881 357.4m
R_VG1_150 MG2_X_9408_Y_1881 MG1_X_9408_Y_1881 357.4m
R_VG1_151 MG2_X_9945_Y_1881 MG1_X_9945_Y_1881 357.4m
R_VG1_152 MG2_X_0_Y_2150 MG1_X_0_Y_2150 357.4m
R_VG1_153 MG2_X_537_Y_2150 MG1_X_537_Y_2150 357.4m
R_VG1_154 MG2_X_1075_Y_2150 MG1_X_1075_Y_2150 357.4m
R_VG1_155 MG2_X_1612_Y_2150 MG1_X_1612_Y_2150 357.4m
R_VG1_156 MG2_X_2150_Y_2150 MG1_X_2150_Y_2150 357.4m
R_VG1_157 MG2_X_2688_Y_2150 MG1_X_2688_Y_2150 357.4m
R_VG1_158 MG2_X_3225_Y_2150 MG1_X_3225_Y_2150 357.4m
R_VG1_159 MG2_X_3763_Y_2150 MG1_X_3763_Y_2150 357.4m
R_VG1_160 MG2_X_4300_Y_2150 MG1_X_4300_Y_2150 357.4m
R_VG1_161 MG2_X_4838_Y_2150 MG1_X_4838_Y_2150 357.4m
R_VG1_162 MG2_X_5376_Y_2150 MG1_X_5376_Y_2150 357.4m
R_VG1_163 MG2_X_5913_Y_2150 MG1_X_5913_Y_2150 357.4m
R_VG1_164 MG2_X_6451_Y_2150 MG1_X_6451_Y_2150 357.4m
R_VG1_165 MG2_X_6988_Y_2150 MG1_X_6988_Y_2150 357.4m
R_VG1_166 MG2_X_7526_Y_2150 MG1_X_7526_Y_2150 357.4m
R_VG1_167 MG2_X_8064_Y_2150 MG1_X_8064_Y_2150 357.4m
R_VG1_168 MG2_X_8601_Y_2150 MG1_X_8601_Y_2150 357.4m
R_VG1_169 MG2_X_9139_Y_2150 MG1_X_9139_Y_2150 357.4m
R_VG1_170 MG2_X_9676_Y_2150 MG1_X_9676_Y_2150 357.4m
R_VG1_171 MG2_X_268_Y_2419 MG1_X_268_Y_2419 357.4m
R_VG1_172 MG2_X_806_Y_2419 MG1_X_806_Y_2419 357.4m
R_VG1_173 MG2_X_1344_Y_2419 MG1_X_1344_Y_2419 357.4m
R_VG1_174 MG2_X_1881_Y_2419 MG1_X_1881_Y_2419 357.4m
R_VG1_175 MG2_X_2419_Y_2419 MG1_X_2419_Y_2419 357.4m
R_VG1_176 MG2_X_2956_Y_2419 MG1_X_2956_Y_2419 357.4m
R_VG1_177 MG2_X_3494_Y_2419 MG1_X_3494_Y_2419 357.4m
R_VG1_178 MG2_X_4032_Y_2419 MG1_X_4032_Y_2419 357.4m
R_VG1_179 MG2_X_4569_Y_2419 MG1_X_4569_Y_2419 357.4m
R_VG1_180 MG2_X_5107_Y_2419 MG1_X_5107_Y_2419 357.4m
R_VG1_181 MG2_X_5644_Y_2419 MG1_X_5644_Y_2419 357.4m
R_VG1_182 MG2_X_6182_Y_2419 MG1_X_6182_Y_2419 357.4m
R_VG1_183 MG2_X_6720_Y_2419 MG1_X_6720_Y_2419 357.4m
R_VG1_184 MG2_X_7257_Y_2419 MG1_X_7257_Y_2419 357.4m
R_VG1_185 MG2_X_7795_Y_2419 MG1_X_7795_Y_2419 357.4m
R_VG1_186 MG2_X_8332_Y_2419 MG1_X_8332_Y_2419 357.4m
R_VG1_187 MG2_X_8870_Y_2419 MG1_X_8870_Y_2419 357.4m
R_VG1_188 MG2_X_9408_Y_2419 MG1_X_9408_Y_2419 357.4m
R_VG1_189 MG2_X_9945_Y_2419 MG1_X_9945_Y_2419 357.4m
R_VG1_190 MG2_X_0_Y_2688 MG1_X_0_Y_2688 357.4m
R_VG1_191 MG2_X_537_Y_2688 MG1_X_537_Y_2688 357.4m
R_VG1_192 MG2_X_1075_Y_2688 MG1_X_1075_Y_2688 357.4m
R_VG1_193 MG2_X_1612_Y_2688 MG1_X_1612_Y_2688 357.4m
R_VG1_194 MG2_X_2150_Y_2688 MG1_X_2150_Y_2688 357.4m
R_VG1_195 MG2_X_2688_Y_2688 MG1_X_2688_Y_2688 357.4m
R_VG1_196 MG2_X_3225_Y_2688 MG1_X_3225_Y_2688 357.4m
R_VG1_197 MG2_X_3763_Y_2688 MG1_X_3763_Y_2688 357.4m
R_VG1_198 MG2_X_4300_Y_2688 MG1_X_4300_Y_2688 357.4m
R_VG1_199 MG2_X_4838_Y_2688 MG1_X_4838_Y_2688 357.4m
R_VG1_200 MG2_X_5376_Y_2688 MG1_X_5376_Y_2688 357.4m
R_VG1_201 MG2_X_5913_Y_2688 MG1_X_5913_Y_2688 357.4m
R_VG1_202 MG2_X_6451_Y_2688 MG1_X_6451_Y_2688 357.4m
R_VG1_203 MG2_X_6988_Y_2688 MG1_X_6988_Y_2688 357.4m
R_VG1_204 MG2_X_7526_Y_2688 MG1_X_7526_Y_2688 357.4m
R_VG1_205 MG2_X_8064_Y_2688 MG1_X_8064_Y_2688 357.4m
R_VG1_206 MG2_X_8601_Y_2688 MG1_X_8601_Y_2688 357.4m
R_VG1_207 MG2_X_9139_Y_2688 MG1_X_9139_Y_2688 357.4m
R_VG1_208 MG2_X_9676_Y_2688 MG1_X_9676_Y_2688 357.4m
R_VG1_209 MG2_X_268_Y_2956 MG1_X_268_Y_2956 357.4m
R_VG1_210 MG2_X_806_Y_2956 MG1_X_806_Y_2956 357.4m
R_VG1_211 MG2_X_1344_Y_2956 MG1_X_1344_Y_2956 357.4m
R_VG1_212 MG2_X_1881_Y_2956 MG1_X_1881_Y_2956 357.4m
R_VG1_213 MG2_X_2419_Y_2956 MG1_X_2419_Y_2956 357.4m
R_VG1_214 MG2_X_2956_Y_2956 MG1_X_2956_Y_2956 357.4m
R_VG1_215 MG2_X_3494_Y_2956 MG1_X_3494_Y_2956 357.4m
R_VG1_216 MG2_X_4032_Y_2956 MG1_X_4032_Y_2956 357.4m
R_VG1_217 MG2_X_4569_Y_2956 MG1_X_4569_Y_2956 357.4m
R_VG1_218 MG2_X_5107_Y_2956 MG1_X_5107_Y_2956 357.4m
R_VG1_219 MG2_X_5644_Y_2956 MG1_X_5644_Y_2956 357.4m
R_VG1_220 MG2_X_6182_Y_2956 MG1_X_6182_Y_2956 357.4m
R_VG1_221 MG2_X_6720_Y_2956 MG1_X_6720_Y_2956 357.4m
R_VG1_222 MG2_X_7257_Y_2956 MG1_X_7257_Y_2956 357.4m
R_VG1_223 MG2_X_7795_Y_2956 MG1_X_7795_Y_2956 357.4m
R_VG1_224 MG2_X_8332_Y_2956 MG1_X_8332_Y_2956 357.4m
R_VG1_225 MG2_X_8870_Y_2956 MG1_X_8870_Y_2956 357.4m
R_VG1_226 MG2_X_9408_Y_2956 MG1_X_9408_Y_2956 357.4m
R_VG1_227 MG2_X_9945_Y_2956 MG1_X_9945_Y_2956 357.4m
R_VG1_228 MG2_X_0_Y_3225 MG1_X_0_Y_3225 357.4m
R_VG1_229 MG2_X_537_Y_3225 MG1_X_537_Y_3225 357.4m
R_VG1_230 MG2_X_1075_Y_3225 MG1_X_1075_Y_3225 357.4m
R_VG1_231 MG2_X_1612_Y_3225 MG1_X_1612_Y_3225 357.4m
R_VG1_232 MG2_X_2150_Y_3225 MG1_X_2150_Y_3225 357.4m
R_VG1_233 MG2_X_2688_Y_3225 MG1_X_2688_Y_3225 357.4m
R_VG1_234 MG2_X_3225_Y_3225 MG1_X_3225_Y_3225 357.4m
R_VG1_235 MG2_X_3763_Y_3225 MG1_X_3763_Y_3225 357.4m
R_VG1_236 MG2_X_4300_Y_3225 MG1_X_4300_Y_3225 357.4m
R_VG1_237 MG2_X_4838_Y_3225 MG1_X_4838_Y_3225 357.4m
R_VG1_238 MG2_X_5376_Y_3225 MG1_X_5376_Y_3225 357.4m
R_VG1_239 MG2_X_5913_Y_3225 MG1_X_5913_Y_3225 357.4m
R_VG1_240 MG2_X_6451_Y_3225 MG1_X_6451_Y_3225 357.4m
R_VG1_241 MG2_X_6988_Y_3225 MG1_X_6988_Y_3225 357.4m
R_VG1_242 MG2_X_7526_Y_3225 MG1_X_7526_Y_3225 357.4m
R_VG1_243 MG2_X_8064_Y_3225 MG1_X_8064_Y_3225 357.4m
R_VG1_244 MG2_X_8601_Y_3225 MG1_X_8601_Y_3225 357.4m
R_VG1_245 MG2_X_9139_Y_3225 MG1_X_9139_Y_3225 357.4m
R_VG1_246 MG2_X_9676_Y_3225 MG1_X_9676_Y_3225 357.4m
R_VG1_247 MG2_X_268_Y_3494 MG1_X_268_Y_3494 357.4m
R_VG1_248 MG2_X_806_Y_3494 MG1_X_806_Y_3494 357.4m
R_VG1_249 MG2_X_1344_Y_3494 MG1_X_1344_Y_3494 357.4m
R_VG1_250 MG2_X_1881_Y_3494 MG1_X_1881_Y_3494 357.4m
R_VG1_251 MG2_X_2419_Y_3494 MG1_X_2419_Y_3494 357.4m
R_VG1_252 MG2_X_2956_Y_3494 MG1_X_2956_Y_3494 357.4m
R_VG1_253 MG2_X_3494_Y_3494 MG1_X_3494_Y_3494 357.4m
R_VG1_254 MG2_X_4032_Y_3494 MG1_X_4032_Y_3494 357.4m
R_VG1_255 MG2_X_4569_Y_3494 MG1_X_4569_Y_3494 357.4m
R_VG1_256 MG2_X_5107_Y_3494 MG1_X_5107_Y_3494 357.4m
R_VG1_257 MG2_X_5644_Y_3494 MG1_X_5644_Y_3494 357.4m
R_VG1_258 MG2_X_6182_Y_3494 MG1_X_6182_Y_3494 357.4m
R_VG1_259 MG2_X_6720_Y_3494 MG1_X_6720_Y_3494 357.4m
R_VG1_260 MG2_X_7257_Y_3494 MG1_X_7257_Y_3494 357.4m
R_VG1_261 MG2_X_7795_Y_3494 MG1_X_7795_Y_3494 357.4m
R_VG1_262 MG2_X_8332_Y_3494 MG1_X_8332_Y_3494 357.4m
R_VG1_263 MG2_X_8870_Y_3494 MG1_X_8870_Y_3494 357.4m
R_VG1_264 MG2_X_9408_Y_3494 MG1_X_9408_Y_3494 357.4m
R_VG1_265 MG2_X_9945_Y_3494 MG1_X_9945_Y_3494 357.4m
R_VG1_266 MG2_X_0_Y_3763 MG1_X_0_Y_3763 357.4m
R_VG1_267 MG2_X_537_Y_3763 MG1_X_537_Y_3763 357.4m
R_VG1_268 MG2_X_1075_Y_3763 MG1_X_1075_Y_3763 357.4m
R_VG1_269 MG2_X_1612_Y_3763 MG1_X_1612_Y_3763 357.4m
R_VG1_270 MG2_X_2150_Y_3763 MG1_X_2150_Y_3763 357.4m
R_VG1_271 MG2_X_2688_Y_3763 MG1_X_2688_Y_3763 357.4m
R_VG1_272 MG2_X_3225_Y_3763 MG1_X_3225_Y_3763 357.4m
R_VG1_273 MG2_X_3763_Y_3763 MG1_X_3763_Y_3763 357.4m
R_VG1_274 MG2_X_4300_Y_3763 MG1_X_4300_Y_3763 357.4m
R_VG1_275 MG2_X_4838_Y_3763 MG1_X_4838_Y_3763 357.4m
R_VG1_276 MG2_X_5376_Y_3763 MG1_X_5376_Y_3763 357.4m
R_VG1_277 MG2_X_5913_Y_3763 MG1_X_5913_Y_3763 357.4m
R_VG1_278 MG2_X_6451_Y_3763 MG1_X_6451_Y_3763 357.4m
R_VG1_279 MG2_X_6988_Y_3763 MG1_X_6988_Y_3763 357.4m
R_VG1_280 MG2_X_7526_Y_3763 MG1_X_7526_Y_3763 357.4m
R_VG1_281 MG2_X_8064_Y_3763 MG1_X_8064_Y_3763 357.4m
R_VG1_282 MG2_X_8601_Y_3763 MG1_X_8601_Y_3763 357.4m
R_VG1_283 MG2_X_9139_Y_3763 MG1_X_9139_Y_3763 357.4m
R_VG1_284 MG2_X_9676_Y_3763 MG1_X_9676_Y_3763 357.4m
R_VG1_285 MG2_X_268_Y_4032 MG1_X_268_Y_4032 357.4m
R_VG1_286 MG2_X_806_Y_4032 MG1_X_806_Y_4032 357.4m
R_VG1_287 MG2_X_1344_Y_4032 MG1_X_1344_Y_4032 357.4m
R_VG1_288 MG2_X_1881_Y_4032 MG1_X_1881_Y_4032 357.4m
R_VG1_289 MG2_X_2419_Y_4032 MG1_X_2419_Y_4032 357.4m
R_VG1_290 MG2_X_2956_Y_4032 MG1_X_2956_Y_4032 357.4m
R_VG1_291 MG2_X_3494_Y_4032 MG1_X_3494_Y_4032 357.4m
R_VG1_292 MG2_X_4032_Y_4032 MG1_X_4032_Y_4032 357.4m
R_VG1_293 MG2_X_4569_Y_4032 MG1_X_4569_Y_4032 357.4m
R_VG1_294 MG2_X_5107_Y_4032 MG1_X_5107_Y_4032 357.4m
R_VG1_295 MG2_X_5644_Y_4032 MG1_X_5644_Y_4032 357.4m
R_VG1_296 MG2_X_6182_Y_4032 MG1_X_6182_Y_4032 357.4m
R_VG1_297 MG2_X_6720_Y_4032 MG1_X_6720_Y_4032 357.4m
R_VG1_298 MG2_X_7257_Y_4032 MG1_X_7257_Y_4032 357.4m
R_VG1_299 MG2_X_7795_Y_4032 MG1_X_7795_Y_4032 357.4m
R_VG1_300 MG2_X_8332_Y_4032 MG1_X_8332_Y_4032 357.4m
R_VG1_301 MG2_X_8870_Y_4032 MG1_X_8870_Y_4032 357.4m
R_VG1_302 MG2_X_9408_Y_4032 MG1_X_9408_Y_4032 357.4m
R_VG1_303 MG2_X_9945_Y_4032 MG1_X_9945_Y_4032 357.4m
R_VG1_304 MG2_X_0_Y_4300 MG1_X_0_Y_4300 357.4m
R_VG1_305 MG2_X_537_Y_4300 MG1_X_537_Y_4300 357.4m
R_VG1_306 MG2_X_1075_Y_4300 MG1_X_1075_Y_4300 357.4m
R_VG1_307 MG2_X_1612_Y_4300 MG1_X_1612_Y_4300 357.4m
R_VG1_308 MG2_X_2150_Y_4300 MG1_X_2150_Y_4300 357.4m
R_VG1_309 MG2_X_2688_Y_4300 MG1_X_2688_Y_4300 357.4m
R_VG1_310 MG2_X_3225_Y_4300 MG1_X_3225_Y_4300 357.4m
R_VG1_311 MG2_X_3763_Y_4300 MG1_X_3763_Y_4300 357.4m
R_VG1_312 MG2_X_4300_Y_4300 MG1_X_4300_Y_4300 357.4m
R_VG1_313 MG2_X_4838_Y_4300 MG1_X_4838_Y_4300 357.4m
R_VG1_314 MG2_X_5376_Y_4300 MG1_X_5376_Y_4300 357.4m
R_VG1_315 MG2_X_5913_Y_4300 MG1_X_5913_Y_4300 357.4m
R_VG1_316 MG2_X_6451_Y_4300 MG1_X_6451_Y_4300 357.4m
R_VG1_317 MG2_X_6988_Y_4300 MG1_X_6988_Y_4300 357.4m
R_VG1_318 MG2_X_7526_Y_4300 MG1_X_7526_Y_4300 357.4m
R_VG1_319 MG2_X_8064_Y_4300 MG1_X_8064_Y_4300 357.4m
R_VG1_320 MG2_X_8601_Y_4300 MG1_X_8601_Y_4300 357.4m
R_VG1_321 MG2_X_9139_Y_4300 MG1_X_9139_Y_4300 357.4m
R_VG1_322 MG2_X_9676_Y_4300 MG1_X_9676_Y_4300 357.4m
R_VG1_323 MG2_X_268_Y_4569 MG1_X_268_Y_4569 357.4m
R_VG1_324 MG2_X_806_Y_4569 MG1_X_806_Y_4569 357.4m
R_VG1_325 MG2_X_1344_Y_4569 MG1_X_1344_Y_4569 357.4m
R_VG1_326 MG2_X_1881_Y_4569 MG1_X_1881_Y_4569 357.4m
R_VG1_327 MG2_X_2419_Y_4569 MG1_X_2419_Y_4569 357.4m
R_VG1_328 MG2_X_2956_Y_4569 MG1_X_2956_Y_4569 357.4m
R_VG1_329 MG2_X_3494_Y_4569 MG1_X_3494_Y_4569 357.4m
R_VG1_330 MG2_X_4032_Y_4569 MG1_X_4032_Y_4569 357.4m
R_VG1_331 MG2_X_4569_Y_4569 MG1_X_4569_Y_4569 357.4m
R_VG1_332 MG2_X_5107_Y_4569 MG1_X_5107_Y_4569 357.4m
R_VG1_333 MG2_X_5644_Y_4569 MG1_X_5644_Y_4569 357.4m
R_VG1_334 MG2_X_6182_Y_4569 MG1_X_6182_Y_4569 357.4m
R_VG1_335 MG2_X_6720_Y_4569 MG1_X_6720_Y_4569 357.4m
R_VG1_336 MG2_X_7257_Y_4569 MG1_X_7257_Y_4569 357.4m
R_VG1_337 MG2_X_7795_Y_4569 MG1_X_7795_Y_4569 357.4m
R_VG1_338 MG2_X_8332_Y_4569 MG1_X_8332_Y_4569 357.4m
R_VG1_339 MG2_X_8870_Y_4569 MG1_X_8870_Y_4569 357.4m
R_VG1_340 MG2_X_9408_Y_4569 MG1_X_9408_Y_4569 357.4m
R_VG1_341 MG2_X_9945_Y_4569 MG1_X_9945_Y_4569 357.4m
R_VG1_342 MG2_X_0_Y_4838 MG1_X_0_Y_4838 357.4m
R_VG1_343 MG2_X_537_Y_4838 MG1_X_537_Y_4838 357.4m
R_VG1_344 MG2_X_1075_Y_4838 MG1_X_1075_Y_4838 357.4m
R_VG1_345 MG2_X_1612_Y_4838 MG1_X_1612_Y_4838 357.4m
R_VG1_346 MG2_X_2150_Y_4838 MG1_X_2150_Y_4838 357.4m
R_VG1_347 MG2_X_2688_Y_4838 MG1_X_2688_Y_4838 357.4m
R_VG1_348 MG2_X_3225_Y_4838 MG1_X_3225_Y_4838 357.4m
R_VG1_349 MG2_X_3763_Y_4838 MG1_X_3763_Y_4838 357.4m
R_VG1_350 MG2_X_4300_Y_4838 MG1_X_4300_Y_4838 357.4m
R_VG1_351 MG2_X_4838_Y_4838 MG1_X_4838_Y_4838 357.4m
R_VG1_352 MG2_X_5376_Y_4838 MG1_X_5376_Y_4838 357.4m
R_VG1_353 MG2_X_5913_Y_4838 MG1_X_5913_Y_4838 357.4m
R_VG1_354 MG2_X_6451_Y_4838 MG1_X_6451_Y_4838 357.4m
R_VG1_355 MG2_X_6988_Y_4838 MG1_X_6988_Y_4838 357.4m
R_VG1_356 MG2_X_7526_Y_4838 MG1_X_7526_Y_4838 357.4m
R_VG1_357 MG2_X_8064_Y_4838 MG1_X_8064_Y_4838 357.4m
R_VG1_358 MG2_X_8601_Y_4838 MG1_X_8601_Y_4838 357.4m
R_VG1_359 MG2_X_9139_Y_4838 MG1_X_9139_Y_4838 357.4m
R_VG1_360 MG2_X_9676_Y_4838 MG1_X_9676_Y_4838 357.4m
R_VG1_361 MG2_X_268_Y_5107 MG1_X_268_Y_5107 357.4m
R_VG1_362 MG2_X_806_Y_5107 MG1_X_806_Y_5107 357.4m
R_VG1_363 MG2_X_1344_Y_5107 MG1_X_1344_Y_5107 357.4m
R_VG1_364 MG2_X_1881_Y_5107 MG1_X_1881_Y_5107 357.4m
R_VG1_365 MG2_X_2419_Y_5107 MG1_X_2419_Y_5107 357.4m
R_VG1_366 MG2_X_2956_Y_5107 MG1_X_2956_Y_5107 357.4m
R_VG1_367 MG2_X_3494_Y_5107 MG1_X_3494_Y_5107 357.4m
R_VG1_368 MG2_X_4032_Y_5107 MG1_X_4032_Y_5107 357.4m
R_VG1_369 MG2_X_4569_Y_5107 MG1_X_4569_Y_5107 357.4m
R_VG1_370 MG2_X_5107_Y_5107 MG1_X_5107_Y_5107 357.4m
R_VG1_371 MG2_X_5644_Y_5107 MG1_X_5644_Y_5107 357.4m
R_VG1_372 MG2_X_6182_Y_5107 MG1_X_6182_Y_5107 357.4m
R_VG1_373 MG2_X_6720_Y_5107 MG1_X_6720_Y_5107 357.4m
R_VG1_374 MG2_X_7257_Y_5107 MG1_X_7257_Y_5107 357.4m
R_VG1_375 MG2_X_7795_Y_5107 MG1_X_7795_Y_5107 357.4m
R_VG1_376 MG2_X_8332_Y_5107 MG1_X_8332_Y_5107 357.4m
R_VG1_377 MG2_X_8870_Y_5107 MG1_X_8870_Y_5107 357.4m
R_VG1_378 MG2_X_9408_Y_5107 MG1_X_9408_Y_5107 357.4m
R_VG1_379 MG2_X_9945_Y_5107 MG1_X_9945_Y_5107 357.4m
R_VG1_380 MG2_X_0_Y_5376 MG1_X_0_Y_5376 357.4m
R_VG1_381 MG2_X_537_Y_5376 MG1_X_537_Y_5376 357.4m
R_VG1_382 MG2_X_1075_Y_5376 MG1_X_1075_Y_5376 357.4m
R_VG1_383 MG2_X_1612_Y_5376 MG1_X_1612_Y_5376 357.4m
R_VG1_384 MG2_X_2150_Y_5376 MG1_X_2150_Y_5376 357.4m
R_VG1_385 MG2_X_2688_Y_5376 MG1_X_2688_Y_5376 357.4m
R_VG1_386 MG2_X_3225_Y_5376 MG1_X_3225_Y_5376 357.4m
R_VG1_387 MG2_X_3763_Y_5376 MG1_X_3763_Y_5376 357.4m
R_VG1_388 MG2_X_4300_Y_5376 MG1_X_4300_Y_5376 357.4m
R_VG1_389 MG2_X_4838_Y_5376 MG1_X_4838_Y_5376 357.4m
R_VG1_390 MG2_X_5376_Y_5376 MG1_X_5376_Y_5376 357.4m
R_VG1_391 MG2_X_5913_Y_5376 MG1_X_5913_Y_5376 357.4m
R_VG1_392 MG2_X_6451_Y_5376 MG1_X_6451_Y_5376 357.4m
R_VG1_393 MG2_X_6988_Y_5376 MG1_X_6988_Y_5376 357.4m
R_VG1_394 MG2_X_7526_Y_5376 MG1_X_7526_Y_5376 357.4m
R_VG1_395 MG2_X_8064_Y_5376 MG1_X_8064_Y_5376 357.4m
R_VG1_396 MG2_X_8601_Y_5376 MG1_X_8601_Y_5376 357.4m
R_VG1_397 MG2_X_9139_Y_5376 MG1_X_9139_Y_5376 357.4m
R_VG1_398 MG2_X_9676_Y_5376 MG1_X_9676_Y_5376 357.4m
R_VG1_399 MG2_X_268_Y_5644 MG1_X_268_Y_5644 357.4m
R_VG1_400 MG2_X_806_Y_5644 MG1_X_806_Y_5644 357.4m
R_VG1_401 MG2_X_1344_Y_5644 MG1_X_1344_Y_5644 357.4m
R_VG1_402 MG2_X_1881_Y_5644 MG1_X_1881_Y_5644 357.4m
R_VG1_403 MG2_X_2419_Y_5644 MG1_X_2419_Y_5644 357.4m
R_VG1_404 MG2_X_2956_Y_5644 MG1_X_2956_Y_5644 357.4m
R_VG1_405 MG2_X_3494_Y_5644 MG1_X_3494_Y_5644 357.4m
R_VG1_406 MG2_X_4032_Y_5644 MG1_X_4032_Y_5644 357.4m
R_VG1_407 MG2_X_4569_Y_5644 MG1_X_4569_Y_5644 357.4m
R_VG1_408 MG2_X_5107_Y_5644 MG1_X_5107_Y_5644 357.4m
R_VG1_409 MG2_X_5644_Y_5644 MG1_X_5644_Y_5644 357.4m
R_VG1_410 MG2_X_6182_Y_5644 MG1_X_6182_Y_5644 357.4m
R_VG1_411 MG2_X_6720_Y_5644 MG1_X_6720_Y_5644 357.4m
R_VG1_412 MG2_X_7257_Y_5644 MG1_X_7257_Y_5644 357.4m
R_VG1_413 MG2_X_7795_Y_5644 MG1_X_7795_Y_5644 357.4m
R_VG1_414 MG2_X_8332_Y_5644 MG1_X_8332_Y_5644 357.4m
R_VG1_415 MG2_X_8870_Y_5644 MG1_X_8870_Y_5644 357.4m
R_VG1_416 MG2_X_9408_Y_5644 MG1_X_9408_Y_5644 357.4m
R_VG1_417 MG2_X_9945_Y_5644 MG1_X_9945_Y_5644 357.4m
R_VG1_418 MG2_X_0_Y_5913 MG1_X_0_Y_5913 357.4m
R_VG1_419 MG2_X_537_Y_5913 MG1_X_537_Y_5913 357.4m
R_VG1_420 MG2_X_1075_Y_5913 MG1_X_1075_Y_5913 357.4m
R_VG1_421 MG2_X_1612_Y_5913 MG1_X_1612_Y_5913 357.4m
R_VG1_422 MG2_X_2150_Y_5913 MG1_X_2150_Y_5913 357.4m
R_VG1_423 MG2_X_2688_Y_5913 MG1_X_2688_Y_5913 357.4m
R_VG1_424 MG2_X_3225_Y_5913 MG1_X_3225_Y_5913 357.4m
R_VG1_425 MG2_X_3763_Y_5913 MG1_X_3763_Y_5913 357.4m
R_VG1_426 MG2_X_4300_Y_5913 MG1_X_4300_Y_5913 357.4m
R_VG1_427 MG2_X_4838_Y_5913 MG1_X_4838_Y_5913 357.4m
R_VG1_428 MG2_X_5376_Y_5913 MG1_X_5376_Y_5913 357.4m
R_VG1_429 MG2_X_5913_Y_5913 MG1_X_5913_Y_5913 357.4m
R_VG1_430 MG2_X_6451_Y_5913 MG1_X_6451_Y_5913 357.4m
R_VG1_431 MG2_X_6988_Y_5913 MG1_X_6988_Y_5913 357.4m
R_VG1_432 MG2_X_7526_Y_5913 MG1_X_7526_Y_5913 357.4m
R_VG1_433 MG2_X_8064_Y_5913 MG1_X_8064_Y_5913 357.4m
R_VG1_434 MG2_X_8601_Y_5913 MG1_X_8601_Y_5913 357.4m
R_VG1_435 MG2_X_9139_Y_5913 MG1_X_9139_Y_5913 357.4m
R_VG1_436 MG2_X_9676_Y_5913 MG1_X_9676_Y_5913 357.4m
R_VG1_437 MG2_X_268_Y_6182 MG1_X_268_Y_6182 357.4m
R_VG1_438 MG2_X_806_Y_6182 MG1_X_806_Y_6182 357.4m
R_VG1_439 MG2_X_1344_Y_6182 MG1_X_1344_Y_6182 357.4m
R_VG1_440 MG2_X_1881_Y_6182 MG1_X_1881_Y_6182 357.4m
R_VG1_441 MG2_X_2419_Y_6182 MG1_X_2419_Y_6182 357.4m
R_VG1_442 MG2_X_2956_Y_6182 MG1_X_2956_Y_6182 357.4m
R_VG1_443 MG2_X_3494_Y_6182 MG1_X_3494_Y_6182 357.4m
R_VG1_444 MG2_X_4032_Y_6182 MG1_X_4032_Y_6182 357.4m
R_VG1_445 MG2_X_4569_Y_6182 MG1_X_4569_Y_6182 357.4m
R_VG1_446 MG2_X_5107_Y_6182 MG1_X_5107_Y_6182 357.4m
R_VG1_447 MG2_X_5644_Y_6182 MG1_X_5644_Y_6182 357.4m
R_VG1_448 MG2_X_6182_Y_6182 MG1_X_6182_Y_6182 357.4m
R_VG1_449 MG2_X_6720_Y_6182 MG1_X_6720_Y_6182 357.4m
R_VG1_450 MG2_X_7257_Y_6182 MG1_X_7257_Y_6182 357.4m
R_VG1_451 MG2_X_7795_Y_6182 MG1_X_7795_Y_6182 357.4m
R_VG1_452 MG2_X_8332_Y_6182 MG1_X_8332_Y_6182 357.4m
R_VG1_453 MG2_X_8870_Y_6182 MG1_X_8870_Y_6182 357.4m
R_VG1_454 MG2_X_9408_Y_6182 MG1_X_9408_Y_6182 357.4m
R_VG1_455 MG2_X_9945_Y_6182 MG1_X_9945_Y_6182 357.4m
R_VG1_456 MG2_X_0_Y_6451 MG1_X_0_Y_6451 357.4m
R_VG1_457 MG2_X_537_Y_6451 MG1_X_537_Y_6451 357.4m
R_VG1_458 MG2_X_1075_Y_6451 MG1_X_1075_Y_6451 357.4m
R_VG1_459 MG2_X_1612_Y_6451 MG1_X_1612_Y_6451 357.4m
R_VG1_460 MG2_X_2150_Y_6451 MG1_X_2150_Y_6451 357.4m
R_VG1_461 MG2_X_2688_Y_6451 MG1_X_2688_Y_6451 357.4m
R_VG1_462 MG2_X_3225_Y_6451 MG1_X_3225_Y_6451 357.4m
R_VG1_463 MG2_X_3763_Y_6451 MG1_X_3763_Y_6451 357.4m
R_VG1_464 MG2_X_4300_Y_6451 MG1_X_4300_Y_6451 357.4m
R_VG1_465 MG2_X_4838_Y_6451 MG1_X_4838_Y_6451 357.4m
R_VG1_466 MG2_X_5376_Y_6451 MG1_X_5376_Y_6451 357.4m
R_VG1_467 MG2_X_5913_Y_6451 MG1_X_5913_Y_6451 357.4m
R_VG1_468 MG2_X_6451_Y_6451 MG1_X_6451_Y_6451 357.4m
R_VG1_469 MG2_X_6988_Y_6451 MG1_X_6988_Y_6451 357.4m
R_VG1_470 MG2_X_7526_Y_6451 MG1_X_7526_Y_6451 357.4m
R_VG1_471 MG2_X_8064_Y_6451 MG1_X_8064_Y_6451 357.4m
R_VG1_472 MG2_X_8601_Y_6451 MG1_X_8601_Y_6451 357.4m
R_VG1_473 MG2_X_9139_Y_6451 MG1_X_9139_Y_6451 357.4m
R_VG1_474 MG2_X_9676_Y_6451 MG1_X_9676_Y_6451 357.4m
R_VG1_475 MG2_X_268_Y_6720 MG1_X_268_Y_6720 357.4m
R_VG1_476 MG2_X_806_Y_6720 MG1_X_806_Y_6720 357.4m
R_VG1_477 MG2_X_1344_Y_6720 MG1_X_1344_Y_6720 357.4m
R_VG1_478 MG2_X_1881_Y_6720 MG1_X_1881_Y_6720 357.4m
R_VG1_479 MG2_X_2419_Y_6720 MG1_X_2419_Y_6720 357.4m
R_VG1_480 MG2_X_2956_Y_6720 MG1_X_2956_Y_6720 357.4m
R_VG1_481 MG2_X_3494_Y_6720 MG1_X_3494_Y_6720 357.4m
R_VG1_482 MG2_X_4032_Y_6720 MG1_X_4032_Y_6720 357.4m
R_VG1_483 MG2_X_4569_Y_6720 MG1_X_4569_Y_6720 357.4m
R_VG1_484 MG2_X_5107_Y_6720 MG1_X_5107_Y_6720 357.4m
R_VG1_485 MG2_X_5644_Y_6720 MG1_X_5644_Y_6720 357.4m
R_VG1_486 MG2_X_6182_Y_6720 MG1_X_6182_Y_6720 357.4m
R_VG1_487 MG2_X_6720_Y_6720 MG1_X_6720_Y_6720 357.4m
R_VG1_488 MG2_X_7257_Y_6720 MG1_X_7257_Y_6720 357.4m
R_VG1_489 MG2_X_7795_Y_6720 MG1_X_7795_Y_6720 357.4m
R_VG1_490 MG2_X_8332_Y_6720 MG1_X_8332_Y_6720 357.4m
R_VG1_491 MG2_X_8870_Y_6720 MG1_X_8870_Y_6720 357.4m
R_VG1_492 MG2_X_9408_Y_6720 MG1_X_9408_Y_6720 357.4m
R_VG1_493 MG2_X_9945_Y_6720 MG1_X_9945_Y_6720 357.4m
R_VG1_494 MG2_X_0_Y_6988 MG1_X_0_Y_6988 357.4m
R_VG1_495 MG2_X_537_Y_6988 MG1_X_537_Y_6988 357.4m
R_VG1_496 MG2_X_1075_Y_6988 MG1_X_1075_Y_6988 357.4m
R_VG1_497 MG2_X_1612_Y_6988 MG1_X_1612_Y_6988 357.4m
R_VG1_498 MG2_X_2150_Y_6988 MG1_X_2150_Y_6988 357.4m
R_VG1_499 MG2_X_2688_Y_6988 MG1_X_2688_Y_6988 357.4m
R_VG1_500 MG2_X_3225_Y_6988 MG1_X_3225_Y_6988 357.4m
R_VG1_501 MG2_X_3763_Y_6988 MG1_X_3763_Y_6988 357.4m
R_VG1_502 MG2_X_4300_Y_6988 MG1_X_4300_Y_6988 357.4m
R_VG1_503 MG2_X_4838_Y_6988 MG1_X_4838_Y_6988 357.4m
R_VG1_504 MG2_X_5376_Y_6988 MG1_X_5376_Y_6988 357.4m
R_VG1_505 MG2_X_5913_Y_6988 MG1_X_5913_Y_6988 357.4m
R_VG1_506 MG2_X_6451_Y_6988 MG1_X_6451_Y_6988 357.4m
R_VG1_507 MG2_X_6988_Y_6988 MG1_X_6988_Y_6988 357.4m
R_VG1_508 MG2_X_7526_Y_6988 MG1_X_7526_Y_6988 357.4m
R_VG1_509 MG2_X_8064_Y_6988 MG1_X_8064_Y_6988 357.4m
R_VG1_510 MG2_X_8601_Y_6988 MG1_X_8601_Y_6988 357.4m
R_VG1_511 MG2_X_9139_Y_6988 MG1_X_9139_Y_6988 357.4m
R_VG1_512 MG2_X_9676_Y_6988 MG1_X_9676_Y_6988 357.4m
R_VG1_513 MG2_X_268_Y_7257 MG1_X_268_Y_7257 357.4m
R_VG1_514 MG2_X_806_Y_7257 MG1_X_806_Y_7257 357.4m
R_VG1_515 MG2_X_1344_Y_7257 MG1_X_1344_Y_7257 357.4m
R_VG1_516 MG2_X_1881_Y_7257 MG1_X_1881_Y_7257 357.4m
R_VG1_517 MG2_X_2419_Y_7257 MG1_X_2419_Y_7257 357.4m
R_VG1_518 MG2_X_2956_Y_7257 MG1_X_2956_Y_7257 357.4m
R_VG1_519 MG2_X_3494_Y_7257 MG1_X_3494_Y_7257 357.4m
R_VG1_520 MG2_X_4032_Y_7257 MG1_X_4032_Y_7257 357.4m
R_VG1_521 MG2_X_4569_Y_7257 MG1_X_4569_Y_7257 357.4m
R_VG1_522 MG2_X_5107_Y_7257 MG1_X_5107_Y_7257 357.4m
R_VG1_523 MG2_X_5644_Y_7257 MG1_X_5644_Y_7257 357.4m
R_VG1_524 MG2_X_6182_Y_7257 MG1_X_6182_Y_7257 357.4m
R_VG1_525 MG2_X_6720_Y_7257 MG1_X_6720_Y_7257 357.4m
R_VG1_526 MG2_X_7257_Y_7257 MG1_X_7257_Y_7257 357.4m
R_VG1_527 MG2_X_7795_Y_7257 MG1_X_7795_Y_7257 357.4m
R_VG1_528 MG2_X_8332_Y_7257 MG1_X_8332_Y_7257 357.4m
R_VG1_529 MG2_X_8870_Y_7257 MG1_X_8870_Y_7257 357.4m
R_VG1_530 MG2_X_9408_Y_7257 MG1_X_9408_Y_7257 357.4m
R_VG1_531 MG2_X_9945_Y_7257 MG1_X_9945_Y_7257 357.4m
R_VG1_532 MG2_X_0_Y_7526 MG1_X_0_Y_7526 357.4m
R_VG1_533 MG2_X_537_Y_7526 MG1_X_537_Y_7526 357.4m
R_VG1_534 MG2_X_1075_Y_7526 MG1_X_1075_Y_7526 357.4m
R_VG1_535 MG2_X_1612_Y_7526 MG1_X_1612_Y_7526 357.4m
R_VG1_536 MG2_X_2150_Y_7526 MG1_X_2150_Y_7526 357.4m
R_VG1_537 MG2_X_2688_Y_7526 MG1_X_2688_Y_7526 357.4m
R_VG1_538 MG2_X_3225_Y_7526 MG1_X_3225_Y_7526 357.4m
R_VG1_539 MG2_X_3763_Y_7526 MG1_X_3763_Y_7526 357.4m
R_VG1_540 MG2_X_4300_Y_7526 MG1_X_4300_Y_7526 357.4m
R_VG1_541 MG2_X_4838_Y_7526 MG1_X_4838_Y_7526 357.4m
R_VG1_542 MG2_X_5376_Y_7526 MG1_X_5376_Y_7526 357.4m
R_VG1_543 MG2_X_5913_Y_7526 MG1_X_5913_Y_7526 357.4m
R_VG1_544 MG2_X_6451_Y_7526 MG1_X_6451_Y_7526 357.4m
R_VG1_545 MG2_X_6988_Y_7526 MG1_X_6988_Y_7526 357.4m
R_VG1_546 MG2_X_7526_Y_7526 MG1_X_7526_Y_7526 357.4m
R_VG1_547 MG2_X_8064_Y_7526 MG1_X_8064_Y_7526 357.4m
R_VG1_548 MG2_X_8601_Y_7526 MG1_X_8601_Y_7526 357.4m
R_VG1_549 MG2_X_9139_Y_7526 MG1_X_9139_Y_7526 357.4m
R_VG1_550 MG2_X_9676_Y_7526 MG1_X_9676_Y_7526 357.4m
R_VG1_551 MG2_X_268_Y_7795 MG1_X_268_Y_7795 357.4m
R_VG1_552 MG2_X_806_Y_7795 MG1_X_806_Y_7795 357.4m
R_VG1_553 MG2_X_1344_Y_7795 MG1_X_1344_Y_7795 357.4m
R_VG1_554 MG2_X_1881_Y_7795 MG1_X_1881_Y_7795 357.4m
R_VG1_555 MG2_X_2419_Y_7795 MG1_X_2419_Y_7795 357.4m
R_VG1_556 MG2_X_2956_Y_7795 MG1_X_2956_Y_7795 357.4m
R_VG1_557 MG2_X_3494_Y_7795 MG1_X_3494_Y_7795 357.4m
R_VG1_558 MG2_X_4032_Y_7795 MG1_X_4032_Y_7795 357.4m
R_VG1_559 MG2_X_4569_Y_7795 MG1_X_4569_Y_7795 357.4m
R_VG1_560 MG2_X_5107_Y_7795 MG1_X_5107_Y_7795 357.4m
R_VG1_561 MG2_X_5644_Y_7795 MG1_X_5644_Y_7795 357.4m
R_VG1_562 MG2_X_6182_Y_7795 MG1_X_6182_Y_7795 357.4m
R_VG1_563 MG2_X_6720_Y_7795 MG1_X_6720_Y_7795 357.4m
R_VG1_564 MG2_X_7257_Y_7795 MG1_X_7257_Y_7795 357.4m
R_VG1_565 MG2_X_7795_Y_7795 MG1_X_7795_Y_7795 357.4m
R_VG1_566 MG2_X_8332_Y_7795 MG1_X_8332_Y_7795 357.4m
R_VG1_567 MG2_X_8870_Y_7795 MG1_X_8870_Y_7795 357.4m
R_VG1_568 MG2_X_9408_Y_7795 MG1_X_9408_Y_7795 357.4m
R_VG1_569 MG2_X_9945_Y_7795 MG1_X_9945_Y_7795 357.4m
R_VG1_570 MG2_X_0_Y_8064 MG1_X_0_Y_8064 357.4m
R_VG1_571 MG2_X_537_Y_8064 MG1_X_537_Y_8064 357.4m
R_VG1_572 MG2_X_1075_Y_8064 MG1_X_1075_Y_8064 357.4m
R_VG1_573 MG2_X_1612_Y_8064 MG1_X_1612_Y_8064 357.4m
R_VG1_574 MG2_X_2150_Y_8064 MG1_X_2150_Y_8064 357.4m
R_VG1_575 MG2_X_2688_Y_8064 MG1_X_2688_Y_8064 357.4m
R_VG1_576 MG2_X_3225_Y_8064 MG1_X_3225_Y_8064 357.4m
R_VG1_577 MG2_X_3763_Y_8064 MG1_X_3763_Y_8064 357.4m
R_VG1_578 MG2_X_4300_Y_8064 MG1_X_4300_Y_8064 357.4m
R_VG1_579 MG2_X_4838_Y_8064 MG1_X_4838_Y_8064 357.4m
R_VG1_580 MG2_X_5376_Y_8064 MG1_X_5376_Y_8064 357.4m
R_VG1_581 MG2_X_5913_Y_8064 MG1_X_5913_Y_8064 357.4m
R_VG1_582 MG2_X_6451_Y_8064 MG1_X_6451_Y_8064 357.4m
R_VG1_583 MG2_X_6988_Y_8064 MG1_X_6988_Y_8064 357.4m
R_VG1_584 MG2_X_7526_Y_8064 MG1_X_7526_Y_8064 357.4m
R_VG1_585 MG2_X_8064_Y_8064 MG1_X_8064_Y_8064 357.4m
R_VG1_586 MG2_X_8601_Y_8064 MG1_X_8601_Y_8064 357.4m
R_VG1_587 MG2_X_9139_Y_8064 MG1_X_9139_Y_8064 357.4m
R_VG1_588 MG2_X_9676_Y_8064 MG1_X_9676_Y_8064 357.4m
R_VG1_589 MG2_X_268_Y_8332 MG1_X_268_Y_8332 357.4m
R_VG1_590 MG2_X_806_Y_8332 MG1_X_806_Y_8332 357.4m
R_VG1_591 MG2_X_1344_Y_8332 MG1_X_1344_Y_8332 357.4m
R_VG1_592 MG2_X_1881_Y_8332 MG1_X_1881_Y_8332 357.4m
R_VG1_593 MG2_X_2419_Y_8332 MG1_X_2419_Y_8332 357.4m
R_VG1_594 MG2_X_2956_Y_8332 MG1_X_2956_Y_8332 357.4m
R_VG1_595 MG2_X_3494_Y_8332 MG1_X_3494_Y_8332 357.4m
R_VG1_596 MG2_X_4032_Y_8332 MG1_X_4032_Y_8332 357.4m
R_VG1_597 MG2_X_4569_Y_8332 MG1_X_4569_Y_8332 357.4m
R_VG1_598 MG2_X_5107_Y_8332 MG1_X_5107_Y_8332 357.4m
R_VG1_599 MG2_X_5644_Y_8332 MG1_X_5644_Y_8332 357.4m
R_VG1_600 MG2_X_6182_Y_8332 MG1_X_6182_Y_8332 357.4m
R_VG1_601 MG2_X_6720_Y_8332 MG1_X_6720_Y_8332 357.4m
R_VG1_602 MG2_X_7257_Y_8332 MG1_X_7257_Y_8332 357.4m
R_VG1_603 MG2_X_7795_Y_8332 MG1_X_7795_Y_8332 357.4m
R_VG1_604 MG2_X_8332_Y_8332 MG1_X_8332_Y_8332 357.4m
R_VG1_605 MG2_X_8870_Y_8332 MG1_X_8870_Y_8332 357.4m
R_VG1_606 MG2_X_9408_Y_8332 MG1_X_9408_Y_8332 357.4m
R_VG1_607 MG2_X_9945_Y_8332 MG1_X_9945_Y_8332 357.4m
R_VG1_608 MG2_X_0_Y_8601 MG1_X_0_Y_8601 357.4m
R_VG1_609 MG2_X_537_Y_8601 MG1_X_537_Y_8601 357.4m
R_VG1_610 MG2_X_1075_Y_8601 MG1_X_1075_Y_8601 357.4m
R_VG1_611 MG2_X_1612_Y_8601 MG1_X_1612_Y_8601 357.4m
R_VG1_612 MG2_X_2150_Y_8601 MG1_X_2150_Y_8601 357.4m
R_VG1_613 MG2_X_2688_Y_8601 MG1_X_2688_Y_8601 357.4m
R_VG1_614 MG2_X_3225_Y_8601 MG1_X_3225_Y_8601 357.4m
R_VG1_615 MG2_X_3763_Y_8601 MG1_X_3763_Y_8601 357.4m
R_VG1_616 MG2_X_4300_Y_8601 MG1_X_4300_Y_8601 357.4m
R_VG1_617 MG2_X_4838_Y_8601 MG1_X_4838_Y_8601 357.4m
R_VG1_618 MG2_X_5376_Y_8601 MG1_X_5376_Y_8601 357.4m
R_VG1_619 MG2_X_5913_Y_8601 MG1_X_5913_Y_8601 357.4m
R_VG1_620 MG2_X_6451_Y_8601 MG1_X_6451_Y_8601 357.4m
R_VG1_621 MG2_X_6988_Y_8601 MG1_X_6988_Y_8601 357.4m
R_VG1_622 MG2_X_7526_Y_8601 MG1_X_7526_Y_8601 357.4m
R_VG1_623 MG2_X_8064_Y_8601 MG1_X_8064_Y_8601 357.4m
R_VG1_624 MG2_X_8601_Y_8601 MG1_X_8601_Y_8601 357.4m
R_VG1_625 MG2_X_9139_Y_8601 MG1_X_9139_Y_8601 357.4m
R_VG1_626 MG2_X_9676_Y_8601 MG1_X_9676_Y_8601 357.4m
R_VG1_627 MG2_X_268_Y_8870 MG1_X_268_Y_8870 357.4m
R_VG1_628 MG2_X_806_Y_8870 MG1_X_806_Y_8870 357.4m
R_VG1_629 MG2_X_1344_Y_8870 MG1_X_1344_Y_8870 357.4m
R_VG1_630 MG2_X_1881_Y_8870 MG1_X_1881_Y_8870 357.4m
R_VG1_631 MG2_X_2419_Y_8870 MG1_X_2419_Y_8870 357.4m
R_VG1_632 MG2_X_2956_Y_8870 MG1_X_2956_Y_8870 357.4m
R_VG1_633 MG2_X_3494_Y_8870 MG1_X_3494_Y_8870 357.4m
R_VG1_634 MG2_X_4032_Y_8870 MG1_X_4032_Y_8870 357.4m
R_VG1_635 MG2_X_4569_Y_8870 MG1_X_4569_Y_8870 357.4m
R_VG1_636 MG2_X_5107_Y_8870 MG1_X_5107_Y_8870 357.4m
R_VG1_637 MG2_X_5644_Y_8870 MG1_X_5644_Y_8870 357.4m
R_VG1_638 MG2_X_6182_Y_8870 MG1_X_6182_Y_8870 357.4m
R_VG1_639 MG2_X_6720_Y_8870 MG1_X_6720_Y_8870 357.4m
R_VG1_640 MG2_X_7257_Y_8870 MG1_X_7257_Y_8870 357.4m
R_VG1_641 MG2_X_7795_Y_8870 MG1_X_7795_Y_8870 357.4m
R_VG1_642 MG2_X_8332_Y_8870 MG1_X_8332_Y_8870 357.4m
R_VG1_643 MG2_X_8870_Y_8870 MG1_X_8870_Y_8870 357.4m
R_VG1_644 MG2_X_9408_Y_8870 MG1_X_9408_Y_8870 357.4m
R_VG1_645 MG2_X_9945_Y_8870 MG1_X_9945_Y_8870 357.4m
R_VG1_646 MG2_X_0_Y_9139 MG1_X_0_Y_9139 357.4m
R_VG1_647 MG2_X_537_Y_9139 MG1_X_537_Y_9139 357.4m
R_VG1_648 MG2_X_1075_Y_9139 MG1_X_1075_Y_9139 357.4m
R_VG1_649 MG2_X_1612_Y_9139 MG1_X_1612_Y_9139 357.4m
R_VG1_650 MG2_X_2150_Y_9139 MG1_X_2150_Y_9139 357.4m
R_VG1_651 MG2_X_2688_Y_9139 MG1_X_2688_Y_9139 357.4m
R_VG1_652 MG2_X_3225_Y_9139 MG1_X_3225_Y_9139 357.4m
R_VG1_653 MG2_X_3763_Y_9139 MG1_X_3763_Y_9139 357.4m
R_VG1_654 MG2_X_4300_Y_9139 MG1_X_4300_Y_9139 357.4m
R_VG1_655 MG2_X_4838_Y_9139 MG1_X_4838_Y_9139 357.4m
R_VG1_656 MG2_X_5376_Y_9139 MG1_X_5376_Y_9139 357.4m
R_VG1_657 MG2_X_5913_Y_9139 MG1_X_5913_Y_9139 357.4m
R_VG1_658 MG2_X_6451_Y_9139 MG1_X_6451_Y_9139 357.4m
R_VG1_659 MG2_X_6988_Y_9139 MG1_X_6988_Y_9139 357.4m
R_VG1_660 MG2_X_7526_Y_9139 MG1_X_7526_Y_9139 357.4m
R_VG1_661 MG2_X_8064_Y_9139 MG1_X_8064_Y_9139 357.4m
R_VG1_662 MG2_X_8601_Y_9139 MG1_X_8601_Y_9139 357.4m
R_VG1_663 MG2_X_9139_Y_9139 MG1_X_9139_Y_9139 357.4m
R_VG1_664 MG2_X_9676_Y_9139 MG1_X_9676_Y_9139 357.4m
R_VG1_665 MG2_X_268_Y_9408 MG1_X_268_Y_9408 357.4m
R_VG1_666 MG2_X_806_Y_9408 MG1_X_806_Y_9408 357.4m
R_VG1_667 MG2_X_1344_Y_9408 MG1_X_1344_Y_9408 357.4m
R_VG1_668 MG2_X_1881_Y_9408 MG1_X_1881_Y_9408 357.4m
R_VG1_669 MG2_X_2419_Y_9408 MG1_X_2419_Y_9408 357.4m
R_VG1_670 MG2_X_2956_Y_9408 MG1_X_2956_Y_9408 357.4m
R_VG1_671 MG2_X_3494_Y_9408 MG1_X_3494_Y_9408 357.4m
R_VG1_672 MG2_X_4032_Y_9408 MG1_X_4032_Y_9408 357.4m
R_VG1_673 MG2_X_4569_Y_9408 MG1_X_4569_Y_9408 357.4m
R_VG1_674 MG2_X_5107_Y_9408 MG1_X_5107_Y_9408 357.4m
R_VG1_675 MG2_X_5644_Y_9408 MG1_X_5644_Y_9408 357.4m
R_VG1_676 MG2_X_6182_Y_9408 MG1_X_6182_Y_9408 357.4m
R_VG1_677 MG2_X_6720_Y_9408 MG1_X_6720_Y_9408 357.4m
R_VG1_678 MG2_X_7257_Y_9408 MG1_X_7257_Y_9408 357.4m
R_VG1_679 MG2_X_7795_Y_9408 MG1_X_7795_Y_9408 357.4m
R_VG1_680 MG2_X_8332_Y_9408 MG1_X_8332_Y_9408 357.4m
R_VG1_681 MG2_X_8870_Y_9408 MG1_X_8870_Y_9408 357.4m
R_VG1_682 MG2_X_9408_Y_9408 MG1_X_9408_Y_9408 357.4m
R_VG1_683 MG2_X_9945_Y_9408 MG1_X_9945_Y_9408 357.4m
R_VG1_684 MG2_X_0_Y_9676 MG1_X_0_Y_9676 357.4m
R_VG1_685 MG2_X_537_Y_9676 MG1_X_537_Y_9676 357.4m
R_VG1_686 MG2_X_1075_Y_9676 MG1_X_1075_Y_9676 357.4m
R_VG1_687 MG2_X_1612_Y_9676 MG1_X_1612_Y_9676 357.4m
R_VG1_688 MG2_X_2150_Y_9676 MG1_X_2150_Y_9676 357.4m
R_VG1_689 MG2_X_2688_Y_9676 MG1_X_2688_Y_9676 357.4m
R_VG1_690 MG2_X_3225_Y_9676 MG1_X_3225_Y_9676 357.4m
R_VG1_691 MG2_X_3763_Y_9676 MG1_X_3763_Y_9676 357.4m
R_VG1_692 MG2_X_4300_Y_9676 MG1_X_4300_Y_9676 357.4m
R_VG1_693 MG2_X_4838_Y_9676 MG1_X_4838_Y_9676 357.4m
R_VG1_694 MG2_X_5376_Y_9676 MG1_X_5376_Y_9676 357.4m
R_VG1_695 MG2_X_5913_Y_9676 MG1_X_5913_Y_9676 357.4m
R_VG1_696 MG2_X_6451_Y_9676 MG1_X_6451_Y_9676 357.4m
R_VG1_697 MG2_X_6988_Y_9676 MG1_X_6988_Y_9676 357.4m
R_VG1_698 MG2_X_7526_Y_9676 MG1_X_7526_Y_9676 357.4m
R_VG1_699 MG2_X_8064_Y_9676 MG1_X_8064_Y_9676 357.4m
R_VG1_700 MG2_X_8601_Y_9676 MG1_X_8601_Y_9676 357.4m
R_VG1_701 MG2_X_9139_Y_9676 MG1_X_9139_Y_9676 357.4m
R_VG1_702 MG2_X_9676_Y_9676 MG1_X_9676_Y_9676 357.4m
R_VG1_703 MG2_X_268_Y_9945 MG1_X_268_Y_9945 357.4m
R_VG1_704 MG2_X_806_Y_9945 MG1_X_806_Y_9945 357.4m
R_VG1_705 MG2_X_1344_Y_9945 MG1_X_1344_Y_9945 357.4m
R_VG1_706 MG2_X_1881_Y_9945 MG1_X_1881_Y_9945 357.4m
R_VG1_707 MG2_X_2419_Y_9945 MG1_X_2419_Y_9945 357.4m
R_VG1_708 MG2_X_2956_Y_9945 MG1_X_2956_Y_9945 357.4m
R_VG1_709 MG2_X_3494_Y_9945 MG1_X_3494_Y_9945 357.4m
R_VG1_710 MG2_X_4032_Y_9945 MG1_X_4032_Y_9945 357.4m
R_VG1_711 MG2_X_4569_Y_9945 MG1_X_4569_Y_9945 357.4m
R_VG1_712 MG2_X_5107_Y_9945 MG1_X_5107_Y_9945 357.4m
R_VG1_713 MG2_X_5644_Y_9945 MG1_X_5644_Y_9945 357.4m
R_VG1_714 MG2_X_6182_Y_9945 MG1_X_6182_Y_9945 357.4m
R_VG1_715 MG2_X_6720_Y_9945 MG1_X_6720_Y_9945 357.4m
R_VG1_716 MG2_X_7257_Y_9945 MG1_X_7257_Y_9945 357.4m
R_VG1_717 MG2_X_7795_Y_9945 MG1_X_7795_Y_9945 357.4m
R_VG1_718 MG2_X_8332_Y_9945 MG1_X_8332_Y_9945 357.4m
R_VG1_719 MG2_X_8870_Y_9945 MG1_X_8870_Y_9945 357.4m
R_VG1_720 MG2_X_9408_Y_9945 MG1_X_9408_Y_9945 357.4m
R_VG1_721 MG2_X_9945_Y_9945 MG1_X_9945_Y_9945 357.4m
R_VSMG5_722 MG1_X_0_Y_0 MSMG5_X_0_Y_0 714.7m
R_VSMG5_723 MG1_X_0_Y_560 MSMG5_X_0_Y_560 714.7m
R_VSMG5_724 MG1_X_0_Y_1120 MSMG5_X_0_Y_1120 714.7m
R_VSMG5_725 MG1_X_0_Y_1680 MSMG5_X_0_Y_1680 714.7m
R_VSMG5_726 MG1_X_0_Y_2240 MSMG5_X_0_Y_2240 714.7m
R_VSMG5_727 MG1_X_0_Y_2800 MSMG5_X_0_Y_2800 714.7m
R_VSMG5_728 MG1_X_0_Y_3360 MSMG5_X_0_Y_3360 714.7m
R_VSMG5_729 MG1_X_0_Y_3920 MSMG5_X_0_Y_3920 714.7m
R_VSMG5_730 MG1_X_0_Y_4480 MSMG5_X_0_Y_4480 714.7m
R_VSMG5_731 MG1_X_0_Y_5040 MSMG5_X_0_Y_5040 714.7m
R_VSMG5_732 MG1_X_0_Y_5600 MSMG5_X_0_Y_5600 714.7m
R_VSMG5_733 MG1_X_0_Y_6160 MSMG5_X_0_Y_6160 714.7m
R_VSMG5_734 MG1_X_0_Y_6720 MSMG5_X_0_Y_6720 714.7m
R_VSMG5_735 MG1_X_0_Y_7280 MSMG5_X_0_Y_7280 714.7m
R_VSMG5_736 MG1_X_0_Y_7840 MSMG5_X_0_Y_7840 714.7m
R_VSMG5_737 MG1_X_0_Y_8400 MSMG5_X_0_Y_8400 714.7m
R_VSMG5_738 MG1_X_0_Y_8960 MSMG5_X_0_Y_8960 714.7m
R_VSMG5_739 MG1_X_0_Y_9520 MSMG5_X_0_Y_9520 714.7m
R_VSMG5_740 MG1_X_268_Y_0 MSMG5_X_268_Y_0 714.7m
R_VSMG5_741 MG1_X_268_Y_560 MSMG5_X_268_Y_560 714.7m
R_VSMG5_742 MG1_X_268_Y_1120 MSMG5_X_268_Y_1120 714.7m
R_VSMG5_743 MG1_X_268_Y_1680 MSMG5_X_268_Y_1680 714.7m
R_VSMG5_744 MG1_X_268_Y_2240 MSMG5_X_268_Y_2240 714.7m
R_VSMG5_745 MG1_X_268_Y_2800 MSMG5_X_268_Y_2800 714.7m
R_VSMG5_746 MG1_X_268_Y_3360 MSMG5_X_268_Y_3360 714.7m
R_VSMG5_747 MG1_X_268_Y_3920 MSMG5_X_268_Y_3920 714.7m
R_VSMG5_748 MG1_X_268_Y_4480 MSMG5_X_268_Y_4480 714.7m
R_VSMG5_749 MG1_X_268_Y_5040 MSMG5_X_268_Y_5040 714.7m
R_VSMG5_750 MG1_X_268_Y_5600 MSMG5_X_268_Y_5600 714.7m
R_VSMG5_751 MG1_X_268_Y_6160 MSMG5_X_268_Y_6160 714.7m
R_VSMG5_752 MG1_X_268_Y_6720 MSMG5_X_268_Y_6720 714.7m
R_VSMG5_753 MG1_X_268_Y_7280 MSMG5_X_268_Y_7280 714.7m
R_VSMG5_754 MG1_X_268_Y_7840 MSMG5_X_268_Y_7840 714.7m
R_VSMG5_755 MG1_X_268_Y_8400 MSMG5_X_268_Y_8400 714.7m
R_VSMG5_756 MG1_X_268_Y_8960 MSMG5_X_268_Y_8960 714.7m
R_VSMG5_757 MG1_X_268_Y_9520 MSMG5_X_268_Y_9520 714.7m
R_VSMG5_758 MG1_X_537_Y_0 MSMG5_X_537_Y_0 714.7m
R_VSMG5_759 MG1_X_537_Y_560 MSMG5_X_537_Y_560 714.7m
R_VSMG5_760 MG1_X_537_Y_1120 MSMG5_X_537_Y_1120 714.7m
R_VSMG5_761 MG1_X_537_Y_1680 MSMG5_X_537_Y_1680 714.7m
R_VSMG5_762 MG1_X_537_Y_2240 MSMG5_X_537_Y_2240 714.7m
R_VSMG5_763 MG1_X_537_Y_2800 MSMG5_X_537_Y_2800 714.7m
R_VSMG5_764 MG1_X_537_Y_3360 MSMG5_X_537_Y_3360 714.7m
R_VSMG5_765 MG1_X_537_Y_3920 MSMG5_X_537_Y_3920 714.7m
R_VSMG5_766 MG1_X_537_Y_4480 MSMG5_X_537_Y_4480 714.7m
R_VSMG5_767 MG1_X_537_Y_5040 MSMG5_X_537_Y_5040 714.7m
R_VSMG5_768 MG1_X_537_Y_5600 MSMG5_X_537_Y_5600 714.7m
R_VSMG5_769 MG1_X_537_Y_6160 MSMG5_X_537_Y_6160 714.7m
R_VSMG5_770 MG1_X_537_Y_6720 MSMG5_X_537_Y_6720 714.7m
R_VSMG5_771 MG1_X_537_Y_7280 MSMG5_X_537_Y_7280 714.7m
R_VSMG5_772 MG1_X_537_Y_7840 MSMG5_X_537_Y_7840 714.7m
R_VSMG5_773 MG1_X_537_Y_8400 MSMG5_X_537_Y_8400 714.7m
R_VSMG5_774 MG1_X_537_Y_8960 MSMG5_X_537_Y_8960 714.7m
R_VSMG5_775 MG1_X_537_Y_9520 MSMG5_X_537_Y_9520 714.7m
R_VSMG5_776 MG1_X_806_Y_0 MSMG5_X_806_Y_0 714.7m
R_VSMG5_777 MG1_X_806_Y_560 MSMG5_X_806_Y_560 714.7m
R_VSMG5_778 MG1_X_806_Y_1120 MSMG5_X_806_Y_1120 714.7m
R_VSMG5_779 MG1_X_806_Y_1680 MSMG5_X_806_Y_1680 714.7m
R_VSMG5_780 MG1_X_806_Y_2240 MSMG5_X_806_Y_2240 714.7m
R_VSMG5_781 MG1_X_806_Y_2800 MSMG5_X_806_Y_2800 714.7m
R_VSMG5_782 MG1_X_806_Y_3360 MSMG5_X_806_Y_3360 714.7m
R_VSMG5_783 MG1_X_806_Y_3920 MSMG5_X_806_Y_3920 714.7m
R_VSMG5_784 MG1_X_806_Y_4480 MSMG5_X_806_Y_4480 714.7m
R_VSMG5_785 MG1_X_806_Y_5040 MSMG5_X_806_Y_5040 714.7m
R_VSMG5_786 MG1_X_806_Y_5600 MSMG5_X_806_Y_5600 714.7m
R_VSMG5_787 MG1_X_806_Y_6160 MSMG5_X_806_Y_6160 714.7m
R_VSMG5_788 MG1_X_806_Y_6720 MSMG5_X_806_Y_6720 714.7m
R_VSMG5_789 MG1_X_806_Y_7280 MSMG5_X_806_Y_7280 714.7m
R_VSMG5_790 MG1_X_806_Y_7840 MSMG5_X_806_Y_7840 714.7m
R_VSMG5_791 MG1_X_806_Y_8400 MSMG5_X_806_Y_8400 714.7m
R_VSMG5_792 MG1_X_806_Y_8960 MSMG5_X_806_Y_8960 714.7m
R_VSMG5_793 MG1_X_806_Y_9520 MSMG5_X_806_Y_9520 714.7m
R_VSMG5_794 MG1_X_1075_Y_0 MSMG5_X_1075_Y_0 714.7m
R_VSMG5_795 MG1_X_1075_Y_560 MSMG5_X_1075_Y_560 714.7m
R_VSMG5_796 MG1_X_1075_Y_1120 MSMG5_X_1075_Y_1120 714.7m
R_VSMG5_797 MG1_X_1075_Y_1680 MSMG5_X_1075_Y_1680 714.7m
R_VSMG5_798 MG1_X_1075_Y_2240 MSMG5_X_1075_Y_2240 714.7m
R_VSMG5_799 MG1_X_1075_Y_2800 MSMG5_X_1075_Y_2800 714.7m
R_VSMG5_800 MG1_X_1075_Y_3360 MSMG5_X_1075_Y_3360 714.7m
R_VSMG5_801 MG1_X_1075_Y_3920 MSMG5_X_1075_Y_3920 714.7m
R_VSMG5_802 MG1_X_1075_Y_4480 MSMG5_X_1075_Y_4480 714.7m
R_VSMG5_803 MG1_X_1075_Y_5040 MSMG5_X_1075_Y_5040 714.7m
R_VSMG5_804 MG1_X_1075_Y_5600 MSMG5_X_1075_Y_5600 714.7m
R_VSMG5_805 MG1_X_1075_Y_6160 MSMG5_X_1075_Y_6160 714.7m
R_VSMG5_806 MG1_X_1075_Y_6720 MSMG5_X_1075_Y_6720 714.7m
R_VSMG5_807 MG1_X_1075_Y_7280 MSMG5_X_1075_Y_7280 714.7m
R_VSMG5_808 MG1_X_1075_Y_7840 MSMG5_X_1075_Y_7840 714.7m
R_VSMG5_809 MG1_X_1075_Y_8400 MSMG5_X_1075_Y_8400 714.7m
R_VSMG5_810 MG1_X_1075_Y_8960 MSMG5_X_1075_Y_8960 714.7m
R_VSMG5_811 MG1_X_1075_Y_9520 MSMG5_X_1075_Y_9520 714.7m
R_VSMG5_812 MG1_X_1344_Y_0 MSMG5_X_1344_Y_0 714.7m
R_VSMG5_813 MG1_X_1344_Y_560 MSMG5_X_1344_Y_560 714.7m
R_VSMG5_814 MG1_X_1344_Y_1120 MSMG5_X_1344_Y_1120 714.7m
R_VSMG5_815 MG1_X_1344_Y_1680 MSMG5_X_1344_Y_1680 714.7m
R_VSMG5_816 MG1_X_1344_Y_2240 MSMG5_X_1344_Y_2240 714.7m
R_VSMG5_817 MG1_X_1344_Y_2800 MSMG5_X_1344_Y_2800 714.7m
R_VSMG5_818 MG1_X_1344_Y_3360 MSMG5_X_1344_Y_3360 714.7m
R_VSMG5_819 MG1_X_1344_Y_3920 MSMG5_X_1344_Y_3920 714.7m
R_VSMG5_820 MG1_X_1344_Y_4480 MSMG5_X_1344_Y_4480 714.7m
R_VSMG5_821 MG1_X_1344_Y_5040 MSMG5_X_1344_Y_5040 714.7m
R_VSMG5_822 MG1_X_1344_Y_5600 MSMG5_X_1344_Y_5600 714.7m
R_VSMG5_823 MG1_X_1344_Y_6160 MSMG5_X_1344_Y_6160 714.7m
R_VSMG5_824 MG1_X_1344_Y_6720 MSMG5_X_1344_Y_6720 714.7m
R_VSMG5_825 MG1_X_1344_Y_7280 MSMG5_X_1344_Y_7280 714.7m
R_VSMG5_826 MG1_X_1344_Y_7840 MSMG5_X_1344_Y_7840 714.7m
R_VSMG5_827 MG1_X_1344_Y_8400 MSMG5_X_1344_Y_8400 714.7m
R_VSMG5_828 MG1_X_1344_Y_8960 MSMG5_X_1344_Y_8960 714.7m
R_VSMG5_829 MG1_X_1344_Y_9520 MSMG5_X_1344_Y_9520 714.7m
R_VSMG5_830 MG1_X_1612_Y_0 MSMG5_X_1612_Y_0 714.7m
R_VSMG5_831 MG1_X_1612_Y_560 MSMG5_X_1612_Y_560 714.7m
R_VSMG5_832 MG1_X_1612_Y_1120 MSMG5_X_1612_Y_1120 714.7m
R_VSMG5_833 MG1_X_1612_Y_1680 MSMG5_X_1612_Y_1680 714.7m
R_VSMG5_834 MG1_X_1612_Y_2240 MSMG5_X_1612_Y_2240 714.7m
R_VSMG5_835 MG1_X_1612_Y_2800 MSMG5_X_1612_Y_2800 714.7m
R_VSMG5_836 MG1_X_1612_Y_3360 MSMG5_X_1612_Y_3360 714.7m
R_VSMG5_837 MG1_X_1612_Y_3920 MSMG5_X_1612_Y_3920 714.7m
R_VSMG5_838 MG1_X_1612_Y_4480 MSMG5_X_1612_Y_4480 714.7m
R_VSMG5_839 MG1_X_1612_Y_5040 MSMG5_X_1612_Y_5040 714.7m
R_VSMG5_840 MG1_X_1612_Y_5600 MSMG5_X_1612_Y_5600 714.7m
R_VSMG5_841 MG1_X_1612_Y_6160 MSMG5_X_1612_Y_6160 714.7m
R_VSMG5_842 MG1_X_1612_Y_6720 MSMG5_X_1612_Y_6720 714.7m
R_VSMG5_843 MG1_X_1612_Y_7280 MSMG5_X_1612_Y_7280 714.7m
R_VSMG5_844 MG1_X_1612_Y_7840 MSMG5_X_1612_Y_7840 714.7m
R_VSMG5_845 MG1_X_1612_Y_8400 MSMG5_X_1612_Y_8400 714.7m
R_VSMG5_846 MG1_X_1612_Y_8960 MSMG5_X_1612_Y_8960 714.7m
R_VSMG5_847 MG1_X_1612_Y_9520 MSMG5_X_1612_Y_9520 714.7m
R_VSMG5_848 MG1_X_1881_Y_0 MSMG5_X_1881_Y_0 714.7m
R_VSMG5_849 MG1_X_1881_Y_560 MSMG5_X_1881_Y_560 714.7m
R_VSMG5_850 MG1_X_1881_Y_1120 MSMG5_X_1881_Y_1120 714.7m
R_VSMG5_851 MG1_X_1881_Y_1680 MSMG5_X_1881_Y_1680 714.7m
R_VSMG5_852 MG1_X_1881_Y_2240 MSMG5_X_1881_Y_2240 714.7m
R_VSMG5_853 MG1_X_1881_Y_2800 MSMG5_X_1881_Y_2800 714.7m
R_VSMG5_854 MG1_X_1881_Y_3360 MSMG5_X_1881_Y_3360 714.7m
R_VSMG5_855 MG1_X_1881_Y_3920 MSMG5_X_1881_Y_3920 714.7m
R_VSMG5_856 MG1_X_1881_Y_4480 MSMG5_X_1881_Y_4480 714.7m
R_VSMG5_857 MG1_X_1881_Y_5040 MSMG5_X_1881_Y_5040 714.7m
R_VSMG5_858 MG1_X_1881_Y_5600 MSMG5_X_1881_Y_5600 714.7m
R_VSMG5_859 MG1_X_1881_Y_6160 MSMG5_X_1881_Y_6160 714.7m
R_VSMG5_860 MG1_X_1881_Y_6720 MSMG5_X_1881_Y_6720 714.7m
R_VSMG5_861 MG1_X_1881_Y_7280 MSMG5_X_1881_Y_7280 714.7m
R_VSMG5_862 MG1_X_1881_Y_7840 MSMG5_X_1881_Y_7840 714.7m
R_VSMG5_863 MG1_X_1881_Y_8400 MSMG5_X_1881_Y_8400 714.7m
R_VSMG5_864 MG1_X_1881_Y_8960 MSMG5_X_1881_Y_8960 714.7m
R_VSMG5_865 MG1_X_1881_Y_9520 MSMG5_X_1881_Y_9520 714.7m
R_VSMG5_866 MG1_X_2150_Y_0 MSMG5_X_2150_Y_0 714.7m
R_VSMG5_867 MG1_X_2150_Y_560 MSMG5_X_2150_Y_560 714.7m
R_VSMG5_868 MG1_X_2150_Y_1120 MSMG5_X_2150_Y_1120 714.7m
R_VSMG5_869 MG1_X_2150_Y_1680 MSMG5_X_2150_Y_1680 714.7m
R_VSMG5_870 MG1_X_2150_Y_2240 MSMG5_X_2150_Y_2240 714.7m
R_VSMG5_871 MG1_X_2150_Y_2800 MSMG5_X_2150_Y_2800 714.7m
R_VSMG5_872 MG1_X_2150_Y_3360 MSMG5_X_2150_Y_3360 714.7m
R_VSMG5_873 MG1_X_2150_Y_3920 MSMG5_X_2150_Y_3920 714.7m
R_VSMG5_874 MG1_X_2150_Y_4480 MSMG5_X_2150_Y_4480 714.7m
R_VSMG5_875 MG1_X_2150_Y_5040 MSMG5_X_2150_Y_5040 714.7m
R_VSMG5_876 MG1_X_2150_Y_5600 MSMG5_X_2150_Y_5600 714.7m
R_VSMG5_877 MG1_X_2150_Y_6160 MSMG5_X_2150_Y_6160 714.7m
R_VSMG5_878 MG1_X_2150_Y_6720 MSMG5_X_2150_Y_6720 714.7m
R_VSMG5_879 MG1_X_2150_Y_7280 MSMG5_X_2150_Y_7280 714.7m
R_VSMG5_880 MG1_X_2150_Y_7840 MSMG5_X_2150_Y_7840 714.7m
R_VSMG5_881 MG1_X_2150_Y_8400 MSMG5_X_2150_Y_8400 714.7m
R_VSMG5_882 MG1_X_2150_Y_8960 MSMG5_X_2150_Y_8960 714.7m
R_VSMG5_883 MG1_X_2150_Y_9520 MSMG5_X_2150_Y_9520 714.7m
R_VSMG5_884 MG1_X_2419_Y_0 MSMG5_X_2419_Y_0 714.7m
R_VSMG5_885 MG1_X_2419_Y_560 MSMG5_X_2419_Y_560 714.7m
R_VSMG5_886 MG1_X_2419_Y_1120 MSMG5_X_2419_Y_1120 714.7m
R_VSMG5_887 MG1_X_2419_Y_1680 MSMG5_X_2419_Y_1680 714.7m
R_VSMG5_888 MG1_X_2419_Y_2240 MSMG5_X_2419_Y_2240 714.7m
R_VSMG5_889 MG1_X_2419_Y_2800 MSMG5_X_2419_Y_2800 714.7m
R_VSMG5_890 MG1_X_2419_Y_3360 MSMG5_X_2419_Y_3360 714.7m
R_VSMG5_891 MG1_X_2419_Y_3920 MSMG5_X_2419_Y_3920 714.7m
R_VSMG5_892 MG1_X_2419_Y_4480 MSMG5_X_2419_Y_4480 714.7m
R_VSMG5_893 MG1_X_2419_Y_5040 MSMG5_X_2419_Y_5040 714.7m
R_VSMG5_894 MG1_X_2419_Y_5600 MSMG5_X_2419_Y_5600 714.7m
R_VSMG5_895 MG1_X_2419_Y_6160 MSMG5_X_2419_Y_6160 714.7m
R_VSMG5_896 MG1_X_2419_Y_6720 MSMG5_X_2419_Y_6720 714.7m
R_VSMG5_897 MG1_X_2419_Y_7280 MSMG5_X_2419_Y_7280 714.7m
R_VSMG5_898 MG1_X_2419_Y_7840 MSMG5_X_2419_Y_7840 714.7m
R_VSMG5_899 MG1_X_2419_Y_8400 MSMG5_X_2419_Y_8400 714.7m
R_VSMG5_900 MG1_X_2419_Y_8960 MSMG5_X_2419_Y_8960 714.7m
R_VSMG5_901 MG1_X_2419_Y_9520 MSMG5_X_2419_Y_9520 714.7m
R_VSMG5_902 MG1_X_2688_Y_0 MSMG5_X_2688_Y_0 714.7m
R_VSMG5_903 MG1_X_2688_Y_560 MSMG5_X_2688_Y_560 714.7m
R_VSMG5_904 MG1_X_2688_Y_1120 MSMG5_X_2688_Y_1120 714.7m
R_VSMG5_905 MG1_X_2688_Y_1680 MSMG5_X_2688_Y_1680 714.7m
R_VSMG5_906 MG1_X_2688_Y_2240 MSMG5_X_2688_Y_2240 714.7m
R_VSMG5_907 MG1_X_2688_Y_2800 MSMG5_X_2688_Y_2800 714.7m
R_VSMG5_908 MG1_X_2688_Y_3360 MSMG5_X_2688_Y_3360 714.7m
R_VSMG5_909 MG1_X_2688_Y_3920 MSMG5_X_2688_Y_3920 714.7m
R_VSMG5_910 MG1_X_2688_Y_4480 MSMG5_X_2688_Y_4480 714.7m
R_VSMG5_911 MG1_X_2688_Y_5040 MSMG5_X_2688_Y_5040 714.7m
R_VSMG5_912 MG1_X_2688_Y_5600 MSMG5_X_2688_Y_5600 714.7m
R_VSMG5_913 MG1_X_2688_Y_6160 MSMG5_X_2688_Y_6160 714.7m
R_VSMG5_914 MG1_X_2688_Y_6720 MSMG5_X_2688_Y_6720 714.7m
R_VSMG5_915 MG1_X_2688_Y_7280 MSMG5_X_2688_Y_7280 714.7m
R_VSMG5_916 MG1_X_2688_Y_7840 MSMG5_X_2688_Y_7840 714.7m
R_VSMG5_917 MG1_X_2688_Y_8400 MSMG5_X_2688_Y_8400 714.7m
R_VSMG5_918 MG1_X_2688_Y_8960 MSMG5_X_2688_Y_8960 714.7m
R_VSMG5_919 MG1_X_2688_Y_9520 MSMG5_X_2688_Y_9520 714.7m
R_VSMG5_920 MG1_X_2956_Y_0 MSMG5_X_2956_Y_0 714.7m
R_VSMG5_921 MG1_X_2956_Y_560 MSMG5_X_2956_Y_560 714.7m
R_VSMG5_922 MG1_X_2956_Y_1120 MSMG5_X_2956_Y_1120 714.7m
R_VSMG5_923 MG1_X_2956_Y_1680 MSMG5_X_2956_Y_1680 714.7m
R_VSMG5_924 MG1_X_2956_Y_2240 MSMG5_X_2956_Y_2240 714.7m
R_VSMG5_925 MG1_X_2956_Y_2800 MSMG5_X_2956_Y_2800 714.7m
R_VSMG5_926 MG1_X_2956_Y_3360 MSMG5_X_2956_Y_3360 714.7m
R_VSMG5_927 MG1_X_2956_Y_3920 MSMG5_X_2956_Y_3920 714.7m
R_VSMG5_928 MG1_X_2956_Y_4480 MSMG5_X_2956_Y_4480 714.7m
R_VSMG5_929 MG1_X_2956_Y_5040 MSMG5_X_2956_Y_5040 714.7m
R_VSMG5_930 MG1_X_2956_Y_5600 MSMG5_X_2956_Y_5600 714.7m
R_VSMG5_931 MG1_X_2956_Y_6160 MSMG5_X_2956_Y_6160 714.7m
R_VSMG5_932 MG1_X_2956_Y_6720 MSMG5_X_2956_Y_6720 714.7m
R_VSMG5_933 MG1_X_2956_Y_7280 MSMG5_X_2956_Y_7280 714.7m
R_VSMG5_934 MG1_X_2956_Y_7840 MSMG5_X_2956_Y_7840 714.7m
R_VSMG5_935 MG1_X_2956_Y_8400 MSMG5_X_2956_Y_8400 714.7m
R_VSMG5_936 MG1_X_2956_Y_8960 MSMG5_X_2956_Y_8960 714.7m
R_VSMG5_937 MG1_X_2956_Y_9520 MSMG5_X_2956_Y_9520 714.7m
R_VSMG5_938 MG1_X_3225_Y_0 MSMG5_X_3225_Y_0 714.7m
R_VSMG5_939 MG1_X_3225_Y_560 MSMG5_X_3225_Y_560 714.7m
R_VSMG5_940 MG1_X_3225_Y_1120 MSMG5_X_3225_Y_1120 714.7m
R_VSMG5_941 MG1_X_3225_Y_1680 MSMG5_X_3225_Y_1680 714.7m
R_VSMG5_942 MG1_X_3225_Y_2240 MSMG5_X_3225_Y_2240 714.7m
R_VSMG5_943 MG1_X_3225_Y_2800 MSMG5_X_3225_Y_2800 714.7m
R_VSMG5_944 MG1_X_3225_Y_3360 MSMG5_X_3225_Y_3360 714.7m
R_VSMG5_945 MG1_X_3225_Y_3920 MSMG5_X_3225_Y_3920 714.7m
R_VSMG5_946 MG1_X_3225_Y_4480 MSMG5_X_3225_Y_4480 714.7m
R_VSMG5_947 MG1_X_3225_Y_5040 MSMG5_X_3225_Y_5040 714.7m
R_VSMG5_948 MG1_X_3225_Y_5600 MSMG5_X_3225_Y_5600 714.7m
R_VSMG5_949 MG1_X_3225_Y_6160 MSMG5_X_3225_Y_6160 714.7m
R_VSMG5_950 MG1_X_3225_Y_6720 MSMG5_X_3225_Y_6720 714.7m
R_VSMG5_951 MG1_X_3225_Y_7280 MSMG5_X_3225_Y_7280 714.7m
R_VSMG5_952 MG1_X_3225_Y_7840 MSMG5_X_3225_Y_7840 714.7m
R_VSMG5_953 MG1_X_3225_Y_8400 MSMG5_X_3225_Y_8400 714.7m
R_VSMG5_954 MG1_X_3225_Y_8960 MSMG5_X_3225_Y_8960 714.7m
R_VSMG5_955 MG1_X_3225_Y_9520 MSMG5_X_3225_Y_9520 714.7m
R_VSMG5_956 MG1_X_3494_Y_0 MSMG5_X_3494_Y_0 714.7m
R_VSMG5_957 MG1_X_3494_Y_560 MSMG5_X_3494_Y_560 714.7m
R_VSMG5_958 MG1_X_3494_Y_1120 MSMG5_X_3494_Y_1120 714.7m
R_VSMG5_959 MG1_X_3494_Y_1680 MSMG5_X_3494_Y_1680 714.7m
R_VSMG5_960 MG1_X_3494_Y_2240 MSMG5_X_3494_Y_2240 714.7m
R_VSMG5_961 MG1_X_3494_Y_2800 MSMG5_X_3494_Y_2800 714.7m
R_VSMG5_962 MG1_X_3494_Y_3360 MSMG5_X_3494_Y_3360 714.7m
R_VSMG5_963 MG1_X_3494_Y_3920 MSMG5_X_3494_Y_3920 714.7m
R_VSMG5_964 MG1_X_3494_Y_4480 MSMG5_X_3494_Y_4480 714.7m
R_VSMG5_965 MG1_X_3494_Y_5040 MSMG5_X_3494_Y_5040 714.7m
R_VSMG5_966 MG1_X_3494_Y_5600 MSMG5_X_3494_Y_5600 714.7m
R_VSMG5_967 MG1_X_3494_Y_6160 MSMG5_X_3494_Y_6160 714.7m
R_VSMG5_968 MG1_X_3494_Y_6720 MSMG5_X_3494_Y_6720 714.7m
R_VSMG5_969 MG1_X_3494_Y_7280 MSMG5_X_3494_Y_7280 714.7m
R_VSMG5_970 MG1_X_3494_Y_7840 MSMG5_X_3494_Y_7840 714.7m
R_VSMG5_971 MG1_X_3494_Y_8400 MSMG5_X_3494_Y_8400 714.7m
R_VSMG5_972 MG1_X_3494_Y_8960 MSMG5_X_3494_Y_8960 714.7m
R_VSMG5_973 MG1_X_3494_Y_9520 MSMG5_X_3494_Y_9520 714.7m
R_VSMG5_974 MG1_X_3763_Y_0 MSMG5_X_3763_Y_0 714.7m
R_VSMG5_975 MG1_X_3763_Y_560 MSMG5_X_3763_Y_560 714.7m
R_VSMG5_976 MG1_X_3763_Y_1120 MSMG5_X_3763_Y_1120 714.7m
R_VSMG5_977 MG1_X_3763_Y_1680 MSMG5_X_3763_Y_1680 714.7m
R_VSMG5_978 MG1_X_3763_Y_2240 MSMG5_X_3763_Y_2240 714.7m
R_VSMG5_979 MG1_X_3763_Y_2800 MSMG5_X_3763_Y_2800 714.7m
R_VSMG5_980 MG1_X_3763_Y_3360 MSMG5_X_3763_Y_3360 714.7m
R_VSMG5_981 MG1_X_3763_Y_3920 MSMG5_X_3763_Y_3920 714.7m
R_VSMG5_982 MG1_X_3763_Y_4480 MSMG5_X_3763_Y_4480 714.7m
R_VSMG5_983 MG1_X_3763_Y_5040 MSMG5_X_3763_Y_5040 714.7m
R_VSMG5_984 MG1_X_3763_Y_5600 MSMG5_X_3763_Y_5600 714.7m
R_VSMG5_985 MG1_X_3763_Y_6160 MSMG5_X_3763_Y_6160 714.7m
R_VSMG5_986 MG1_X_3763_Y_6720 MSMG5_X_3763_Y_6720 714.7m
R_VSMG5_987 MG1_X_3763_Y_7280 MSMG5_X_3763_Y_7280 714.7m
R_VSMG5_988 MG1_X_3763_Y_7840 MSMG5_X_3763_Y_7840 714.7m
R_VSMG5_989 MG1_X_3763_Y_8400 MSMG5_X_3763_Y_8400 714.7m
R_VSMG5_990 MG1_X_3763_Y_8960 MSMG5_X_3763_Y_8960 714.7m
R_VSMG5_991 MG1_X_3763_Y_9520 MSMG5_X_3763_Y_9520 714.7m
R_VSMG5_992 MG1_X_4032_Y_0 MSMG5_X_4032_Y_0 714.7m
R_VSMG5_993 MG1_X_4032_Y_560 MSMG5_X_4032_Y_560 714.7m
R_VSMG5_994 MG1_X_4032_Y_1120 MSMG5_X_4032_Y_1120 714.7m
R_VSMG5_995 MG1_X_4032_Y_1680 MSMG5_X_4032_Y_1680 714.7m
R_VSMG5_996 MG1_X_4032_Y_2240 MSMG5_X_4032_Y_2240 714.7m
R_VSMG5_997 MG1_X_4032_Y_2800 MSMG5_X_4032_Y_2800 714.7m
R_VSMG5_998 MG1_X_4032_Y_3360 MSMG5_X_4032_Y_3360 714.7m
R_VSMG5_999 MG1_X_4032_Y_3920 MSMG5_X_4032_Y_3920 714.7m
R_VSMG5_1000 MG1_X_4032_Y_4480 MSMG5_X_4032_Y_4480 714.7m
R_VSMG5_1001 MG1_X_4032_Y_5040 MSMG5_X_4032_Y_5040 714.7m
R_VSMG5_1002 MG1_X_4032_Y_5600 MSMG5_X_4032_Y_5600 714.7m
R_VSMG5_1003 MG1_X_4032_Y_6160 MSMG5_X_4032_Y_6160 714.7m
R_VSMG5_1004 MG1_X_4032_Y_6720 MSMG5_X_4032_Y_6720 714.7m
R_VSMG5_1005 MG1_X_4032_Y_7280 MSMG5_X_4032_Y_7280 714.7m
R_VSMG5_1006 MG1_X_4032_Y_7840 MSMG5_X_4032_Y_7840 714.7m
R_VSMG5_1007 MG1_X_4032_Y_8400 MSMG5_X_4032_Y_8400 714.7m
R_VSMG5_1008 MG1_X_4032_Y_8960 MSMG5_X_4032_Y_8960 714.7m
R_VSMG5_1009 MG1_X_4032_Y_9520 MSMG5_X_4032_Y_9520 714.7m
R_VSMG5_1010 MG1_X_4300_Y_0 MSMG5_X_4300_Y_0 714.7m
R_VSMG5_1011 MG1_X_4300_Y_560 MSMG5_X_4300_Y_560 714.7m
R_VSMG5_1012 MG1_X_4300_Y_1120 MSMG5_X_4300_Y_1120 714.7m
R_VSMG5_1013 MG1_X_4300_Y_1680 MSMG5_X_4300_Y_1680 714.7m
R_VSMG5_1014 MG1_X_4300_Y_2240 MSMG5_X_4300_Y_2240 714.7m
R_VSMG5_1015 MG1_X_4300_Y_2800 MSMG5_X_4300_Y_2800 714.7m
R_VSMG5_1016 MG1_X_4300_Y_3360 MSMG5_X_4300_Y_3360 714.7m
R_VSMG5_1017 MG1_X_4300_Y_3920 MSMG5_X_4300_Y_3920 714.7m
R_VSMG5_1018 MG1_X_4300_Y_4480 MSMG5_X_4300_Y_4480 714.7m
R_VSMG5_1019 MG1_X_4300_Y_5040 MSMG5_X_4300_Y_5040 714.7m
R_VSMG5_1020 MG1_X_4300_Y_5600 MSMG5_X_4300_Y_5600 714.7m
R_VSMG5_1021 MG1_X_4300_Y_6160 MSMG5_X_4300_Y_6160 714.7m
R_VSMG5_1022 MG1_X_4300_Y_6720 MSMG5_X_4300_Y_6720 714.7m
R_VSMG5_1023 MG1_X_4300_Y_7280 MSMG5_X_4300_Y_7280 714.7m
R_VSMG5_1024 MG1_X_4300_Y_7840 MSMG5_X_4300_Y_7840 714.7m
R_VSMG5_1025 MG1_X_4300_Y_8400 MSMG5_X_4300_Y_8400 714.7m
R_VSMG5_1026 MG1_X_4300_Y_8960 MSMG5_X_4300_Y_8960 714.7m
R_VSMG5_1027 MG1_X_4300_Y_9520 MSMG5_X_4300_Y_9520 714.7m
R_VSMG5_1028 MG1_X_4569_Y_0 MSMG5_X_4569_Y_0 714.7m
R_VSMG5_1029 MG1_X_4569_Y_560 MSMG5_X_4569_Y_560 714.7m
R_VSMG5_1030 MG1_X_4569_Y_1120 MSMG5_X_4569_Y_1120 714.7m
R_VSMG5_1031 MG1_X_4569_Y_1680 MSMG5_X_4569_Y_1680 714.7m
R_VSMG5_1032 MG1_X_4569_Y_2240 MSMG5_X_4569_Y_2240 714.7m
R_VSMG5_1033 MG1_X_4569_Y_2800 MSMG5_X_4569_Y_2800 714.7m
R_VSMG5_1034 MG1_X_4569_Y_3360 MSMG5_X_4569_Y_3360 714.7m
R_VSMG5_1035 MG1_X_4569_Y_3920 MSMG5_X_4569_Y_3920 714.7m
R_VSMG5_1036 MG1_X_4569_Y_4480 MSMG5_X_4569_Y_4480 714.7m
R_VSMG5_1037 MG1_X_4569_Y_5040 MSMG5_X_4569_Y_5040 714.7m
R_VSMG5_1038 MG1_X_4569_Y_5600 MSMG5_X_4569_Y_5600 714.7m
R_VSMG5_1039 MG1_X_4569_Y_6160 MSMG5_X_4569_Y_6160 714.7m
R_VSMG5_1040 MG1_X_4569_Y_6720 MSMG5_X_4569_Y_6720 714.7m
R_VSMG5_1041 MG1_X_4569_Y_7280 MSMG5_X_4569_Y_7280 714.7m
R_VSMG5_1042 MG1_X_4569_Y_7840 MSMG5_X_4569_Y_7840 714.7m
R_VSMG5_1043 MG1_X_4569_Y_8400 MSMG5_X_4569_Y_8400 714.7m
R_VSMG5_1044 MG1_X_4569_Y_8960 MSMG5_X_4569_Y_8960 714.7m
R_VSMG5_1045 MG1_X_4569_Y_9520 MSMG5_X_4569_Y_9520 714.7m
R_VSMG5_1046 MG1_X_4838_Y_0 MSMG5_X_4838_Y_0 714.7m
R_VSMG5_1047 MG1_X_4838_Y_560 MSMG5_X_4838_Y_560 714.7m
R_VSMG5_1048 MG1_X_4838_Y_1120 MSMG5_X_4838_Y_1120 714.7m
R_VSMG5_1049 MG1_X_4838_Y_1680 MSMG5_X_4838_Y_1680 714.7m
R_VSMG5_1050 MG1_X_4838_Y_2240 MSMG5_X_4838_Y_2240 714.7m
R_VSMG5_1051 MG1_X_4838_Y_2800 MSMG5_X_4838_Y_2800 714.7m
R_VSMG5_1052 MG1_X_4838_Y_3360 MSMG5_X_4838_Y_3360 714.7m
R_VSMG5_1053 MG1_X_4838_Y_3920 MSMG5_X_4838_Y_3920 714.7m
R_VSMG5_1054 MG1_X_4838_Y_4480 MSMG5_X_4838_Y_4480 714.7m
R_VSMG5_1055 MG1_X_4838_Y_5040 MSMG5_X_4838_Y_5040 714.7m
R_VSMG5_1056 MG1_X_4838_Y_5600 MSMG5_X_4838_Y_5600 714.7m
R_VSMG5_1057 MG1_X_4838_Y_6160 MSMG5_X_4838_Y_6160 714.7m
R_VSMG5_1058 MG1_X_4838_Y_6720 MSMG5_X_4838_Y_6720 714.7m
R_VSMG5_1059 MG1_X_4838_Y_7280 MSMG5_X_4838_Y_7280 714.7m
R_VSMG5_1060 MG1_X_4838_Y_7840 MSMG5_X_4838_Y_7840 714.7m
R_VSMG5_1061 MG1_X_4838_Y_8400 MSMG5_X_4838_Y_8400 714.7m
R_VSMG5_1062 MG1_X_4838_Y_8960 MSMG5_X_4838_Y_8960 714.7m
R_VSMG5_1063 MG1_X_4838_Y_9520 MSMG5_X_4838_Y_9520 714.7m
R_VSMG5_1064 MG1_X_5107_Y_0 MSMG5_X_5107_Y_0 714.7m
R_VSMG5_1065 MG1_X_5107_Y_560 MSMG5_X_5107_Y_560 714.7m
R_VSMG5_1066 MG1_X_5107_Y_1120 MSMG5_X_5107_Y_1120 714.7m
R_VSMG5_1067 MG1_X_5107_Y_1680 MSMG5_X_5107_Y_1680 714.7m
R_VSMG5_1068 MG1_X_5107_Y_2240 MSMG5_X_5107_Y_2240 714.7m
R_VSMG5_1069 MG1_X_5107_Y_2800 MSMG5_X_5107_Y_2800 714.7m
R_VSMG5_1070 MG1_X_5107_Y_3360 MSMG5_X_5107_Y_3360 714.7m
R_VSMG5_1071 MG1_X_5107_Y_3920 MSMG5_X_5107_Y_3920 714.7m
R_VSMG5_1072 MG1_X_5107_Y_4480 MSMG5_X_5107_Y_4480 714.7m
R_VSMG5_1073 MG1_X_5107_Y_5040 MSMG5_X_5107_Y_5040 714.7m
R_VSMG5_1074 MG1_X_5107_Y_5600 MSMG5_X_5107_Y_5600 714.7m
R_VSMG5_1075 MG1_X_5107_Y_6160 MSMG5_X_5107_Y_6160 714.7m
R_VSMG5_1076 MG1_X_5107_Y_6720 MSMG5_X_5107_Y_6720 714.7m
R_VSMG5_1077 MG1_X_5107_Y_7280 MSMG5_X_5107_Y_7280 714.7m
R_VSMG5_1078 MG1_X_5107_Y_7840 MSMG5_X_5107_Y_7840 714.7m
R_VSMG5_1079 MG1_X_5107_Y_8400 MSMG5_X_5107_Y_8400 714.7m
R_VSMG5_1080 MG1_X_5107_Y_8960 MSMG5_X_5107_Y_8960 714.7m
R_VSMG5_1081 MG1_X_5107_Y_9520 MSMG5_X_5107_Y_9520 714.7m
R_VSMG5_1082 MG1_X_5376_Y_0 MSMG5_X_5376_Y_0 714.7m
R_VSMG5_1083 MG1_X_5376_Y_560 MSMG5_X_5376_Y_560 714.7m
R_VSMG5_1084 MG1_X_5376_Y_1120 MSMG5_X_5376_Y_1120 714.7m
R_VSMG5_1085 MG1_X_5376_Y_1680 MSMG5_X_5376_Y_1680 714.7m
R_VSMG5_1086 MG1_X_5376_Y_2240 MSMG5_X_5376_Y_2240 714.7m
R_VSMG5_1087 MG1_X_5376_Y_2800 MSMG5_X_5376_Y_2800 714.7m
R_VSMG5_1088 MG1_X_5376_Y_3360 MSMG5_X_5376_Y_3360 714.7m
R_VSMG5_1089 MG1_X_5376_Y_3920 MSMG5_X_5376_Y_3920 714.7m
R_VSMG5_1090 MG1_X_5376_Y_4480 MSMG5_X_5376_Y_4480 714.7m
R_VSMG5_1091 MG1_X_5376_Y_5040 MSMG5_X_5376_Y_5040 714.7m
R_VSMG5_1092 MG1_X_5376_Y_5600 MSMG5_X_5376_Y_5600 714.7m
R_VSMG5_1093 MG1_X_5376_Y_6160 MSMG5_X_5376_Y_6160 714.7m
R_VSMG5_1094 MG1_X_5376_Y_6720 MSMG5_X_5376_Y_6720 714.7m
R_VSMG5_1095 MG1_X_5376_Y_7280 MSMG5_X_5376_Y_7280 714.7m
R_VSMG5_1096 MG1_X_5376_Y_7840 MSMG5_X_5376_Y_7840 714.7m
R_VSMG5_1097 MG1_X_5376_Y_8400 MSMG5_X_5376_Y_8400 714.7m
R_VSMG5_1098 MG1_X_5376_Y_8960 MSMG5_X_5376_Y_8960 714.7m
R_VSMG5_1099 MG1_X_5376_Y_9520 MSMG5_X_5376_Y_9520 714.7m
R_VSMG5_1100 MG1_X_5644_Y_0 MSMG5_X_5644_Y_0 714.7m
R_VSMG5_1101 MG1_X_5644_Y_560 MSMG5_X_5644_Y_560 714.7m
R_VSMG5_1102 MG1_X_5644_Y_1120 MSMG5_X_5644_Y_1120 714.7m
R_VSMG5_1103 MG1_X_5644_Y_1680 MSMG5_X_5644_Y_1680 714.7m
R_VSMG5_1104 MG1_X_5644_Y_2240 MSMG5_X_5644_Y_2240 714.7m
R_VSMG5_1105 MG1_X_5644_Y_2800 MSMG5_X_5644_Y_2800 714.7m
R_VSMG5_1106 MG1_X_5644_Y_3360 MSMG5_X_5644_Y_3360 714.7m
R_VSMG5_1107 MG1_X_5644_Y_3920 MSMG5_X_5644_Y_3920 714.7m
R_VSMG5_1108 MG1_X_5644_Y_4480 MSMG5_X_5644_Y_4480 714.7m
R_VSMG5_1109 MG1_X_5644_Y_5040 MSMG5_X_5644_Y_5040 714.7m
R_VSMG5_1110 MG1_X_5644_Y_5600 MSMG5_X_5644_Y_5600 714.7m
R_VSMG5_1111 MG1_X_5644_Y_6160 MSMG5_X_5644_Y_6160 714.7m
R_VSMG5_1112 MG1_X_5644_Y_6720 MSMG5_X_5644_Y_6720 714.7m
R_VSMG5_1113 MG1_X_5644_Y_7280 MSMG5_X_5644_Y_7280 714.7m
R_VSMG5_1114 MG1_X_5644_Y_7840 MSMG5_X_5644_Y_7840 714.7m
R_VSMG5_1115 MG1_X_5644_Y_8400 MSMG5_X_5644_Y_8400 714.7m
R_VSMG5_1116 MG1_X_5644_Y_8960 MSMG5_X_5644_Y_8960 714.7m
R_VSMG5_1117 MG1_X_5644_Y_9520 MSMG5_X_5644_Y_9520 714.7m
R_VSMG5_1118 MG1_X_5913_Y_0 MSMG5_X_5913_Y_0 714.7m
R_VSMG5_1119 MG1_X_5913_Y_560 MSMG5_X_5913_Y_560 714.7m
R_VSMG5_1120 MG1_X_5913_Y_1120 MSMG5_X_5913_Y_1120 714.7m
R_VSMG5_1121 MG1_X_5913_Y_1680 MSMG5_X_5913_Y_1680 714.7m
R_VSMG5_1122 MG1_X_5913_Y_2240 MSMG5_X_5913_Y_2240 714.7m
R_VSMG5_1123 MG1_X_5913_Y_2800 MSMG5_X_5913_Y_2800 714.7m
R_VSMG5_1124 MG1_X_5913_Y_3360 MSMG5_X_5913_Y_3360 714.7m
R_VSMG5_1125 MG1_X_5913_Y_3920 MSMG5_X_5913_Y_3920 714.7m
R_VSMG5_1126 MG1_X_5913_Y_4480 MSMG5_X_5913_Y_4480 714.7m
R_VSMG5_1127 MG1_X_5913_Y_5040 MSMG5_X_5913_Y_5040 714.7m
R_VSMG5_1128 MG1_X_5913_Y_5600 MSMG5_X_5913_Y_5600 714.7m
R_VSMG5_1129 MG1_X_5913_Y_6160 MSMG5_X_5913_Y_6160 714.7m
R_VSMG5_1130 MG1_X_5913_Y_6720 MSMG5_X_5913_Y_6720 714.7m
R_VSMG5_1131 MG1_X_5913_Y_7280 MSMG5_X_5913_Y_7280 714.7m
R_VSMG5_1132 MG1_X_5913_Y_7840 MSMG5_X_5913_Y_7840 714.7m
R_VSMG5_1133 MG1_X_5913_Y_8400 MSMG5_X_5913_Y_8400 714.7m
R_VSMG5_1134 MG1_X_5913_Y_8960 MSMG5_X_5913_Y_8960 714.7m
R_VSMG5_1135 MG1_X_5913_Y_9520 MSMG5_X_5913_Y_9520 714.7m
R_VSMG5_1136 MG1_X_6182_Y_0 MSMG5_X_6182_Y_0 714.7m
R_VSMG5_1137 MG1_X_6182_Y_560 MSMG5_X_6182_Y_560 714.7m
R_VSMG5_1138 MG1_X_6182_Y_1120 MSMG5_X_6182_Y_1120 714.7m
R_VSMG5_1139 MG1_X_6182_Y_1680 MSMG5_X_6182_Y_1680 714.7m
R_VSMG5_1140 MG1_X_6182_Y_2240 MSMG5_X_6182_Y_2240 714.7m
R_VSMG5_1141 MG1_X_6182_Y_2800 MSMG5_X_6182_Y_2800 714.7m
R_VSMG5_1142 MG1_X_6182_Y_3360 MSMG5_X_6182_Y_3360 714.7m
R_VSMG5_1143 MG1_X_6182_Y_3920 MSMG5_X_6182_Y_3920 714.7m
R_VSMG5_1144 MG1_X_6182_Y_4480 MSMG5_X_6182_Y_4480 714.7m
R_VSMG5_1145 MG1_X_6182_Y_5040 MSMG5_X_6182_Y_5040 714.7m
R_VSMG5_1146 MG1_X_6182_Y_5600 MSMG5_X_6182_Y_5600 714.7m
R_VSMG5_1147 MG1_X_6182_Y_6160 MSMG5_X_6182_Y_6160 714.7m
R_VSMG5_1148 MG1_X_6182_Y_6720 MSMG5_X_6182_Y_6720 714.7m
R_VSMG5_1149 MG1_X_6182_Y_7280 MSMG5_X_6182_Y_7280 714.7m
R_VSMG5_1150 MG1_X_6182_Y_7840 MSMG5_X_6182_Y_7840 714.7m
R_VSMG5_1151 MG1_X_6182_Y_8400 MSMG5_X_6182_Y_8400 714.7m
R_VSMG5_1152 MG1_X_6182_Y_8960 MSMG5_X_6182_Y_8960 714.7m
R_VSMG5_1153 MG1_X_6182_Y_9520 MSMG5_X_6182_Y_9520 714.7m
R_VSMG5_1154 MG1_X_6451_Y_0 MSMG5_X_6451_Y_0 714.7m
R_VSMG5_1155 MG1_X_6451_Y_560 MSMG5_X_6451_Y_560 714.7m
R_VSMG5_1156 MG1_X_6451_Y_1120 MSMG5_X_6451_Y_1120 714.7m
R_VSMG5_1157 MG1_X_6451_Y_1680 MSMG5_X_6451_Y_1680 714.7m
R_VSMG5_1158 MG1_X_6451_Y_2240 MSMG5_X_6451_Y_2240 714.7m
R_VSMG5_1159 MG1_X_6451_Y_2800 MSMG5_X_6451_Y_2800 714.7m
R_VSMG5_1160 MG1_X_6451_Y_3360 MSMG5_X_6451_Y_3360 714.7m
R_VSMG5_1161 MG1_X_6451_Y_3920 MSMG5_X_6451_Y_3920 714.7m
R_VSMG5_1162 MG1_X_6451_Y_4480 MSMG5_X_6451_Y_4480 714.7m
R_VSMG5_1163 MG1_X_6451_Y_5040 MSMG5_X_6451_Y_5040 714.7m
R_VSMG5_1164 MG1_X_6451_Y_5600 MSMG5_X_6451_Y_5600 714.7m
R_VSMG5_1165 MG1_X_6451_Y_6160 MSMG5_X_6451_Y_6160 714.7m
R_VSMG5_1166 MG1_X_6451_Y_6720 MSMG5_X_6451_Y_6720 714.7m
R_VSMG5_1167 MG1_X_6451_Y_7280 MSMG5_X_6451_Y_7280 714.7m
R_VSMG5_1168 MG1_X_6451_Y_7840 MSMG5_X_6451_Y_7840 714.7m
R_VSMG5_1169 MG1_X_6451_Y_8400 MSMG5_X_6451_Y_8400 714.7m
R_VSMG5_1170 MG1_X_6451_Y_8960 MSMG5_X_6451_Y_8960 714.7m
R_VSMG5_1171 MG1_X_6451_Y_9520 MSMG5_X_6451_Y_9520 714.7m
R_VSMG5_1172 MG1_X_6720_Y_0 MSMG5_X_6720_Y_0 714.7m
R_VSMG5_1173 MG1_X_6720_Y_560 MSMG5_X_6720_Y_560 714.7m
R_VSMG5_1174 MG1_X_6720_Y_1120 MSMG5_X_6720_Y_1120 714.7m
R_VSMG5_1175 MG1_X_6720_Y_1680 MSMG5_X_6720_Y_1680 714.7m
R_VSMG5_1176 MG1_X_6720_Y_2240 MSMG5_X_6720_Y_2240 714.7m
R_VSMG5_1177 MG1_X_6720_Y_2800 MSMG5_X_6720_Y_2800 714.7m
R_VSMG5_1178 MG1_X_6720_Y_3360 MSMG5_X_6720_Y_3360 714.7m
R_VSMG5_1179 MG1_X_6720_Y_3920 MSMG5_X_6720_Y_3920 714.7m
R_VSMG5_1180 MG1_X_6720_Y_4480 MSMG5_X_6720_Y_4480 714.7m
R_VSMG5_1181 MG1_X_6720_Y_5040 MSMG5_X_6720_Y_5040 714.7m
R_VSMG5_1182 MG1_X_6720_Y_5600 MSMG5_X_6720_Y_5600 714.7m
R_VSMG5_1183 MG1_X_6720_Y_6160 MSMG5_X_6720_Y_6160 714.7m
R_VSMG5_1184 MG1_X_6720_Y_6720 MSMG5_X_6720_Y_6720 714.7m
R_VSMG5_1185 MG1_X_6720_Y_7280 MSMG5_X_6720_Y_7280 714.7m
R_VSMG5_1186 MG1_X_6720_Y_7840 MSMG5_X_6720_Y_7840 714.7m
R_VSMG5_1187 MG1_X_6720_Y_8400 MSMG5_X_6720_Y_8400 714.7m
R_VSMG5_1188 MG1_X_6720_Y_8960 MSMG5_X_6720_Y_8960 714.7m
R_VSMG5_1189 MG1_X_6720_Y_9520 MSMG5_X_6720_Y_9520 714.7m
R_VSMG5_1190 MG1_X_6988_Y_0 MSMG5_X_6988_Y_0 714.7m
R_VSMG5_1191 MG1_X_6988_Y_560 MSMG5_X_6988_Y_560 714.7m
R_VSMG5_1192 MG1_X_6988_Y_1120 MSMG5_X_6988_Y_1120 714.7m
R_VSMG5_1193 MG1_X_6988_Y_1680 MSMG5_X_6988_Y_1680 714.7m
R_VSMG5_1194 MG1_X_6988_Y_2240 MSMG5_X_6988_Y_2240 714.7m
R_VSMG5_1195 MG1_X_6988_Y_2800 MSMG5_X_6988_Y_2800 714.7m
R_VSMG5_1196 MG1_X_6988_Y_3360 MSMG5_X_6988_Y_3360 714.7m
R_VSMG5_1197 MG1_X_6988_Y_3920 MSMG5_X_6988_Y_3920 714.7m
R_VSMG5_1198 MG1_X_6988_Y_4480 MSMG5_X_6988_Y_4480 714.7m
R_VSMG5_1199 MG1_X_6988_Y_5040 MSMG5_X_6988_Y_5040 714.7m
R_VSMG5_1200 MG1_X_6988_Y_5600 MSMG5_X_6988_Y_5600 714.7m
R_VSMG5_1201 MG1_X_6988_Y_6160 MSMG5_X_6988_Y_6160 714.7m
R_VSMG5_1202 MG1_X_6988_Y_6720 MSMG5_X_6988_Y_6720 714.7m
R_VSMG5_1203 MG1_X_6988_Y_7280 MSMG5_X_6988_Y_7280 714.7m
R_VSMG5_1204 MG1_X_6988_Y_7840 MSMG5_X_6988_Y_7840 714.7m
R_VSMG5_1205 MG1_X_6988_Y_8400 MSMG5_X_6988_Y_8400 714.7m
R_VSMG5_1206 MG1_X_6988_Y_8960 MSMG5_X_6988_Y_8960 714.7m
R_VSMG5_1207 MG1_X_6988_Y_9520 MSMG5_X_6988_Y_9520 714.7m
R_VSMG5_1208 MG1_X_7257_Y_0 MSMG5_X_7257_Y_0 714.7m
R_VSMG5_1209 MG1_X_7257_Y_560 MSMG5_X_7257_Y_560 714.7m
R_VSMG5_1210 MG1_X_7257_Y_1120 MSMG5_X_7257_Y_1120 714.7m
R_VSMG5_1211 MG1_X_7257_Y_1680 MSMG5_X_7257_Y_1680 714.7m
R_VSMG5_1212 MG1_X_7257_Y_2240 MSMG5_X_7257_Y_2240 714.7m
R_VSMG5_1213 MG1_X_7257_Y_2800 MSMG5_X_7257_Y_2800 714.7m
R_VSMG5_1214 MG1_X_7257_Y_3360 MSMG5_X_7257_Y_3360 714.7m
R_VSMG5_1215 MG1_X_7257_Y_3920 MSMG5_X_7257_Y_3920 714.7m
R_VSMG5_1216 MG1_X_7257_Y_4480 MSMG5_X_7257_Y_4480 714.7m
R_VSMG5_1217 MG1_X_7257_Y_5040 MSMG5_X_7257_Y_5040 714.7m
R_VSMG5_1218 MG1_X_7257_Y_5600 MSMG5_X_7257_Y_5600 714.7m
R_VSMG5_1219 MG1_X_7257_Y_6160 MSMG5_X_7257_Y_6160 714.7m
R_VSMG5_1220 MG1_X_7257_Y_6720 MSMG5_X_7257_Y_6720 714.7m
R_VSMG5_1221 MG1_X_7257_Y_7280 MSMG5_X_7257_Y_7280 714.7m
R_VSMG5_1222 MG1_X_7257_Y_7840 MSMG5_X_7257_Y_7840 714.7m
R_VSMG5_1223 MG1_X_7257_Y_8400 MSMG5_X_7257_Y_8400 714.7m
R_VSMG5_1224 MG1_X_7257_Y_8960 MSMG5_X_7257_Y_8960 714.7m
R_VSMG5_1225 MG1_X_7257_Y_9520 MSMG5_X_7257_Y_9520 714.7m
R_VSMG5_1226 MG1_X_7526_Y_0 MSMG5_X_7526_Y_0 714.7m
R_VSMG5_1227 MG1_X_7526_Y_560 MSMG5_X_7526_Y_560 714.7m
R_VSMG5_1228 MG1_X_7526_Y_1120 MSMG5_X_7526_Y_1120 714.7m
R_VSMG5_1229 MG1_X_7526_Y_1680 MSMG5_X_7526_Y_1680 714.7m
R_VSMG5_1230 MG1_X_7526_Y_2240 MSMG5_X_7526_Y_2240 714.7m
R_VSMG5_1231 MG1_X_7526_Y_2800 MSMG5_X_7526_Y_2800 714.7m
R_VSMG5_1232 MG1_X_7526_Y_3360 MSMG5_X_7526_Y_3360 714.7m
R_VSMG5_1233 MG1_X_7526_Y_3920 MSMG5_X_7526_Y_3920 714.7m
R_VSMG5_1234 MG1_X_7526_Y_4480 MSMG5_X_7526_Y_4480 714.7m
R_VSMG5_1235 MG1_X_7526_Y_5040 MSMG5_X_7526_Y_5040 714.7m
R_VSMG5_1236 MG1_X_7526_Y_5600 MSMG5_X_7526_Y_5600 714.7m
R_VSMG5_1237 MG1_X_7526_Y_6160 MSMG5_X_7526_Y_6160 714.7m
R_VSMG5_1238 MG1_X_7526_Y_6720 MSMG5_X_7526_Y_6720 714.7m
R_VSMG5_1239 MG1_X_7526_Y_7280 MSMG5_X_7526_Y_7280 714.7m
R_VSMG5_1240 MG1_X_7526_Y_7840 MSMG5_X_7526_Y_7840 714.7m
R_VSMG5_1241 MG1_X_7526_Y_8400 MSMG5_X_7526_Y_8400 714.7m
R_VSMG5_1242 MG1_X_7526_Y_8960 MSMG5_X_7526_Y_8960 714.7m
R_VSMG5_1243 MG1_X_7526_Y_9520 MSMG5_X_7526_Y_9520 714.7m
R_VSMG5_1244 MG1_X_7795_Y_0 MSMG5_X_7795_Y_0 714.7m
R_VSMG5_1245 MG1_X_7795_Y_560 MSMG5_X_7795_Y_560 714.7m
R_VSMG5_1246 MG1_X_7795_Y_1120 MSMG5_X_7795_Y_1120 714.7m
R_VSMG5_1247 MG1_X_7795_Y_1680 MSMG5_X_7795_Y_1680 714.7m
R_VSMG5_1248 MG1_X_7795_Y_2240 MSMG5_X_7795_Y_2240 714.7m
R_VSMG5_1249 MG1_X_7795_Y_2800 MSMG5_X_7795_Y_2800 714.7m
R_VSMG5_1250 MG1_X_7795_Y_3360 MSMG5_X_7795_Y_3360 714.7m
R_VSMG5_1251 MG1_X_7795_Y_3920 MSMG5_X_7795_Y_3920 714.7m
R_VSMG5_1252 MG1_X_7795_Y_4480 MSMG5_X_7795_Y_4480 714.7m
R_VSMG5_1253 MG1_X_7795_Y_5040 MSMG5_X_7795_Y_5040 714.7m
R_VSMG5_1254 MG1_X_7795_Y_5600 MSMG5_X_7795_Y_5600 714.7m
R_VSMG5_1255 MG1_X_7795_Y_6160 MSMG5_X_7795_Y_6160 714.7m
R_VSMG5_1256 MG1_X_7795_Y_6720 MSMG5_X_7795_Y_6720 714.7m
R_VSMG5_1257 MG1_X_7795_Y_7280 MSMG5_X_7795_Y_7280 714.7m
R_VSMG5_1258 MG1_X_7795_Y_7840 MSMG5_X_7795_Y_7840 714.7m
R_VSMG5_1259 MG1_X_7795_Y_8400 MSMG5_X_7795_Y_8400 714.7m
R_VSMG5_1260 MG1_X_7795_Y_8960 MSMG5_X_7795_Y_8960 714.7m
R_VSMG5_1261 MG1_X_7795_Y_9520 MSMG5_X_7795_Y_9520 714.7m
R_VSMG5_1262 MG1_X_8064_Y_0 MSMG5_X_8064_Y_0 714.7m
R_VSMG5_1263 MG1_X_8064_Y_560 MSMG5_X_8064_Y_560 714.7m
R_VSMG5_1264 MG1_X_8064_Y_1120 MSMG5_X_8064_Y_1120 714.7m
R_VSMG5_1265 MG1_X_8064_Y_1680 MSMG5_X_8064_Y_1680 714.7m
R_VSMG5_1266 MG1_X_8064_Y_2240 MSMG5_X_8064_Y_2240 714.7m
R_VSMG5_1267 MG1_X_8064_Y_2800 MSMG5_X_8064_Y_2800 714.7m
R_VSMG5_1268 MG1_X_8064_Y_3360 MSMG5_X_8064_Y_3360 714.7m
R_VSMG5_1269 MG1_X_8064_Y_3920 MSMG5_X_8064_Y_3920 714.7m
R_VSMG5_1270 MG1_X_8064_Y_4480 MSMG5_X_8064_Y_4480 714.7m
R_VSMG5_1271 MG1_X_8064_Y_5040 MSMG5_X_8064_Y_5040 714.7m
R_VSMG5_1272 MG1_X_8064_Y_5600 MSMG5_X_8064_Y_5600 714.7m
R_VSMG5_1273 MG1_X_8064_Y_6160 MSMG5_X_8064_Y_6160 714.7m
R_VSMG5_1274 MG1_X_8064_Y_6720 MSMG5_X_8064_Y_6720 714.7m
R_VSMG5_1275 MG1_X_8064_Y_7280 MSMG5_X_8064_Y_7280 714.7m
R_VSMG5_1276 MG1_X_8064_Y_7840 MSMG5_X_8064_Y_7840 714.7m
R_VSMG5_1277 MG1_X_8064_Y_8400 MSMG5_X_8064_Y_8400 714.7m
R_VSMG5_1278 MG1_X_8064_Y_8960 MSMG5_X_8064_Y_8960 714.7m
R_VSMG5_1279 MG1_X_8064_Y_9520 MSMG5_X_8064_Y_9520 714.7m
R_VSMG5_1280 MG1_X_8332_Y_0 MSMG5_X_8332_Y_0 714.7m
R_VSMG5_1281 MG1_X_8332_Y_560 MSMG5_X_8332_Y_560 714.7m
R_VSMG5_1282 MG1_X_8332_Y_1120 MSMG5_X_8332_Y_1120 714.7m
R_VSMG5_1283 MG1_X_8332_Y_1680 MSMG5_X_8332_Y_1680 714.7m
R_VSMG5_1284 MG1_X_8332_Y_2240 MSMG5_X_8332_Y_2240 714.7m
R_VSMG5_1285 MG1_X_8332_Y_2800 MSMG5_X_8332_Y_2800 714.7m
R_VSMG5_1286 MG1_X_8332_Y_3360 MSMG5_X_8332_Y_3360 714.7m
R_VSMG5_1287 MG1_X_8332_Y_3920 MSMG5_X_8332_Y_3920 714.7m
R_VSMG5_1288 MG1_X_8332_Y_4480 MSMG5_X_8332_Y_4480 714.7m
R_VSMG5_1289 MG1_X_8332_Y_5040 MSMG5_X_8332_Y_5040 714.7m
R_VSMG5_1290 MG1_X_8332_Y_5600 MSMG5_X_8332_Y_5600 714.7m
R_VSMG5_1291 MG1_X_8332_Y_6160 MSMG5_X_8332_Y_6160 714.7m
R_VSMG5_1292 MG1_X_8332_Y_6720 MSMG5_X_8332_Y_6720 714.7m
R_VSMG5_1293 MG1_X_8332_Y_7280 MSMG5_X_8332_Y_7280 714.7m
R_VSMG5_1294 MG1_X_8332_Y_7840 MSMG5_X_8332_Y_7840 714.7m
R_VSMG5_1295 MG1_X_8332_Y_8400 MSMG5_X_8332_Y_8400 714.7m
R_VSMG5_1296 MG1_X_8332_Y_8960 MSMG5_X_8332_Y_8960 714.7m
R_VSMG5_1297 MG1_X_8332_Y_9520 MSMG5_X_8332_Y_9520 714.7m
R_VSMG5_1298 MG1_X_8601_Y_0 MSMG5_X_8601_Y_0 714.7m
R_VSMG5_1299 MG1_X_8601_Y_560 MSMG5_X_8601_Y_560 714.7m
R_VSMG5_1300 MG1_X_8601_Y_1120 MSMG5_X_8601_Y_1120 714.7m
R_VSMG5_1301 MG1_X_8601_Y_1680 MSMG5_X_8601_Y_1680 714.7m
R_VSMG5_1302 MG1_X_8601_Y_2240 MSMG5_X_8601_Y_2240 714.7m
R_VSMG5_1303 MG1_X_8601_Y_2800 MSMG5_X_8601_Y_2800 714.7m
R_VSMG5_1304 MG1_X_8601_Y_3360 MSMG5_X_8601_Y_3360 714.7m
R_VSMG5_1305 MG1_X_8601_Y_3920 MSMG5_X_8601_Y_3920 714.7m
R_VSMG5_1306 MG1_X_8601_Y_4480 MSMG5_X_8601_Y_4480 714.7m
R_VSMG5_1307 MG1_X_8601_Y_5040 MSMG5_X_8601_Y_5040 714.7m
R_VSMG5_1308 MG1_X_8601_Y_5600 MSMG5_X_8601_Y_5600 714.7m
R_VSMG5_1309 MG1_X_8601_Y_6160 MSMG5_X_8601_Y_6160 714.7m
R_VSMG5_1310 MG1_X_8601_Y_6720 MSMG5_X_8601_Y_6720 714.7m
R_VSMG5_1311 MG1_X_8601_Y_7280 MSMG5_X_8601_Y_7280 714.7m
R_VSMG5_1312 MG1_X_8601_Y_7840 MSMG5_X_8601_Y_7840 714.7m
R_VSMG5_1313 MG1_X_8601_Y_8400 MSMG5_X_8601_Y_8400 714.7m
R_VSMG5_1314 MG1_X_8601_Y_8960 MSMG5_X_8601_Y_8960 714.7m
R_VSMG5_1315 MG1_X_8601_Y_9520 MSMG5_X_8601_Y_9520 714.7m
R_VSMG5_1316 MG1_X_8870_Y_0 MSMG5_X_8870_Y_0 714.7m
R_VSMG5_1317 MG1_X_8870_Y_560 MSMG5_X_8870_Y_560 714.7m
R_VSMG5_1318 MG1_X_8870_Y_1120 MSMG5_X_8870_Y_1120 714.7m
R_VSMG5_1319 MG1_X_8870_Y_1680 MSMG5_X_8870_Y_1680 714.7m
R_VSMG5_1320 MG1_X_8870_Y_2240 MSMG5_X_8870_Y_2240 714.7m
R_VSMG5_1321 MG1_X_8870_Y_2800 MSMG5_X_8870_Y_2800 714.7m
R_VSMG5_1322 MG1_X_8870_Y_3360 MSMG5_X_8870_Y_3360 714.7m
R_VSMG5_1323 MG1_X_8870_Y_3920 MSMG5_X_8870_Y_3920 714.7m
R_VSMG5_1324 MG1_X_8870_Y_4480 MSMG5_X_8870_Y_4480 714.7m
R_VSMG5_1325 MG1_X_8870_Y_5040 MSMG5_X_8870_Y_5040 714.7m
R_VSMG5_1326 MG1_X_8870_Y_5600 MSMG5_X_8870_Y_5600 714.7m
R_VSMG5_1327 MG1_X_8870_Y_6160 MSMG5_X_8870_Y_6160 714.7m
R_VSMG5_1328 MG1_X_8870_Y_6720 MSMG5_X_8870_Y_6720 714.7m
R_VSMG5_1329 MG1_X_8870_Y_7280 MSMG5_X_8870_Y_7280 714.7m
R_VSMG5_1330 MG1_X_8870_Y_7840 MSMG5_X_8870_Y_7840 714.7m
R_VSMG5_1331 MG1_X_8870_Y_8400 MSMG5_X_8870_Y_8400 714.7m
R_VSMG5_1332 MG1_X_8870_Y_8960 MSMG5_X_8870_Y_8960 714.7m
R_VSMG5_1333 MG1_X_8870_Y_9520 MSMG5_X_8870_Y_9520 714.7m
R_VSMG5_1334 MG1_X_9139_Y_0 MSMG5_X_9139_Y_0 714.7m
R_VSMG5_1335 MG1_X_9139_Y_560 MSMG5_X_9139_Y_560 714.7m
R_VSMG5_1336 MG1_X_9139_Y_1120 MSMG5_X_9139_Y_1120 714.7m
R_VSMG5_1337 MG1_X_9139_Y_1680 MSMG5_X_9139_Y_1680 714.7m
R_VSMG5_1338 MG1_X_9139_Y_2240 MSMG5_X_9139_Y_2240 714.7m
R_VSMG5_1339 MG1_X_9139_Y_2800 MSMG5_X_9139_Y_2800 714.7m
R_VSMG5_1340 MG1_X_9139_Y_3360 MSMG5_X_9139_Y_3360 714.7m
R_VSMG5_1341 MG1_X_9139_Y_3920 MSMG5_X_9139_Y_3920 714.7m
R_VSMG5_1342 MG1_X_9139_Y_4480 MSMG5_X_9139_Y_4480 714.7m
R_VSMG5_1343 MG1_X_9139_Y_5040 MSMG5_X_9139_Y_5040 714.7m
R_VSMG5_1344 MG1_X_9139_Y_5600 MSMG5_X_9139_Y_5600 714.7m
R_VSMG5_1345 MG1_X_9139_Y_6160 MSMG5_X_9139_Y_6160 714.7m
R_VSMG5_1346 MG1_X_9139_Y_6720 MSMG5_X_9139_Y_6720 714.7m
R_VSMG5_1347 MG1_X_9139_Y_7280 MSMG5_X_9139_Y_7280 714.7m
R_VSMG5_1348 MG1_X_9139_Y_7840 MSMG5_X_9139_Y_7840 714.7m
R_VSMG5_1349 MG1_X_9139_Y_8400 MSMG5_X_9139_Y_8400 714.7m
R_VSMG5_1350 MG1_X_9139_Y_8960 MSMG5_X_9139_Y_8960 714.7m
R_VSMG5_1351 MG1_X_9139_Y_9520 MSMG5_X_9139_Y_9520 714.7m
R_VSMG5_1352 MG1_X_9408_Y_0 MSMG5_X_9408_Y_0 714.7m
R_VSMG5_1353 MG1_X_9408_Y_560 MSMG5_X_9408_Y_560 714.7m
R_VSMG5_1354 MG1_X_9408_Y_1120 MSMG5_X_9408_Y_1120 714.7m
R_VSMG5_1355 MG1_X_9408_Y_1680 MSMG5_X_9408_Y_1680 714.7m
R_VSMG5_1356 MG1_X_9408_Y_2240 MSMG5_X_9408_Y_2240 714.7m
R_VSMG5_1357 MG1_X_9408_Y_2800 MSMG5_X_9408_Y_2800 714.7m
R_VSMG5_1358 MG1_X_9408_Y_3360 MSMG5_X_9408_Y_3360 714.7m
R_VSMG5_1359 MG1_X_9408_Y_3920 MSMG5_X_9408_Y_3920 714.7m
R_VSMG5_1360 MG1_X_9408_Y_4480 MSMG5_X_9408_Y_4480 714.7m
R_VSMG5_1361 MG1_X_9408_Y_5040 MSMG5_X_9408_Y_5040 714.7m
R_VSMG5_1362 MG1_X_9408_Y_5600 MSMG5_X_9408_Y_5600 714.7m
R_VSMG5_1363 MG1_X_9408_Y_6160 MSMG5_X_9408_Y_6160 714.7m
R_VSMG5_1364 MG1_X_9408_Y_6720 MSMG5_X_9408_Y_6720 714.7m
R_VSMG5_1365 MG1_X_9408_Y_7280 MSMG5_X_9408_Y_7280 714.7m
R_VSMG5_1366 MG1_X_9408_Y_7840 MSMG5_X_9408_Y_7840 714.7m
R_VSMG5_1367 MG1_X_9408_Y_8400 MSMG5_X_9408_Y_8400 714.7m
R_VSMG5_1368 MG1_X_9408_Y_8960 MSMG5_X_9408_Y_8960 714.7m
R_VSMG5_1369 MG1_X_9408_Y_9520 MSMG5_X_9408_Y_9520 714.7m
R_VSMG5_1370 MG1_X_9676_Y_0 MSMG5_X_9676_Y_0 714.7m
R_VSMG5_1371 MG1_X_9676_Y_560 MSMG5_X_9676_Y_560 714.7m
R_VSMG5_1372 MG1_X_9676_Y_1120 MSMG5_X_9676_Y_1120 714.7m
R_VSMG5_1373 MG1_X_9676_Y_1680 MSMG5_X_9676_Y_1680 714.7m
R_VSMG5_1374 MG1_X_9676_Y_2240 MSMG5_X_9676_Y_2240 714.7m
R_VSMG5_1375 MG1_X_9676_Y_2800 MSMG5_X_9676_Y_2800 714.7m
R_VSMG5_1376 MG1_X_9676_Y_3360 MSMG5_X_9676_Y_3360 714.7m
R_VSMG5_1377 MG1_X_9676_Y_3920 MSMG5_X_9676_Y_3920 714.7m
R_VSMG5_1378 MG1_X_9676_Y_4480 MSMG5_X_9676_Y_4480 714.7m
R_VSMG5_1379 MG1_X_9676_Y_5040 MSMG5_X_9676_Y_5040 714.7m
R_VSMG5_1380 MG1_X_9676_Y_5600 MSMG5_X_9676_Y_5600 714.7m
R_VSMG5_1381 MG1_X_9676_Y_6160 MSMG5_X_9676_Y_6160 714.7m
R_VSMG5_1382 MG1_X_9676_Y_6720 MSMG5_X_9676_Y_6720 714.7m
R_VSMG5_1383 MG1_X_9676_Y_7280 MSMG5_X_9676_Y_7280 714.7m
R_VSMG5_1384 MG1_X_9676_Y_7840 MSMG5_X_9676_Y_7840 714.7m
R_VSMG5_1385 MG1_X_9676_Y_8400 MSMG5_X_9676_Y_8400 714.7m
R_VSMG5_1386 MG1_X_9676_Y_8960 MSMG5_X_9676_Y_8960 714.7m
R_VSMG5_1387 MG1_X_9676_Y_9520 MSMG5_X_9676_Y_9520 714.7m
R_VSMG5_1388 MG1_X_9945_Y_0 MSMG5_X_9945_Y_0 714.7m
R_VSMG5_1389 MG1_X_9945_Y_560 MSMG5_X_9945_Y_560 714.7m
R_VSMG5_1390 MG1_X_9945_Y_1120 MSMG5_X_9945_Y_1120 714.7m
R_VSMG5_1391 MG1_X_9945_Y_1680 MSMG5_X_9945_Y_1680 714.7m
R_VSMG5_1392 MG1_X_9945_Y_2240 MSMG5_X_9945_Y_2240 714.7m
R_VSMG5_1393 MG1_X_9945_Y_2800 MSMG5_X_9945_Y_2800 714.7m
R_VSMG5_1394 MG1_X_9945_Y_3360 MSMG5_X_9945_Y_3360 714.7m
R_VSMG5_1395 MG1_X_9945_Y_3920 MSMG5_X_9945_Y_3920 714.7m
R_VSMG5_1396 MG1_X_9945_Y_4480 MSMG5_X_9945_Y_4480 714.7m
R_VSMG5_1397 MG1_X_9945_Y_5040 MSMG5_X_9945_Y_5040 714.7m
R_VSMG5_1398 MG1_X_9945_Y_5600 MSMG5_X_9945_Y_5600 714.7m
R_VSMG5_1399 MG1_X_9945_Y_6160 MSMG5_X_9945_Y_6160 714.7m
R_VSMG5_1400 MG1_X_9945_Y_6720 MSMG5_X_9945_Y_6720 714.7m
R_VSMG5_1401 MG1_X_9945_Y_7280 MSMG5_X_9945_Y_7280 714.7m
R_VSMG5_1402 MG1_X_9945_Y_7840 MSMG5_X_9945_Y_7840 714.7m
R_VSMG5_1403 MG1_X_9945_Y_8400 MSMG5_X_9945_Y_8400 714.7m
R_VSMG5_1404 MG1_X_9945_Y_8960 MSMG5_X_9945_Y_8960 714.7m
R_VSMG5_1405 MG1_X_9945_Y_9520 MSMG5_X_9945_Y_9520 714.7m
R_VSMG4_1406 MSMG5_X_0_Y_0 MSMG4_X_0_Y_0 714.7m
R_VSMG4_1407 MSMG5_X_0_Y_560 MSMG4_X_0_Y_560 714.7m
R_VSMG4_1408 MSMG5_X_0_Y_1120 MSMG4_X_0_Y_1120 714.7m
R_VSMG4_1409 MSMG5_X_0_Y_1680 MSMG4_X_0_Y_1680 714.7m
R_VSMG4_1410 MSMG5_X_0_Y_2240 MSMG4_X_0_Y_2240 714.7m
R_VSMG4_1411 MSMG5_X_0_Y_2800 MSMG4_X_0_Y_2800 714.7m
R_VSMG4_1412 MSMG5_X_0_Y_3360 MSMG4_X_0_Y_3360 714.7m
R_VSMG4_1413 MSMG5_X_0_Y_3920 MSMG4_X_0_Y_3920 714.7m
R_VSMG4_1414 MSMG5_X_0_Y_4480 MSMG4_X_0_Y_4480 714.7m
R_VSMG4_1415 MSMG5_X_0_Y_5040 MSMG4_X_0_Y_5040 714.7m
R_VSMG4_1416 MSMG5_X_0_Y_5600 MSMG4_X_0_Y_5600 714.7m
R_VSMG4_1417 MSMG5_X_0_Y_6160 MSMG4_X_0_Y_6160 714.7m
R_VSMG4_1418 MSMG5_X_0_Y_6720 MSMG4_X_0_Y_6720 714.7m
R_VSMG4_1419 MSMG5_X_0_Y_7280 MSMG4_X_0_Y_7280 714.7m
R_VSMG4_1420 MSMG5_X_0_Y_7840 MSMG4_X_0_Y_7840 714.7m
R_VSMG4_1421 MSMG5_X_0_Y_8400 MSMG4_X_0_Y_8400 714.7m
R_VSMG4_1422 MSMG5_X_0_Y_8960 MSMG4_X_0_Y_8960 714.7m
R_VSMG4_1423 MSMG5_X_0_Y_9520 MSMG4_X_0_Y_9520 714.7m
R_VSMG3_1424 MSMG4_X_0_Y_0 MSMG3_X_0_Y_0 714.7m
R_VSMG3_1425 MSMG4_X_0_Y_1120 MSMG3_X_0_Y_1120 714.7m
R_VSMG3_1426 MSMG4_X_0_Y_2240 MSMG3_X_0_Y_2240 714.7m
R_VSMG3_1427 MSMG4_X_0_Y_3360 MSMG3_X_0_Y_3360 714.7m
R_VSMG3_1428 MSMG4_X_0_Y_4480 MSMG3_X_0_Y_4480 714.7m
R_VSMG3_1429 MSMG4_X_0_Y_5600 MSMG3_X_0_Y_5600 714.7m
R_VSMG3_1430 MSMG4_X_0_Y_6720 MSMG3_X_0_Y_6720 714.7m
R_VSMG3_1431 MSMG4_X_0_Y_7840 MSMG3_X_0_Y_7840 714.7m
R_VSMG3_1432 MSMG4_X_0_Y_8960 MSMG3_X_0_Y_8960 714.7m
R_VSMG3_1433 MSMG4_X_560_Y_560 MSMG3_X_560_Y_560 714.7m
R_VSMG3_1434 MSMG4_X_560_Y_1680 MSMG3_X_560_Y_1680 714.7m
R_VSMG3_1435 MSMG4_X_560_Y_2800 MSMG3_X_560_Y_2800 714.7m
R_VSMG3_1436 MSMG4_X_560_Y_3920 MSMG3_X_560_Y_3920 714.7m
R_VSMG3_1437 MSMG4_X_560_Y_5040 MSMG3_X_560_Y_5040 714.7m
R_VSMG3_1438 MSMG4_X_560_Y_6160 MSMG3_X_560_Y_6160 714.7m
R_VSMG3_1439 MSMG4_X_560_Y_7280 MSMG3_X_560_Y_7280 714.7m
R_VSMG3_1440 MSMG4_X_560_Y_8400 MSMG3_X_560_Y_8400 714.7m
R_VSMG3_1441 MSMG4_X_560_Y_9520 MSMG3_X_560_Y_9520 714.7m
R_VSMG3_1442 MSMG4_X_1120_Y_0 MSMG3_X_1120_Y_0 714.7m
R_VSMG3_1443 MSMG4_X_1120_Y_1120 MSMG3_X_1120_Y_1120 714.7m
R_VSMG3_1444 MSMG4_X_1120_Y_2240 MSMG3_X_1120_Y_2240 714.7m
R_VSMG3_1445 MSMG4_X_1120_Y_3360 MSMG3_X_1120_Y_3360 714.7m
R_VSMG3_1446 MSMG4_X_1120_Y_4480 MSMG3_X_1120_Y_4480 714.7m
R_VSMG3_1447 MSMG4_X_1120_Y_5600 MSMG3_X_1120_Y_5600 714.7m
R_VSMG3_1448 MSMG4_X_1120_Y_6720 MSMG3_X_1120_Y_6720 714.7m
R_VSMG3_1449 MSMG4_X_1120_Y_7840 MSMG3_X_1120_Y_7840 714.7m
R_VSMG3_1450 MSMG4_X_1120_Y_8960 MSMG3_X_1120_Y_8960 714.7m
R_VSMG3_1451 MSMG4_X_1680_Y_560 MSMG3_X_1680_Y_560 714.7m
R_VSMG3_1452 MSMG4_X_1680_Y_1680 MSMG3_X_1680_Y_1680 714.7m
R_VSMG3_1453 MSMG4_X_1680_Y_2800 MSMG3_X_1680_Y_2800 714.7m
R_VSMG3_1454 MSMG4_X_1680_Y_3920 MSMG3_X_1680_Y_3920 714.7m
R_VSMG3_1455 MSMG4_X_1680_Y_5040 MSMG3_X_1680_Y_5040 714.7m
R_VSMG3_1456 MSMG4_X_1680_Y_6160 MSMG3_X_1680_Y_6160 714.7m
R_VSMG3_1457 MSMG4_X_1680_Y_7280 MSMG3_X_1680_Y_7280 714.7m
R_VSMG3_1458 MSMG4_X_1680_Y_8400 MSMG3_X_1680_Y_8400 714.7m
R_VSMG3_1459 MSMG4_X_1680_Y_9520 MSMG3_X_1680_Y_9520 714.7m
R_VSMG3_1460 MSMG4_X_2240_Y_0 MSMG3_X_2240_Y_0 714.7m
R_VSMG3_1461 MSMG4_X_2240_Y_1120 MSMG3_X_2240_Y_1120 714.7m
R_VSMG3_1462 MSMG4_X_2240_Y_2240 MSMG3_X_2240_Y_2240 714.7m
R_VSMG3_1463 MSMG4_X_2240_Y_3360 MSMG3_X_2240_Y_3360 714.7m
R_VSMG3_1464 MSMG4_X_2240_Y_4480 MSMG3_X_2240_Y_4480 714.7m
R_VSMG3_1465 MSMG4_X_2240_Y_5600 MSMG3_X_2240_Y_5600 714.7m
R_VSMG3_1466 MSMG4_X_2240_Y_6720 MSMG3_X_2240_Y_6720 714.7m
R_VSMG3_1467 MSMG4_X_2240_Y_7840 MSMG3_X_2240_Y_7840 714.7m
R_VSMG3_1468 MSMG4_X_2240_Y_8960 MSMG3_X_2240_Y_8960 714.7m
R_VSMG3_1469 MSMG4_X_2800_Y_560 MSMG3_X_2800_Y_560 714.7m
R_VSMG3_1470 MSMG4_X_2800_Y_1680 MSMG3_X_2800_Y_1680 714.7m
R_VSMG3_1471 MSMG4_X_2800_Y_2800 MSMG3_X_2800_Y_2800 714.7m
R_VSMG3_1472 MSMG4_X_2800_Y_3920 MSMG3_X_2800_Y_3920 714.7m
R_VSMG3_1473 MSMG4_X_2800_Y_5040 MSMG3_X_2800_Y_5040 714.7m
R_VSMG3_1474 MSMG4_X_2800_Y_6160 MSMG3_X_2800_Y_6160 714.7m
R_VSMG3_1475 MSMG4_X_2800_Y_7280 MSMG3_X_2800_Y_7280 714.7m
R_VSMG3_1476 MSMG4_X_2800_Y_8400 MSMG3_X_2800_Y_8400 714.7m
R_VSMG3_1477 MSMG4_X_2800_Y_9520 MSMG3_X_2800_Y_9520 714.7m
R_VSMG3_1478 MSMG4_X_3360_Y_0 MSMG3_X_3360_Y_0 714.7m
R_VSMG3_1479 MSMG4_X_3360_Y_1120 MSMG3_X_3360_Y_1120 714.7m
R_VSMG3_1480 MSMG4_X_3360_Y_2240 MSMG3_X_3360_Y_2240 714.7m
R_VSMG3_1481 MSMG4_X_3360_Y_3360 MSMG3_X_3360_Y_3360 714.7m
R_VSMG3_1482 MSMG4_X_3360_Y_4480 MSMG3_X_3360_Y_4480 714.7m
R_VSMG3_1483 MSMG4_X_3360_Y_5600 MSMG3_X_3360_Y_5600 714.7m
R_VSMG3_1484 MSMG4_X_3360_Y_6720 MSMG3_X_3360_Y_6720 714.7m
R_VSMG3_1485 MSMG4_X_3360_Y_7840 MSMG3_X_3360_Y_7840 714.7m
R_VSMG3_1486 MSMG4_X_3360_Y_8960 MSMG3_X_3360_Y_8960 714.7m
R_VSMG3_1487 MSMG4_X_3920_Y_560 MSMG3_X_3920_Y_560 714.7m
R_VSMG3_1488 MSMG4_X_3920_Y_1680 MSMG3_X_3920_Y_1680 714.7m
R_VSMG3_1489 MSMG4_X_3920_Y_2800 MSMG3_X_3920_Y_2800 714.7m
R_VSMG3_1490 MSMG4_X_3920_Y_3920 MSMG3_X_3920_Y_3920 714.7m
R_VSMG3_1491 MSMG4_X_3920_Y_5040 MSMG3_X_3920_Y_5040 714.7m
R_VSMG3_1492 MSMG4_X_3920_Y_6160 MSMG3_X_3920_Y_6160 714.7m
R_VSMG3_1493 MSMG4_X_3920_Y_7280 MSMG3_X_3920_Y_7280 714.7m
R_VSMG3_1494 MSMG4_X_3920_Y_8400 MSMG3_X_3920_Y_8400 714.7m
R_VSMG3_1495 MSMG4_X_3920_Y_9520 MSMG3_X_3920_Y_9520 714.7m
R_VSMG3_1496 MSMG4_X_4480_Y_0 MSMG3_X_4480_Y_0 714.7m
R_VSMG3_1497 MSMG4_X_4480_Y_1120 MSMG3_X_4480_Y_1120 714.7m
R_VSMG3_1498 MSMG4_X_4480_Y_2240 MSMG3_X_4480_Y_2240 714.7m
R_VSMG3_1499 MSMG4_X_4480_Y_3360 MSMG3_X_4480_Y_3360 714.7m
R_VSMG3_1500 MSMG4_X_4480_Y_4480 MSMG3_X_4480_Y_4480 714.7m
R_VSMG3_1501 MSMG4_X_4480_Y_5600 MSMG3_X_4480_Y_5600 714.7m
R_VSMG3_1502 MSMG4_X_4480_Y_6720 MSMG3_X_4480_Y_6720 714.7m
R_VSMG3_1503 MSMG4_X_4480_Y_7840 MSMG3_X_4480_Y_7840 714.7m
R_VSMG3_1504 MSMG4_X_4480_Y_8960 MSMG3_X_4480_Y_8960 714.7m
R_VSMG3_1505 MSMG4_X_5040_Y_560 MSMG3_X_5040_Y_560 714.7m
R_VSMG3_1506 MSMG4_X_5040_Y_1680 MSMG3_X_5040_Y_1680 714.7m
R_VSMG3_1507 MSMG4_X_5040_Y_2800 MSMG3_X_5040_Y_2800 714.7m
R_VSMG3_1508 MSMG4_X_5040_Y_3920 MSMG3_X_5040_Y_3920 714.7m
R_VSMG3_1509 MSMG4_X_5040_Y_5040 MSMG3_X_5040_Y_5040 714.7m
R_VSMG3_1510 MSMG4_X_5040_Y_6160 MSMG3_X_5040_Y_6160 714.7m
R_VSMG3_1511 MSMG4_X_5040_Y_7280 MSMG3_X_5040_Y_7280 714.7m
R_VSMG3_1512 MSMG4_X_5040_Y_8400 MSMG3_X_5040_Y_8400 714.7m
R_VSMG3_1513 MSMG4_X_5040_Y_9520 MSMG3_X_5040_Y_9520 714.7m
R_VSMG3_1514 MSMG4_X_5600_Y_0 MSMG3_X_5600_Y_0 714.7m
R_VSMG3_1515 MSMG4_X_5600_Y_1120 MSMG3_X_5600_Y_1120 714.7m
R_VSMG3_1516 MSMG4_X_5600_Y_2240 MSMG3_X_5600_Y_2240 714.7m
R_VSMG3_1517 MSMG4_X_5600_Y_3360 MSMG3_X_5600_Y_3360 714.7m
R_VSMG3_1518 MSMG4_X_5600_Y_4480 MSMG3_X_5600_Y_4480 714.7m
R_VSMG3_1519 MSMG4_X_5600_Y_5600 MSMG3_X_5600_Y_5600 714.7m
R_VSMG3_1520 MSMG4_X_5600_Y_6720 MSMG3_X_5600_Y_6720 714.7m
R_VSMG3_1521 MSMG4_X_5600_Y_7840 MSMG3_X_5600_Y_7840 714.7m
R_VSMG3_1522 MSMG4_X_5600_Y_8960 MSMG3_X_5600_Y_8960 714.7m
R_VSMG3_1523 MSMG4_X_6160_Y_560 MSMG3_X_6160_Y_560 714.7m
R_VSMG3_1524 MSMG4_X_6160_Y_1680 MSMG3_X_6160_Y_1680 714.7m
R_VSMG3_1525 MSMG4_X_6160_Y_2800 MSMG3_X_6160_Y_2800 714.7m
R_VSMG3_1526 MSMG4_X_6160_Y_3920 MSMG3_X_6160_Y_3920 714.7m
R_VSMG3_1527 MSMG4_X_6160_Y_5040 MSMG3_X_6160_Y_5040 714.7m
R_VSMG3_1528 MSMG4_X_6160_Y_6160 MSMG3_X_6160_Y_6160 714.7m
R_VSMG3_1529 MSMG4_X_6160_Y_7280 MSMG3_X_6160_Y_7280 714.7m
R_VSMG3_1530 MSMG4_X_6160_Y_8400 MSMG3_X_6160_Y_8400 714.7m
R_VSMG3_1531 MSMG4_X_6160_Y_9520 MSMG3_X_6160_Y_9520 714.7m
R_VSMG3_1532 MSMG4_X_6720_Y_0 MSMG3_X_6720_Y_0 714.7m
R_VSMG3_1533 MSMG4_X_6720_Y_1120 MSMG3_X_6720_Y_1120 714.7m
R_VSMG3_1534 MSMG4_X_6720_Y_2240 MSMG3_X_6720_Y_2240 714.7m
R_VSMG3_1535 MSMG4_X_6720_Y_3360 MSMG3_X_6720_Y_3360 714.7m
R_VSMG3_1536 MSMG4_X_6720_Y_4480 MSMG3_X_6720_Y_4480 714.7m
R_VSMG3_1537 MSMG4_X_6720_Y_5600 MSMG3_X_6720_Y_5600 714.7m
R_VSMG3_1538 MSMG4_X_6720_Y_6720 MSMG3_X_6720_Y_6720 714.7m
R_VSMG3_1539 MSMG4_X_6720_Y_7840 MSMG3_X_6720_Y_7840 714.7m
R_VSMG3_1540 MSMG4_X_6720_Y_8960 MSMG3_X_6720_Y_8960 714.7m
R_VSMG3_1541 MSMG4_X_7280_Y_560 MSMG3_X_7280_Y_560 714.7m
R_VSMG3_1542 MSMG4_X_7280_Y_1680 MSMG3_X_7280_Y_1680 714.7m
R_VSMG3_1543 MSMG4_X_7280_Y_2800 MSMG3_X_7280_Y_2800 714.7m
R_VSMG3_1544 MSMG4_X_7280_Y_3920 MSMG3_X_7280_Y_3920 714.7m
R_VSMG3_1545 MSMG4_X_7280_Y_5040 MSMG3_X_7280_Y_5040 714.7m
R_VSMG3_1546 MSMG4_X_7280_Y_6160 MSMG3_X_7280_Y_6160 714.7m
R_VSMG3_1547 MSMG4_X_7280_Y_7280 MSMG3_X_7280_Y_7280 714.7m
R_VSMG3_1548 MSMG4_X_7280_Y_8400 MSMG3_X_7280_Y_8400 714.7m
R_VSMG3_1549 MSMG4_X_7280_Y_9520 MSMG3_X_7280_Y_9520 714.7m
R_VSMG3_1550 MSMG4_X_7840_Y_0 MSMG3_X_7840_Y_0 714.7m
R_VSMG3_1551 MSMG4_X_7840_Y_1120 MSMG3_X_7840_Y_1120 714.7m
R_VSMG3_1552 MSMG4_X_7840_Y_2240 MSMG3_X_7840_Y_2240 714.7m
R_VSMG3_1553 MSMG4_X_7840_Y_3360 MSMG3_X_7840_Y_3360 714.7m
R_VSMG3_1554 MSMG4_X_7840_Y_4480 MSMG3_X_7840_Y_4480 714.7m
R_VSMG3_1555 MSMG4_X_7840_Y_5600 MSMG3_X_7840_Y_5600 714.7m
R_VSMG3_1556 MSMG4_X_7840_Y_6720 MSMG3_X_7840_Y_6720 714.7m
R_VSMG3_1557 MSMG4_X_7840_Y_7840 MSMG3_X_7840_Y_7840 714.7m
R_VSMG3_1558 MSMG4_X_7840_Y_8960 MSMG3_X_7840_Y_8960 714.7m
R_VSMG3_1559 MSMG4_X_8400_Y_560 MSMG3_X_8400_Y_560 714.7m
R_VSMG3_1560 MSMG4_X_8400_Y_1680 MSMG3_X_8400_Y_1680 714.7m
R_VSMG3_1561 MSMG4_X_8400_Y_2800 MSMG3_X_8400_Y_2800 714.7m
R_VSMG3_1562 MSMG4_X_8400_Y_3920 MSMG3_X_8400_Y_3920 714.7m
R_VSMG3_1563 MSMG4_X_8400_Y_5040 MSMG3_X_8400_Y_5040 714.7m
R_VSMG3_1564 MSMG4_X_8400_Y_6160 MSMG3_X_8400_Y_6160 714.7m
R_VSMG3_1565 MSMG4_X_8400_Y_7280 MSMG3_X_8400_Y_7280 714.7m
R_VSMG3_1566 MSMG4_X_8400_Y_8400 MSMG3_X_8400_Y_8400 714.7m
R_VSMG3_1567 MSMG4_X_8400_Y_9520 MSMG3_X_8400_Y_9520 714.7m
R_VSMG3_1568 MSMG4_X_8960_Y_0 MSMG3_X_8960_Y_0 714.7m
R_VSMG3_1569 MSMG4_X_8960_Y_1120 MSMG3_X_8960_Y_1120 714.7m
R_VSMG3_1570 MSMG4_X_8960_Y_2240 MSMG3_X_8960_Y_2240 714.7m
R_VSMG3_1571 MSMG4_X_8960_Y_3360 MSMG3_X_8960_Y_3360 714.7m
R_VSMG3_1572 MSMG4_X_8960_Y_4480 MSMG3_X_8960_Y_4480 714.7m
R_VSMG3_1573 MSMG4_X_8960_Y_5600 MSMG3_X_8960_Y_5600 714.7m
R_VSMG3_1574 MSMG4_X_8960_Y_6720 MSMG3_X_8960_Y_6720 714.7m
R_VSMG3_1575 MSMG4_X_8960_Y_7840 MSMG3_X_8960_Y_7840 714.7m
R_VSMG3_1576 MSMG4_X_8960_Y_8960 MSMG3_X_8960_Y_8960 714.7m
R_VSMG3_1577 MSMG4_X_9520_Y_560 MSMG3_X_9520_Y_560 714.7m
R_VSMG3_1578 MSMG4_X_9520_Y_1680 MSMG3_X_9520_Y_1680 714.7m
R_VSMG3_1579 MSMG4_X_9520_Y_2800 MSMG3_X_9520_Y_2800 714.7m
R_VSMG3_1580 MSMG4_X_9520_Y_3920 MSMG3_X_9520_Y_3920 714.7m
R_VSMG3_1581 MSMG4_X_9520_Y_5040 MSMG3_X_9520_Y_5040 714.7m
R_VSMG3_1582 MSMG4_X_9520_Y_6160 MSMG3_X_9520_Y_6160 714.7m
R_VSMG3_1583 MSMG4_X_9520_Y_7280 MSMG3_X_9520_Y_7280 714.7m
R_VSMG3_1584 MSMG4_X_9520_Y_8400 MSMG3_X_9520_Y_8400 714.7m
R_VSMG3_1585 MSMG4_X_9520_Y_9520 MSMG3_X_9520_Y_9520 714.7m
R_VSMG2_1586 MSMG3_X_0_Y_0 MSMG2_X_0_Y_0 714.7m
R_VSMG2_1587 MSMG3_X_0_Y_560 MSMG2_X_0_Y_560 714.7m
R_VSMG2_1588 MSMG3_X_0_Y_1120 MSMG2_X_0_Y_1120 714.7m
R_VSMG2_1589 MSMG3_X_0_Y_1680 MSMG2_X_0_Y_1680 714.7m
R_VSMG2_1590 MSMG3_X_0_Y_2240 MSMG2_X_0_Y_2240 714.7m
R_VSMG2_1591 MSMG3_X_0_Y_2800 MSMG2_X_0_Y_2800 714.7m
R_VSMG2_1592 MSMG3_X_0_Y_3360 MSMG2_X_0_Y_3360 714.7m
R_VSMG2_1593 MSMG3_X_0_Y_3920 MSMG2_X_0_Y_3920 714.7m
R_VSMG2_1594 MSMG3_X_0_Y_4480 MSMG2_X_0_Y_4480 714.7m
R_VSMG2_1595 MSMG3_X_0_Y_5040 MSMG2_X_0_Y_5040 714.7m
R_VSMG2_1596 MSMG3_X_0_Y_5600 MSMG2_X_0_Y_5600 714.7m
R_VSMG2_1597 MSMG3_X_0_Y_6160 MSMG2_X_0_Y_6160 714.7m
R_VSMG2_1598 MSMG3_X_0_Y_6720 MSMG2_X_0_Y_6720 714.7m
R_VSMG2_1599 MSMG3_X_0_Y_7280 MSMG2_X_0_Y_7280 714.7m
R_VSMG2_1600 MSMG3_X_0_Y_7840 MSMG2_X_0_Y_7840 714.7m
R_VSMG2_1601 MSMG3_X_0_Y_8400 MSMG2_X_0_Y_8400 714.7m
R_VSMG2_1602 MSMG3_X_0_Y_8960 MSMG2_X_0_Y_8960 714.7m
R_VSMG2_1603 MSMG3_X_0_Y_9520 MSMG2_X_0_Y_9520 714.7m
R_VSMG2_1604 MSMG3_X_560_Y_0 MSMG2_X_560_Y_0 714.7m
R_VSMG2_1605 MSMG3_X_560_Y_560 MSMG2_X_560_Y_560 714.7m
R_VSMG2_1606 MSMG3_X_560_Y_1120 MSMG2_X_560_Y_1120 714.7m
R_VSMG2_1607 MSMG3_X_560_Y_1680 MSMG2_X_560_Y_1680 714.7m
R_VSMG2_1608 MSMG3_X_560_Y_2240 MSMG2_X_560_Y_2240 714.7m
R_VSMG2_1609 MSMG3_X_560_Y_2800 MSMG2_X_560_Y_2800 714.7m
R_VSMG2_1610 MSMG3_X_560_Y_3360 MSMG2_X_560_Y_3360 714.7m
R_VSMG2_1611 MSMG3_X_560_Y_3920 MSMG2_X_560_Y_3920 714.7m
R_VSMG2_1612 MSMG3_X_560_Y_4480 MSMG2_X_560_Y_4480 714.7m
R_VSMG2_1613 MSMG3_X_560_Y_5040 MSMG2_X_560_Y_5040 714.7m
R_VSMG2_1614 MSMG3_X_560_Y_5600 MSMG2_X_560_Y_5600 714.7m
R_VSMG2_1615 MSMG3_X_560_Y_6160 MSMG2_X_560_Y_6160 714.7m
R_VSMG2_1616 MSMG3_X_560_Y_6720 MSMG2_X_560_Y_6720 714.7m
R_VSMG2_1617 MSMG3_X_560_Y_7280 MSMG2_X_560_Y_7280 714.7m
R_VSMG2_1618 MSMG3_X_560_Y_7840 MSMG2_X_560_Y_7840 714.7m
R_VSMG2_1619 MSMG3_X_560_Y_8400 MSMG2_X_560_Y_8400 714.7m
R_VSMG2_1620 MSMG3_X_560_Y_8960 MSMG2_X_560_Y_8960 714.7m
R_VSMG2_1621 MSMG3_X_560_Y_9520 MSMG2_X_560_Y_9520 714.7m
R_VSMG2_1622 MSMG3_X_1120_Y_0 MSMG2_X_1120_Y_0 714.7m
R_VSMG2_1623 MSMG3_X_1120_Y_560 MSMG2_X_1120_Y_560 714.7m
R_VSMG2_1624 MSMG3_X_1120_Y_1120 MSMG2_X_1120_Y_1120 714.7m
R_VSMG2_1625 MSMG3_X_1120_Y_1680 MSMG2_X_1120_Y_1680 714.7m
R_VSMG2_1626 MSMG3_X_1120_Y_2240 MSMG2_X_1120_Y_2240 714.7m
R_VSMG2_1627 MSMG3_X_1120_Y_2800 MSMG2_X_1120_Y_2800 714.7m
R_VSMG2_1628 MSMG3_X_1120_Y_3360 MSMG2_X_1120_Y_3360 714.7m
R_VSMG2_1629 MSMG3_X_1120_Y_3920 MSMG2_X_1120_Y_3920 714.7m
R_VSMG2_1630 MSMG3_X_1120_Y_4480 MSMG2_X_1120_Y_4480 714.7m
R_VSMG2_1631 MSMG3_X_1120_Y_5040 MSMG2_X_1120_Y_5040 714.7m
R_VSMG2_1632 MSMG3_X_1120_Y_5600 MSMG2_X_1120_Y_5600 714.7m
R_VSMG2_1633 MSMG3_X_1120_Y_6160 MSMG2_X_1120_Y_6160 714.7m
R_VSMG2_1634 MSMG3_X_1120_Y_6720 MSMG2_X_1120_Y_6720 714.7m
R_VSMG2_1635 MSMG3_X_1120_Y_7280 MSMG2_X_1120_Y_7280 714.7m
R_VSMG2_1636 MSMG3_X_1120_Y_7840 MSMG2_X_1120_Y_7840 714.7m
R_VSMG2_1637 MSMG3_X_1120_Y_8400 MSMG2_X_1120_Y_8400 714.7m
R_VSMG2_1638 MSMG3_X_1120_Y_8960 MSMG2_X_1120_Y_8960 714.7m
R_VSMG2_1639 MSMG3_X_1120_Y_9520 MSMG2_X_1120_Y_9520 714.7m
R_VSMG2_1640 MSMG3_X_1680_Y_0 MSMG2_X_1680_Y_0 714.7m
R_VSMG2_1641 MSMG3_X_1680_Y_560 MSMG2_X_1680_Y_560 714.7m
R_VSMG2_1642 MSMG3_X_1680_Y_1120 MSMG2_X_1680_Y_1120 714.7m
R_VSMG2_1643 MSMG3_X_1680_Y_1680 MSMG2_X_1680_Y_1680 714.7m
R_VSMG2_1644 MSMG3_X_1680_Y_2240 MSMG2_X_1680_Y_2240 714.7m
R_VSMG2_1645 MSMG3_X_1680_Y_2800 MSMG2_X_1680_Y_2800 714.7m
R_VSMG2_1646 MSMG3_X_1680_Y_3360 MSMG2_X_1680_Y_3360 714.7m
R_VSMG2_1647 MSMG3_X_1680_Y_3920 MSMG2_X_1680_Y_3920 714.7m
R_VSMG2_1648 MSMG3_X_1680_Y_4480 MSMG2_X_1680_Y_4480 714.7m
R_VSMG2_1649 MSMG3_X_1680_Y_5040 MSMG2_X_1680_Y_5040 714.7m
R_VSMG2_1650 MSMG3_X_1680_Y_5600 MSMG2_X_1680_Y_5600 714.7m
R_VSMG2_1651 MSMG3_X_1680_Y_6160 MSMG2_X_1680_Y_6160 714.7m
R_VSMG2_1652 MSMG3_X_1680_Y_6720 MSMG2_X_1680_Y_6720 714.7m
R_VSMG2_1653 MSMG3_X_1680_Y_7280 MSMG2_X_1680_Y_7280 714.7m
R_VSMG2_1654 MSMG3_X_1680_Y_7840 MSMG2_X_1680_Y_7840 714.7m
R_VSMG2_1655 MSMG3_X_1680_Y_8400 MSMG2_X_1680_Y_8400 714.7m
R_VSMG2_1656 MSMG3_X_1680_Y_8960 MSMG2_X_1680_Y_8960 714.7m
R_VSMG2_1657 MSMG3_X_1680_Y_9520 MSMG2_X_1680_Y_9520 714.7m
R_VSMG2_1658 MSMG3_X_2240_Y_0 MSMG2_X_2240_Y_0 714.7m
R_VSMG2_1659 MSMG3_X_2240_Y_560 MSMG2_X_2240_Y_560 714.7m
R_VSMG2_1660 MSMG3_X_2240_Y_1120 MSMG2_X_2240_Y_1120 714.7m
R_VSMG2_1661 MSMG3_X_2240_Y_1680 MSMG2_X_2240_Y_1680 714.7m
R_VSMG2_1662 MSMG3_X_2240_Y_2240 MSMG2_X_2240_Y_2240 714.7m
R_VSMG2_1663 MSMG3_X_2240_Y_2800 MSMG2_X_2240_Y_2800 714.7m
R_VSMG2_1664 MSMG3_X_2240_Y_3360 MSMG2_X_2240_Y_3360 714.7m
R_VSMG2_1665 MSMG3_X_2240_Y_3920 MSMG2_X_2240_Y_3920 714.7m
R_VSMG2_1666 MSMG3_X_2240_Y_4480 MSMG2_X_2240_Y_4480 714.7m
R_VSMG2_1667 MSMG3_X_2240_Y_5040 MSMG2_X_2240_Y_5040 714.7m
R_VSMG2_1668 MSMG3_X_2240_Y_5600 MSMG2_X_2240_Y_5600 714.7m
R_VSMG2_1669 MSMG3_X_2240_Y_6160 MSMG2_X_2240_Y_6160 714.7m
R_VSMG2_1670 MSMG3_X_2240_Y_6720 MSMG2_X_2240_Y_6720 714.7m
R_VSMG2_1671 MSMG3_X_2240_Y_7280 MSMG2_X_2240_Y_7280 714.7m
R_VSMG2_1672 MSMG3_X_2240_Y_7840 MSMG2_X_2240_Y_7840 714.7m
R_VSMG2_1673 MSMG3_X_2240_Y_8400 MSMG2_X_2240_Y_8400 714.7m
R_VSMG2_1674 MSMG3_X_2240_Y_8960 MSMG2_X_2240_Y_8960 714.7m
R_VSMG2_1675 MSMG3_X_2240_Y_9520 MSMG2_X_2240_Y_9520 714.7m
R_VSMG2_1676 MSMG3_X_2800_Y_0 MSMG2_X_2800_Y_0 714.7m
R_VSMG2_1677 MSMG3_X_2800_Y_560 MSMG2_X_2800_Y_560 714.7m
R_VSMG2_1678 MSMG3_X_2800_Y_1120 MSMG2_X_2800_Y_1120 714.7m
R_VSMG2_1679 MSMG3_X_2800_Y_1680 MSMG2_X_2800_Y_1680 714.7m
R_VSMG2_1680 MSMG3_X_2800_Y_2240 MSMG2_X_2800_Y_2240 714.7m
R_VSMG2_1681 MSMG3_X_2800_Y_2800 MSMG2_X_2800_Y_2800 714.7m
R_VSMG2_1682 MSMG3_X_2800_Y_3360 MSMG2_X_2800_Y_3360 714.7m
R_VSMG2_1683 MSMG3_X_2800_Y_3920 MSMG2_X_2800_Y_3920 714.7m
R_VSMG2_1684 MSMG3_X_2800_Y_4480 MSMG2_X_2800_Y_4480 714.7m
R_VSMG2_1685 MSMG3_X_2800_Y_5040 MSMG2_X_2800_Y_5040 714.7m
R_VSMG2_1686 MSMG3_X_2800_Y_5600 MSMG2_X_2800_Y_5600 714.7m
R_VSMG2_1687 MSMG3_X_2800_Y_6160 MSMG2_X_2800_Y_6160 714.7m
R_VSMG2_1688 MSMG3_X_2800_Y_6720 MSMG2_X_2800_Y_6720 714.7m
R_VSMG2_1689 MSMG3_X_2800_Y_7280 MSMG2_X_2800_Y_7280 714.7m
R_VSMG2_1690 MSMG3_X_2800_Y_7840 MSMG2_X_2800_Y_7840 714.7m
R_VSMG2_1691 MSMG3_X_2800_Y_8400 MSMG2_X_2800_Y_8400 714.7m
R_VSMG2_1692 MSMG3_X_2800_Y_8960 MSMG2_X_2800_Y_8960 714.7m
R_VSMG2_1693 MSMG3_X_2800_Y_9520 MSMG2_X_2800_Y_9520 714.7m
R_VSMG2_1694 MSMG3_X_3360_Y_0 MSMG2_X_3360_Y_0 714.7m
R_VSMG2_1695 MSMG3_X_3360_Y_560 MSMG2_X_3360_Y_560 714.7m
R_VSMG2_1696 MSMG3_X_3360_Y_1120 MSMG2_X_3360_Y_1120 714.7m
R_VSMG2_1697 MSMG3_X_3360_Y_1680 MSMG2_X_3360_Y_1680 714.7m
R_VSMG2_1698 MSMG3_X_3360_Y_2240 MSMG2_X_3360_Y_2240 714.7m
R_VSMG2_1699 MSMG3_X_3360_Y_2800 MSMG2_X_3360_Y_2800 714.7m
R_VSMG2_1700 MSMG3_X_3360_Y_3360 MSMG2_X_3360_Y_3360 714.7m
R_VSMG2_1701 MSMG3_X_3360_Y_3920 MSMG2_X_3360_Y_3920 714.7m
R_VSMG2_1702 MSMG3_X_3360_Y_4480 MSMG2_X_3360_Y_4480 714.7m
R_VSMG2_1703 MSMG3_X_3360_Y_5040 MSMG2_X_3360_Y_5040 714.7m
R_VSMG2_1704 MSMG3_X_3360_Y_5600 MSMG2_X_3360_Y_5600 714.7m
R_VSMG2_1705 MSMG3_X_3360_Y_6160 MSMG2_X_3360_Y_6160 714.7m
R_VSMG2_1706 MSMG3_X_3360_Y_6720 MSMG2_X_3360_Y_6720 714.7m
R_VSMG2_1707 MSMG3_X_3360_Y_7280 MSMG2_X_3360_Y_7280 714.7m
R_VSMG2_1708 MSMG3_X_3360_Y_7840 MSMG2_X_3360_Y_7840 714.7m
R_VSMG2_1709 MSMG3_X_3360_Y_8400 MSMG2_X_3360_Y_8400 714.7m
R_VSMG2_1710 MSMG3_X_3360_Y_8960 MSMG2_X_3360_Y_8960 714.7m
R_VSMG2_1711 MSMG3_X_3360_Y_9520 MSMG2_X_3360_Y_9520 714.7m
R_VSMG2_1712 MSMG3_X_3920_Y_0 MSMG2_X_3920_Y_0 714.7m
R_VSMG2_1713 MSMG3_X_3920_Y_560 MSMG2_X_3920_Y_560 714.7m
R_VSMG2_1714 MSMG3_X_3920_Y_1120 MSMG2_X_3920_Y_1120 714.7m
R_VSMG2_1715 MSMG3_X_3920_Y_1680 MSMG2_X_3920_Y_1680 714.7m
R_VSMG2_1716 MSMG3_X_3920_Y_2240 MSMG2_X_3920_Y_2240 714.7m
R_VSMG2_1717 MSMG3_X_3920_Y_2800 MSMG2_X_3920_Y_2800 714.7m
R_VSMG2_1718 MSMG3_X_3920_Y_3360 MSMG2_X_3920_Y_3360 714.7m
R_VSMG2_1719 MSMG3_X_3920_Y_3920 MSMG2_X_3920_Y_3920 714.7m
R_VSMG2_1720 MSMG3_X_3920_Y_4480 MSMG2_X_3920_Y_4480 714.7m
R_VSMG2_1721 MSMG3_X_3920_Y_5040 MSMG2_X_3920_Y_5040 714.7m
R_VSMG2_1722 MSMG3_X_3920_Y_5600 MSMG2_X_3920_Y_5600 714.7m
R_VSMG2_1723 MSMG3_X_3920_Y_6160 MSMG2_X_3920_Y_6160 714.7m
R_VSMG2_1724 MSMG3_X_3920_Y_6720 MSMG2_X_3920_Y_6720 714.7m
R_VSMG2_1725 MSMG3_X_3920_Y_7280 MSMG2_X_3920_Y_7280 714.7m
R_VSMG2_1726 MSMG3_X_3920_Y_7840 MSMG2_X_3920_Y_7840 714.7m
R_VSMG2_1727 MSMG3_X_3920_Y_8400 MSMG2_X_3920_Y_8400 714.7m
R_VSMG2_1728 MSMG3_X_3920_Y_8960 MSMG2_X_3920_Y_8960 714.7m
R_VSMG2_1729 MSMG3_X_3920_Y_9520 MSMG2_X_3920_Y_9520 714.7m
R_VSMG2_1730 MSMG3_X_4480_Y_0 MSMG2_X_4480_Y_0 714.7m
R_VSMG2_1731 MSMG3_X_4480_Y_560 MSMG2_X_4480_Y_560 714.7m
R_VSMG2_1732 MSMG3_X_4480_Y_1120 MSMG2_X_4480_Y_1120 714.7m
R_VSMG2_1733 MSMG3_X_4480_Y_1680 MSMG2_X_4480_Y_1680 714.7m
R_VSMG2_1734 MSMG3_X_4480_Y_2240 MSMG2_X_4480_Y_2240 714.7m
R_VSMG2_1735 MSMG3_X_4480_Y_2800 MSMG2_X_4480_Y_2800 714.7m
R_VSMG2_1736 MSMG3_X_4480_Y_3360 MSMG2_X_4480_Y_3360 714.7m
R_VSMG2_1737 MSMG3_X_4480_Y_3920 MSMG2_X_4480_Y_3920 714.7m
R_VSMG2_1738 MSMG3_X_4480_Y_4480 MSMG2_X_4480_Y_4480 714.7m
R_VSMG2_1739 MSMG3_X_4480_Y_5040 MSMG2_X_4480_Y_5040 714.7m
R_VSMG2_1740 MSMG3_X_4480_Y_5600 MSMG2_X_4480_Y_5600 714.7m
R_VSMG2_1741 MSMG3_X_4480_Y_6160 MSMG2_X_4480_Y_6160 714.7m
R_VSMG2_1742 MSMG3_X_4480_Y_6720 MSMG2_X_4480_Y_6720 714.7m
R_VSMG2_1743 MSMG3_X_4480_Y_7280 MSMG2_X_4480_Y_7280 714.7m
R_VSMG2_1744 MSMG3_X_4480_Y_7840 MSMG2_X_4480_Y_7840 714.7m
R_VSMG2_1745 MSMG3_X_4480_Y_8400 MSMG2_X_4480_Y_8400 714.7m
R_VSMG2_1746 MSMG3_X_4480_Y_8960 MSMG2_X_4480_Y_8960 714.7m
R_VSMG2_1747 MSMG3_X_4480_Y_9520 MSMG2_X_4480_Y_9520 714.7m
R_VSMG2_1748 MSMG3_X_5040_Y_0 MSMG2_X_5040_Y_0 714.7m
R_VSMG2_1749 MSMG3_X_5040_Y_560 MSMG2_X_5040_Y_560 714.7m
R_VSMG2_1750 MSMG3_X_5040_Y_1120 MSMG2_X_5040_Y_1120 714.7m
R_VSMG2_1751 MSMG3_X_5040_Y_1680 MSMG2_X_5040_Y_1680 714.7m
R_VSMG2_1752 MSMG3_X_5040_Y_2240 MSMG2_X_5040_Y_2240 714.7m
R_VSMG2_1753 MSMG3_X_5040_Y_2800 MSMG2_X_5040_Y_2800 714.7m
R_VSMG2_1754 MSMG3_X_5040_Y_3360 MSMG2_X_5040_Y_3360 714.7m
R_VSMG2_1755 MSMG3_X_5040_Y_3920 MSMG2_X_5040_Y_3920 714.7m
R_VSMG2_1756 MSMG3_X_5040_Y_4480 MSMG2_X_5040_Y_4480 714.7m
R_VSMG2_1757 MSMG3_X_5040_Y_5040 MSMG2_X_5040_Y_5040 714.7m
R_VSMG2_1758 MSMG3_X_5040_Y_5600 MSMG2_X_5040_Y_5600 714.7m
R_VSMG2_1759 MSMG3_X_5040_Y_6160 MSMG2_X_5040_Y_6160 714.7m
R_VSMG2_1760 MSMG3_X_5040_Y_6720 MSMG2_X_5040_Y_6720 714.7m
R_VSMG2_1761 MSMG3_X_5040_Y_7280 MSMG2_X_5040_Y_7280 714.7m
R_VSMG2_1762 MSMG3_X_5040_Y_7840 MSMG2_X_5040_Y_7840 714.7m
R_VSMG2_1763 MSMG3_X_5040_Y_8400 MSMG2_X_5040_Y_8400 714.7m
R_VSMG2_1764 MSMG3_X_5040_Y_8960 MSMG2_X_5040_Y_8960 714.7m
R_VSMG2_1765 MSMG3_X_5040_Y_9520 MSMG2_X_5040_Y_9520 714.7m
R_VSMG2_1766 MSMG3_X_5600_Y_0 MSMG2_X_5600_Y_0 714.7m
R_VSMG2_1767 MSMG3_X_5600_Y_560 MSMG2_X_5600_Y_560 714.7m
R_VSMG2_1768 MSMG3_X_5600_Y_1120 MSMG2_X_5600_Y_1120 714.7m
R_VSMG2_1769 MSMG3_X_5600_Y_1680 MSMG2_X_5600_Y_1680 714.7m
R_VSMG2_1770 MSMG3_X_5600_Y_2240 MSMG2_X_5600_Y_2240 714.7m
R_VSMG2_1771 MSMG3_X_5600_Y_2800 MSMG2_X_5600_Y_2800 714.7m
R_VSMG2_1772 MSMG3_X_5600_Y_3360 MSMG2_X_5600_Y_3360 714.7m
R_VSMG2_1773 MSMG3_X_5600_Y_3920 MSMG2_X_5600_Y_3920 714.7m
R_VSMG2_1774 MSMG3_X_5600_Y_4480 MSMG2_X_5600_Y_4480 714.7m
R_VSMG2_1775 MSMG3_X_5600_Y_5040 MSMG2_X_5600_Y_5040 714.7m
R_VSMG2_1776 MSMG3_X_5600_Y_5600 MSMG2_X_5600_Y_5600 714.7m
R_VSMG2_1777 MSMG3_X_5600_Y_6160 MSMG2_X_5600_Y_6160 714.7m
R_VSMG2_1778 MSMG3_X_5600_Y_6720 MSMG2_X_5600_Y_6720 714.7m
R_VSMG2_1779 MSMG3_X_5600_Y_7280 MSMG2_X_5600_Y_7280 714.7m
R_VSMG2_1780 MSMG3_X_5600_Y_7840 MSMG2_X_5600_Y_7840 714.7m
R_VSMG2_1781 MSMG3_X_5600_Y_8400 MSMG2_X_5600_Y_8400 714.7m
R_VSMG2_1782 MSMG3_X_5600_Y_8960 MSMG2_X_5600_Y_8960 714.7m
R_VSMG2_1783 MSMG3_X_5600_Y_9520 MSMG2_X_5600_Y_9520 714.7m
R_VSMG2_1784 MSMG3_X_6160_Y_0 MSMG2_X_6160_Y_0 714.7m
R_VSMG2_1785 MSMG3_X_6160_Y_560 MSMG2_X_6160_Y_560 714.7m
R_VSMG2_1786 MSMG3_X_6160_Y_1120 MSMG2_X_6160_Y_1120 714.7m
R_VSMG2_1787 MSMG3_X_6160_Y_1680 MSMG2_X_6160_Y_1680 714.7m
R_VSMG2_1788 MSMG3_X_6160_Y_2240 MSMG2_X_6160_Y_2240 714.7m
R_VSMG2_1789 MSMG3_X_6160_Y_2800 MSMG2_X_6160_Y_2800 714.7m
R_VSMG2_1790 MSMG3_X_6160_Y_3360 MSMG2_X_6160_Y_3360 714.7m
R_VSMG2_1791 MSMG3_X_6160_Y_3920 MSMG2_X_6160_Y_3920 714.7m
R_VSMG2_1792 MSMG3_X_6160_Y_4480 MSMG2_X_6160_Y_4480 714.7m
R_VSMG2_1793 MSMG3_X_6160_Y_5040 MSMG2_X_6160_Y_5040 714.7m
R_VSMG2_1794 MSMG3_X_6160_Y_5600 MSMG2_X_6160_Y_5600 714.7m
R_VSMG2_1795 MSMG3_X_6160_Y_6160 MSMG2_X_6160_Y_6160 714.7m
R_VSMG2_1796 MSMG3_X_6160_Y_6720 MSMG2_X_6160_Y_6720 714.7m
R_VSMG2_1797 MSMG3_X_6160_Y_7280 MSMG2_X_6160_Y_7280 714.7m
R_VSMG2_1798 MSMG3_X_6160_Y_7840 MSMG2_X_6160_Y_7840 714.7m
R_VSMG2_1799 MSMG3_X_6160_Y_8400 MSMG2_X_6160_Y_8400 714.7m
R_VSMG2_1800 MSMG3_X_6160_Y_8960 MSMG2_X_6160_Y_8960 714.7m
R_VSMG2_1801 MSMG3_X_6160_Y_9520 MSMG2_X_6160_Y_9520 714.7m
R_VSMG2_1802 MSMG3_X_6720_Y_0 MSMG2_X_6720_Y_0 714.7m
R_VSMG2_1803 MSMG3_X_6720_Y_560 MSMG2_X_6720_Y_560 714.7m
R_VSMG2_1804 MSMG3_X_6720_Y_1120 MSMG2_X_6720_Y_1120 714.7m
R_VSMG2_1805 MSMG3_X_6720_Y_1680 MSMG2_X_6720_Y_1680 714.7m
R_VSMG2_1806 MSMG3_X_6720_Y_2240 MSMG2_X_6720_Y_2240 714.7m
R_VSMG2_1807 MSMG3_X_6720_Y_2800 MSMG2_X_6720_Y_2800 714.7m
R_VSMG2_1808 MSMG3_X_6720_Y_3360 MSMG2_X_6720_Y_3360 714.7m
R_VSMG2_1809 MSMG3_X_6720_Y_3920 MSMG2_X_6720_Y_3920 714.7m
R_VSMG2_1810 MSMG3_X_6720_Y_4480 MSMG2_X_6720_Y_4480 714.7m
R_VSMG2_1811 MSMG3_X_6720_Y_5040 MSMG2_X_6720_Y_5040 714.7m
R_VSMG2_1812 MSMG3_X_6720_Y_5600 MSMG2_X_6720_Y_5600 714.7m
R_VSMG2_1813 MSMG3_X_6720_Y_6160 MSMG2_X_6720_Y_6160 714.7m
R_VSMG2_1814 MSMG3_X_6720_Y_6720 MSMG2_X_6720_Y_6720 714.7m
R_VSMG2_1815 MSMG3_X_6720_Y_7280 MSMG2_X_6720_Y_7280 714.7m
R_VSMG2_1816 MSMG3_X_6720_Y_7840 MSMG2_X_6720_Y_7840 714.7m
R_VSMG2_1817 MSMG3_X_6720_Y_8400 MSMG2_X_6720_Y_8400 714.7m
R_VSMG2_1818 MSMG3_X_6720_Y_8960 MSMG2_X_6720_Y_8960 714.7m
R_VSMG2_1819 MSMG3_X_6720_Y_9520 MSMG2_X_6720_Y_9520 714.7m
R_VSMG2_1820 MSMG3_X_7280_Y_0 MSMG2_X_7280_Y_0 714.7m
R_VSMG2_1821 MSMG3_X_7280_Y_560 MSMG2_X_7280_Y_560 714.7m
R_VSMG2_1822 MSMG3_X_7280_Y_1120 MSMG2_X_7280_Y_1120 714.7m
R_VSMG2_1823 MSMG3_X_7280_Y_1680 MSMG2_X_7280_Y_1680 714.7m
R_VSMG2_1824 MSMG3_X_7280_Y_2240 MSMG2_X_7280_Y_2240 714.7m
R_VSMG2_1825 MSMG3_X_7280_Y_2800 MSMG2_X_7280_Y_2800 714.7m
R_VSMG2_1826 MSMG3_X_7280_Y_3360 MSMG2_X_7280_Y_3360 714.7m
R_VSMG2_1827 MSMG3_X_7280_Y_3920 MSMG2_X_7280_Y_3920 714.7m
R_VSMG2_1828 MSMG3_X_7280_Y_4480 MSMG2_X_7280_Y_4480 714.7m
R_VSMG2_1829 MSMG3_X_7280_Y_5040 MSMG2_X_7280_Y_5040 714.7m
R_VSMG2_1830 MSMG3_X_7280_Y_5600 MSMG2_X_7280_Y_5600 714.7m
R_VSMG2_1831 MSMG3_X_7280_Y_6160 MSMG2_X_7280_Y_6160 714.7m
R_VSMG2_1832 MSMG3_X_7280_Y_6720 MSMG2_X_7280_Y_6720 714.7m
R_VSMG2_1833 MSMG3_X_7280_Y_7280 MSMG2_X_7280_Y_7280 714.7m
R_VSMG2_1834 MSMG3_X_7280_Y_7840 MSMG2_X_7280_Y_7840 714.7m
R_VSMG2_1835 MSMG3_X_7280_Y_8400 MSMG2_X_7280_Y_8400 714.7m
R_VSMG2_1836 MSMG3_X_7280_Y_8960 MSMG2_X_7280_Y_8960 714.7m
R_VSMG2_1837 MSMG3_X_7280_Y_9520 MSMG2_X_7280_Y_9520 714.7m
R_VSMG2_1838 MSMG3_X_7840_Y_0 MSMG2_X_7840_Y_0 714.7m
R_VSMG2_1839 MSMG3_X_7840_Y_560 MSMG2_X_7840_Y_560 714.7m
R_VSMG2_1840 MSMG3_X_7840_Y_1120 MSMG2_X_7840_Y_1120 714.7m
R_VSMG2_1841 MSMG3_X_7840_Y_1680 MSMG2_X_7840_Y_1680 714.7m
R_VSMG2_1842 MSMG3_X_7840_Y_2240 MSMG2_X_7840_Y_2240 714.7m
R_VSMG2_1843 MSMG3_X_7840_Y_2800 MSMG2_X_7840_Y_2800 714.7m
R_VSMG2_1844 MSMG3_X_7840_Y_3360 MSMG2_X_7840_Y_3360 714.7m
R_VSMG2_1845 MSMG3_X_7840_Y_3920 MSMG2_X_7840_Y_3920 714.7m
R_VSMG2_1846 MSMG3_X_7840_Y_4480 MSMG2_X_7840_Y_4480 714.7m
R_VSMG2_1847 MSMG3_X_7840_Y_5040 MSMG2_X_7840_Y_5040 714.7m
R_VSMG2_1848 MSMG3_X_7840_Y_5600 MSMG2_X_7840_Y_5600 714.7m
R_VSMG2_1849 MSMG3_X_7840_Y_6160 MSMG2_X_7840_Y_6160 714.7m
R_VSMG2_1850 MSMG3_X_7840_Y_6720 MSMG2_X_7840_Y_6720 714.7m
R_VSMG2_1851 MSMG3_X_7840_Y_7280 MSMG2_X_7840_Y_7280 714.7m
R_VSMG2_1852 MSMG3_X_7840_Y_7840 MSMG2_X_7840_Y_7840 714.7m
R_VSMG2_1853 MSMG3_X_7840_Y_8400 MSMG2_X_7840_Y_8400 714.7m
R_VSMG2_1854 MSMG3_X_7840_Y_8960 MSMG2_X_7840_Y_8960 714.7m
R_VSMG2_1855 MSMG3_X_7840_Y_9520 MSMG2_X_7840_Y_9520 714.7m
R_VSMG2_1856 MSMG3_X_8400_Y_0 MSMG2_X_8400_Y_0 714.7m
R_VSMG2_1857 MSMG3_X_8400_Y_560 MSMG2_X_8400_Y_560 714.7m
R_VSMG2_1858 MSMG3_X_8400_Y_1120 MSMG2_X_8400_Y_1120 714.7m
R_VSMG2_1859 MSMG3_X_8400_Y_1680 MSMG2_X_8400_Y_1680 714.7m
R_VSMG2_1860 MSMG3_X_8400_Y_2240 MSMG2_X_8400_Y_2240 714.7m
R_VSMG2_1861 MSMG3_X_8400_Y_2800 MSMG2_X_8400_Y_2800 714.7m
R_VSMG2_1862 MSMG3_X_8400_Y_3360 MSMG2_X_8400_Y_3360 714.7m
R_VSMG2_1863 MSMG3_X_8400_Y_3920 MSMG2_X_8400_Y_3920 714.7m
R_VSMG2_1864 MSMG3_X_8400_Y_4480 MSMG2_X_8400_Y_4480 714.7m
R_VSMG2_1865 MSMG3_X_8400_Y_5040 MSMG2_X_8400_Y_5040 714.7m
R_VSMG2_1866 MSMG3_X_8400_Y_5600 MSMG2_X_8400_Y_5600 714.7m
R_VSMG2_1867 MSMG3_X_8400_Y_6160 MSMG2_X_8400_Y_6160 714.7m
R_VSMG2_1868 MSMG3_X_8400_Y_6720 MSMG2_X_8400_Y_6720 714.7m
R_VSMG2_1869 MSMG3_X_8400_Y_7280 MSMG2_X_8400_Y_7280 714.7m
R_VSMG2_1870 MSMG3_X_8400_Y_7840 MSMG2_X_8400_Y_7840 714.7m
R_VSMG2_1871 MSMG3_X_8400_Y_8400 MSMG2_X_8400_Y_8400 714.7m
R_VSMG2_1872 MSMG3_X_8400_Y_8960 MSMG2_X_8400_Y_8960 714.7m
R_VSMG2_1873 MSMG3_X_8400_Y_9520 MSMG2_X_8400_Y_9520 714.7m
R_VSMG2_1874 MSMG3_X_8960_Y_0 MSMG2_X_8960_Y_0 714.7m
R_VSMG2_1875 MSMG3_X_8960_Y_560 MSMG2_X_8960_Y_560 714.7m
R_VSMG2_1876 MSMG3_X_8960_Y_1120 MSMG2_X_8960_Y_1120 714.7m
R_VSMG2_1877 MSMG3_X_8960_Y_1680 MSMG2_X_8960_Y_1680 714.7m
R_VSMG2_1878 MSMG3_X_8960_Y_2240 MSMG2_X_8960_Y_2240 714.7m
R_VSMG2_1879 MSMG3_X_8960_Y_2800 MSMG2_X_8960_Y_2800 714.7m
R_VSMG2_1880 MSMG3_X_8960_Y_3360 MSMG2_X_8960_Y_3360 714.7m
R_VSMG2_1881 MSMG3_X_8960_Y_3920 MSMG2_X_8960_Y_3920 714.7m
R_VSMG2_1882 MSMG3_X_8960_Y_4480 MSMG2_X_8960_Y_4480 714.7m
R_VSMG2_1883 MSMG3_X_8960_Y_5040 MSMG2_X_8960_Y_5040 714.7m
R_VSMG2_1884 MSMG3_X_8960_Y_5600 MSMG2_X_8960_Y_5600 714.7m
R_VSMG2_1885 MSMG3_X_8960_Y_6160 MSMG2_X_8960_Y_6160 714.7m
R_VSMG2_1886 MSMG3_X_8960_Y_6720 MSMG2_X_8960_Y_6720 714.7m
R_VSMG2_1887 MSMG3_X_8960_Y_7280 MSMG2_X_8960_Y_7280 714.7m
R_VSMG2_1888 MSMG3_X_8960_Y_7840 MSMG2_X_8960_Y_7840 714.7m
R_VSMG2_1889 MSMG3_X_8960_Y_8400 MSMG2_X_8960_Y_8400 714.7m
R_VSMG2_1890 MSMG3_X_8960_Y_8960 MSMG2_X_8960_Y_8960 714.7m
R_VSMG2_1891 MSMG3_X_8960_Y_9520 MSMG2_X_8960_Y_9520 714.7m
R_VSMG2_1892 MSMG3_X_9520_Y_0 MSMG2_X_9520_Y_0 714.7m
R_VSMG2_1893 MSMG3_X_9520_Y_560 MSMG2_X_9520_Y_560 714.7m
R_VSMG2_1894 MSMG3_X_9520_Y_1120 MSMG2_X_9520_Y_1120 714.7m
R_VSMG2_1895 MSMG3_X_9520_Y_1680 MSMG2_X_9520_Y_1680 714.7m
R_VSMG2_1896 MSMG3_X_9520_Y_2240 MSMG2_X_9520_Y_2240 714.7m
R_VSMG2_1897 MSMG3_X_9520_Y_2800 MSMG2_X_9520_Y_2800 714.7m
R_VSMG2_1898 MSMG3_X_9520_Y_3360 MSMG2_X_9520_Y_3360 714.7m
R_VSMG2_1899 MSMG3_X_9520_Y_3920 MSMG2_X_9520_Y_3920 714.7m
R_VSMG2_1900 MSMG3_X_9520_Y_4480 MSMG2_X_9520_Y_4480 714.7m
R_VSMG2_1901 MSMG3_X_9520_Y_5040 MSMG2_X_9520_Y_5040 714.7m
R_VSMG2_1902 MSMG3_X_9520_Y_5600 MSMG2_X_9520_Y_5600 714.7m
R_VSMG2_1903 MSMG3_X_9520_Y_6160 MSMG2_X_9520_Y_6160 714.7m
R_VSMG2_1904 MSMG3_X_9520_Y_6720 MSMG2_X_9520_Y_6720 714.7m
R_VSMG2_1905 MSMG3_X_9520_Y_7280 MSMG2_X_9520_Y_7280 714.7m
R_VSMG2_1906 MSMG3_X_9520_Y_7840 MSMG2_X_9520_Y_7840 714.7m
R_VSMG2_1907 MSMG3_X_9520_Y_8400 MSMG2_X_9520_Y_8400 714.7m
R_VSMG2_1908 MSMG3_X_9520_Y_8960 MSMG2_X_9520_Y_8960 714.7m
R_VSMG2_1909 MSMG3_X_9520_Y_9520 MSMG2_X_9520_Y_9520 714.7m
R_VSMG1_1910 MSMG2_X_0_Y_0 MSMG1_X_0_Y_0 714.7m
R_VSMG1_1911 MSMG2_X_560_Y_0 MSMG1_X_560_Y_0 714.7m
R_VSMG1_1912 MSMG2_X_1120_Y_0 MSMG1_X_1120_Y_0 714.7m
R_VSMG1_1913 MSMG2_X_1680_Y_0 MSMG1_X_1680_Y_0 714.7m
R_VSMG1_1914 MSMG2_X_2240_Y_0 MSMG1_X_2240_Y_0 714.7m
R_VSMG1_1915 MSMG2_X_2800_Y_0 MSMG1_X_2800_Y_0 714.7m
R_VSMG1_1916 MSMG2_X_3360_Y_0 MSMG1_X_3360_Y_0 714.7m
R_VSMG1_1917 MSMG2_X_3920_Y_0 MSMG1_X_3920_Y_0 714.7m
R_VSMG1_1918 MSMG2_X_4480_Y_0 MSMG1_X_4480_Y_0 714.7m
R_VSMG1_1919 MSMG2_X_5040_Y_0 MSMG1_X_5040_Y_0 714.7m
R_VSMG1_1920 MSMG2_X_5600_Y_0 MSMG1_X_5600_Y_0 714.7m
R_VSMG1_1921 MSMG2_X_6160_Y_0 MSMG1_X_6160_Y_0 714.7m
R_VSMG1_1922 MSMG2_X_6720_Y_0 MSMG1_X_6720_Y_0 714.7m
R_VSMG1_1923 MSMG2_X_7280_Y_0 MSMG1_X_7280_Y_0 714.7m
R_VSMG1_1924 MSMG2_X_7840_Y_0 MSMG1_X_7840_Y_0 714.7m
R_VSMG1_1925 MSMG2_X_8400_Y_0 MSMG1_X_8400_Y_0 714.7m
R_VSMG1_1926 MSMG2_X_8960_Y_0 MSMG1_X_8960_Y_0 714.7m
R_VSMG1_1927 MSMG2_X_9520_Y_0 MSMG1_X_9520_Y_0 714.7m
R_VSMG1_1928 MSMG2_X_0_Y_560 MSMG1_X_0_Y_560 714.7m
R_VSMG1_1929 MSMG2_X_560_Y_560 MSMG1_X_560_Y_560 714.7m
R_VSMG1_1930 MSMG2_X_1120_Y_560 MSMG1_X_1120_Y_560 714.7m
R_VSMG1_1931 MSMG2_X_1680_Y_560 MSMG1_X_1680_Y_560 714.7m
R_VSMG1_1932 MSMG2_X_2240_Y_560 MSMG1_X_2240_Y_560 714.7m
R_VSMG1_1933 MSMG2_X_2800_Y_560 MSMG1_X_2800_Y_560 714.7m
R_VSMG1_1934 MSMG2_X_3360_Y_560 MSMG1_X_3360_Y_560 714.7m
R_VSMG1_1935 MSMG2_X_3920_Y_560 MSMG1_X_3920_Y_560 714.7m
R_VSMG1_1936 MSMG2_X_4480_Y_560 MSMG1_X_4480_Y_560 714.7m
R_VSMG1_1937 MSMG2_X_5040_Y_560 MSMG1_X_5040_Y_560 714.7m
R_VSMG1_1938 MSMG2_X_5600_Y_560 MSMG1_X_5600_Y_560 714.7m
R_VSMG1_1939 MSMG2_X_6160_Y_560 MSMG1_X_6160_Y_560 714.7m
R_VSMG1_1940 MSMG2_X_6720_Y_560 MSMG1_X_6720_Y_560 714.7m
R_VSMG1_1941 MSMG2_X_7280_Y_560 MSMG1_X_7280_Y_560 714.7m
R_VSMG1_1942 MSMG2_X_7840_Y_560 MSMG1_X_7840_Y_560 714.7m
R_VSMG1_1943 MSMG2_X_8400_Y_560 MSMG1_X_8400_Y_560 714.7m
R_VSMG1_1944 MSMG2_X_8960_Y_560 MSMG1_X_8960_Y_560 714.7m
R_VSMG1_1945 MSMG2_X_9520_Y_560 MSMG1_X_9520_Y_560 714.7m
R_VSMG1_1946 MSMG2_X_0_Y_1120 MSMG1_X_0_Y_1120 714.7m
R_VSMG1_1947 MSMG2_X_560_Y_1120 MSMG1_X_560_Y_1120 714.7m
R_VSMG1_1948 MSMG2_X_1120_Y_1120 MSMG1_X_1120_Y_1120 714.7m
R_VSMG1_1949 MSMG2_X_1680_Y_1120 MSMG1_X_1680_Y_1120 714.7m
R_VSMG1_1950 MSMG2_X_2240_Y_1120 MSMG1_X_2240_Y_1120 714.7m
R_VSMG1_1951 MSMG2_X_2800_Y_1120 MSMG1_X_2800_Y_1120 714.7m
R_VSMG1_1952 MSMG2_X_3360_Y_1120 MSMG1_X_3360_Y_1120 714.7m
R_VSMG1_1953 MSMG2_X_3920_Y_1120 MSMG1_X_3920_Y_1120 714.7m
R_VSMG1_1954 MSMG2_X_4480_Y_1120 MSMG1_X_4480_Y_1120 714.7m
R_VSMG1_1955 MSMG2_X_5040_Y_1120 MSMG1_X_5040_Y_1120 714.7m
R_VSMG1_1956 MSMG2_X_5600_Y_1120 MSMG1_X_5600_Y_1120 714.7m
R_VSMG1_1957 MSMG2_X_6160_Y_1120 MSMG1_X_6160_Y_1120 714.7m
R_VSMG1_1958 MSMG2_X_6720_Y_1120 MSMG1_X_6720_Y_1120 714.7m
R_VSMG1_1959 MSMG2_X_7280_Y_1120 MSMG1_X_7280_Y_1120 714.7m
R_VSMG1_1960 MSMG2_X_7840_Y_1120 MSMG1_X_7840_Y_1120 714.7m
R_VSMG1_1961 MSMG2_X_8400_Y_1120 MSMG1_X_8400_Y_1120 714.7m
R_VSMG1_1962 MSMG2_X_8960_Y_1120 MSMG1_X_8960_Y_1120 714.7m
R_VSMG1_1963 MSMG2_X_9520_Y_1120 MSMG1_X_9520_Y_1120 714.7m
R_VSMG1_1964 MSMG2_X_0_Y_1680 MSMG1_X_0_Y_1680 714.7m
R_VSMG1_1965 MSMG2_X_560_Y_1680 MSMG1_X_560_Y_1680 714.7m
R_VSMG1_1966 MSMG2_X_1120_Y_1680 MSMG1_X_1120_Y_1680 714.7m
R_VSMG1_1967 MSMG2_X_1680_Y_1680 MSMG1_X_1680_Y_1680 714.7m
R_VSMG1_1968 MSMG2_X_2240_Y_1680 MSMG1_X_2240_Y_1680 714.7m
R_VSMG1_1969 MSMG2_X_2800_Y_1680 MSMG1_X_2800_Y_1680 714.7m
R_VSMG1_1970 MSMG2_X_3360_Y_1680 MSMG1_X_3360_Y_1680 714.7m
R_VSMG1_1971 MSMG2_X_3920_Y_1680 MSMG1_X_3920_Y_1680 714.7m
R_VSMG1_1972 MSMG2_X_4480_Y_1680 MSMG1_X_4480_Y_1680 714.7m
R_VSMG1_1973 MSMG2_X_5040_Y_1680 MSMG1_X_5040_Y_1680 714.7m
R_VSMG1_1974 MSMG2_X_5600_Y_1680 MSMG1_X_5600_Y_1680 714.7m
R_VSMG1_1975 MSMG2_X_6160_Y_1680 MSMG1_X_6160_Y_1680 714.7m
R_VSMG1_1976 MSMG2_X_6720_Y_1680 MSMG1_X_6720_Y_1680 714.7m
R_VSMG1_1977 MSMG2_X_7280_Y_1680 MSMG1_X_7280_Y_1680 714.7m
R_VSMG1_1978 MSMG2_X_7840_Y_1680 MSMG1_X_7840_Y_1680 714.7m
R_VSMG1_1979 MSMG2_X_8400_Y_1680 MSMG1_X_8400_Y_1680 714.7m
R_VSMG1_1980 MSMG2_X_8960_Y_1680 MSMG1_X_8960_Y_1680 714.7m
R_VSMG1_1981 MSMG2_X_9520_Y_1680 MSMG1_X_9520_Y_1680 714.7m
R_VSMG1_1982 MSMG2_X_0_Y_2240 MSMG1_X_0_Y_2240 714.7m
R_VSMG1_1983 MSMG2_X_560_Y_2240 MSMG1_X_560_Y_2240 714.7m
R_VSMG1_1984 MSMG2_X_1120_Y_2240 MSMG1_X_1120_Y_2240 714.7m
R_VSMG1_1985 MSMG2_X_1680_Y_2240 MSMG1_X_1680_Y_2240 714.7m
R_VSMG1_1986 MSMG2_X_2240_Y_2240 MSMG1_X_2240_Y_2240 714.7m
R_VSMG1_1987 MSMG2_X_2800_Y_2240 MSMG1_X_2800_Y_2240 714.7m
R_VSMG1_1988 MSMG2_X_3360_Y_2240 MSMG1_X_3360_Y_2240 714.7m
R_VSMG1_1989 MSMG2_X_3920_Y_2240 MSMG1_X_3920_Y_2240 714.7m
R_VSMG1_1990 MSMG2_X_4480_Y_2240 MSMG1_X_4480_Y_2240 714.7m
R_VSMG1_1991 MSMG2_X_5040_Y_2240 MSMG1_X_5040_Y_2240 714.7m
R_VSMG1_1992 MSMG2_X_5600_Y_2240 MSMG1_X_5600_Y_2240 714.7m
R_VSMG1_1993 MSMG2_X_6160_Y_2240 MSMG1_X_6160_Y_2240 714.7m
R_VSMG1_1994 MSMG2_X_6720_Y_2240 MSMG1_X_6720_Y_2240 714.7m
R_VSMG1_1995 MSMG2_X_7280_Y_2240 MSMG1_X_7280_Y_2240 714.7m
R_VSMG1_1996 MSMG2_X_7840_Y_2240 MSMG1_X_7840_Y_2240 714.7m
R_VSMG1_1997 MSMG2_X_8400_Y_2240 MSMG1_X_8400_Y_2240 714.7m
R_VSMG1_1998 MSMG2_X_8960_Y_2240 MSMG1_X_8960_Y_2240 714.7m
R_VSMG1_1999 MSMG2_X_9520_Y_2240 MSMG1_X_9520_Y_2240 714.7m
R_VSMG1_2000 MSMG2_X_0_Y_2800 MSMG1_X_0_Y_2800 714.7m
R_VSMG1_2001 MSMG2_X_560_Y_2800 MSMG1_X_560_Y_2800 714.7m
R_VSMG1_2002 MSMG2_X_1120_Y_2800 MSMG1_X_1120_Y_2800 714.7m
R_VSMG1_2003 MSMG2_X_1680_Y_2800 MSMG1_X_1680_Y_2800 714.7m
R_VSMG1_2004 MSMG2_X_2240_Y_2800 MSMG1_X_2240_Y_2800 714.7m
R_VSMG1_2005 MSMG2_X_2800_Y_2800 MSMG1_X_2800_Y_2800 714.7m
R_VSMG1_2006 MSMG2_X_3360_Y_2800 MSMG1_X_3360_Y_2800 714.7m
R_VSMG1_2007 MSMG2_X_3920_Y_2800 MSMG1_X_3920_Y_2800 714.7m
R_VSMG1_2008 MSMG2_X_4480_Y_2800 MSMG1_X_4480_Y_2800 714.7m
R_VSMG1_2009 MSMG2_X_5040_Y_2800 MSMG1_X_5040_Y_2800 714.7m
R_VSMG1_2010 MSMG2_X_5600_Y_2800 MSMG1_X_5600_Y_2800 714.7m
R_VSMG1_2011 MSMG2_X_6160_Y_2800 MSMG1_X_6160_Y_2800 714.7m
R_VSMG1_2012 MSMG2_X_6720_Y_2800 MSMG1_X_6720_Y_2800 714.7m
R_VSMG1_2013 MSMG2_X_7280_Y_2800 MSMG1_X_7280_Y_2800 714.7m
R_VSMG1_2014 MSMG2_X_7840_Y_2800 MSMG1_X_7840_Y_2800 714.7m
R_VSMG1_2015 MSMG2_X_8400_Y_2800 MSMG1_X_8400_Y_2800 714.7m
R_VSMG1_2016 MSMG2_X_8960_Y_2800 MSMG1_X_8960_Y_2800 714.7m
R_VSMG1_2017 MSMG2_X_9520_Y_2800 MSMG1_X_9520_Y_2800 714.7m
R_VSMG1_2018 MSMG2_X_0_Y_3360 MSMG1_X_0_Y_3360 714.7m
R_VSMG1_2019 MSMG2_X_560_Y_3360 MSMG1_X_560_Y_3360 714.7m
R_VSMG1_2020 MSMG2_X_1120_Y_3360 MSMG1_X_1120_Y_3360 714.7m
R_VSMG1_2021 MSMG2_X_1680_Y_3360 MSMG1_X_1680_Y_3360 714.7m
R_VSMG1_2022 MSMG2_X_2240_Y_3360 MSMG1_X_2240_Y_3360 714.7m
R_VSMG1_2023 MSMG2_X_2800_Y_3360 MSMG1_X_2800_Y_3360 714.7m
R_VSMG1_2024 MSMG2_X_3360_Y_3360 MSMG1_X_3360_Y_3360 714.7m
R_VSMG1_2025 MSMG2_X_3920_Y_3360 MSMG1_X_3920_Y_3360 714.7m
R_VSMG1_2026 MSMG2_X_4480_Y_3360 MSMG1_X_4480_Y_3360 714.7m
R_VSMG1_2027 MSMG2_X_5040_Y_3360 MSMG1_X_5040_Y_3360 714.7m
R_VSMG1_2028 MSMG2_X_5600_Y_3360 MSMG1_X_5600_Y_3360 714.7m
R_VSMG1_2029 MSMG2_X_6160_Y_3360 MSMG1_X_6160_Y_3360 714.7m
R_VSMG1_2030 MSMG2_X_6720_Y_3360 MSMG1_X_6720_Y_3360 714.7m
R_VSMG1_2031 MSMG2_X_7280_Y_3360 MSMG1_X_7280_Y_3360 714.7m
R_VSMG1_2032 MSMG2_X_7840_Y_3360 MSMG1_X_7840_Y_3360 714.7m
R_VSMG1_2033 MSMG2_X_8400_Y_3360 MSMG1_X_8400_Y_3360 714.7m
R_VSMG1_2034 MSMG2_X_8960_Y_3360 MSMG1_X_8960_Y_3360 714.7m
R_VSMG1_2035 MSMG2_X_9520_Y_3360 MSMG1_X_9520_Y_3360 714.7m
R_VSMG1_2036 MSMG2_X_0_Y_3920 MSMG1_X_0_Y_3920 714.7m
R_VSMG1_2037 MSMG2_X_560_Y_3920 MSMG1_X_560_Y_3920 714.7m
R_VSMG1_2038 MSMG2_X_1120_Y_3920 MSMG1_X_1120_Y_3920 714.7m
R_VSMG1_2039 MSMG2_X_1680_Y_3920 MSMG1_X_1680_Y_3920 714.7m
R_VSMG1_2040 MSMG2_X_2240_Y_3920 MSMG1_X_2240_Y_3920 714.7m
R_VSMG1_2041 MSMG2_X_2800_Y_3920 MSMG1_X_2800_Y_3920 714.7m
R_VSMG1_2042 MSMG2_X_3360_Y_3920 MSMG1_X_3360_Y_3920 714.7m
R_VSMG1_2043 MSMG2_X_3920_Y_3920 MSMG1_X_3920_Y_3920 714.7m
R_VSMG1_2044 MSMG2_X_4480_Y_3920 MSMG1_X_4480_Y_3920 714.7m
R_VSMG1_2045 MSMG2_X_5040_Y_3920 MSMG1_X_5040_Y_3920 714.7m
R_VSMG1_2046 MSMG2_X_5600_Y_3920 MSMG1_X_5600_Y_3920 714.7m
R_VSMG1_2047 MSMG2_X_6160_Y_3920 MSMG1_X_6160_Y_3920 714.7m
R_VSMG1_2048 MSMG2_X_6720_Y_3920 MSMG1_X_6720_Y_3920 714.7m
R_VSMG1_2049 MSMG2_X_7280_Y_3920 MSMG1_X_7280_Y_3920 714.7m
R_VSMG1_2050 MSMG2_X_7840_Y_3920 MSMG1_X_7840_Y_3920 714.7m
R_VSMG1_2051 MSMG2_X_8400_Y_3920 MSMG1_X_8400_Y_3920 714.7m
R_VSMG1_2052 MSMG2_X_8960_Y_3920 MSMG1_X_8960_Y_3920 714.7m
R_VSMG1_2053 MSMG2_X_9520_Y_3920 MSMG1_X_9520_Y_3920 714.7m
R_VSMG1_2054 MSMG2_X_0_Y_4480 MSMG1_X_0_Y_4480 714.7m
R_VSMG1_2055 MSMG2_X_560_Y_4480 MSMG1_X_560_Y_4480 714.7m
R_VSMG1_2056 MSMG2_X_1120_Y_4480 MSMG1_X_1120_Y_4480 714.7m
R_VSMG1_2057 MSMG2_X_1680_Y_4480 MSMG1_X_1680_Y_4480 714.7m
R_VSMG1_2058 MSMG2_X_2240_Y_4480 MSMG1_X_2240_Y_4480 714.7m
R_VSMG1_2059 MSMG2_X_2800_Y_4480 MSMG1_X_2800_Y_4480 714.7m
R_VSMG1_2060 MSMG2_X_3360_Y_4480 MSMG1_X_3360_Y_4480 714.7m
R_VSMG1_2061 MSMG2_X_3920_Y_4480 MSMG1_X_3920_Y_4480 714.7m
R_VSMG1_2062 MSMG2_X_4480_Y_4480 MSMG1_X_4480_Y_4480 714.7m
R_VSMG1_2063 MSMG2_X_5040_Y_4480 MSMG1_X_5040_Y_4480 714.7m
R_VSMG1_2064 MSMG2_X_5600_Y_4480 MSMG1_X_5600_Y_4480 714.7m
R_VSMG1_2065 MSMG2_X_6160_Y_4480 MSMG1_X_6160_Y_4480 714.7m
R_VSMG1_2066 MSMG2_X_6720_Y_4480 MSMG1_X_6720_Y_4480 714.7m
R_VSMG1_2067 MSMG2_X_7280_Y_4480 MSMG1_X_7280_Y_4480 714.7m
R_VSMG1_2068 MSMG2_X_7840_Y_4480 MSMG1_X_7840_Y_4480 714.7m
R_VSMG1_2069 MSMG2_X_8400_Y_4480 MSMG1_X_8400_Y_4480 714.7m
R_VSMG1_2070 MSMG2_X_8960_Y_4480 MSMG1_X_8960_Y_4480 714.7m
R_VSMG1_2071 MSMG2_X_9520_Y_4480 MSMG1_X_9520_Y_4480 714.7m
R_VSMG1_2072 MSMG2_X_0_Y_5040 MSMG1_X_0_Y_5040 714.7m
R_VSMG1_2073 MSMG2_X_560_Y_5040 MSMG1_X_560_Y_5040 714.7m
R_VSMG1_2074 MSMG2_X_1120_Y_5040 MSMG1_X_1120_Y_5040 714.7m
R_VSMG1_2075 MSMG2_X_1680_Y_5040 MSMG1_X_1680_Y_5040 714.7m
R_VSMG1_2076 MSMG2_X_2240_Y_5040 MSMG1_X_2240_Y_5040 714.7m
R_VSMG1_2077 MSMG2_X_2800_Y_5040 MSMG1_X_2800_Y_5040 714.7m
R_VSMG1_2078 MSMG2_X_3360_Y_5040 MSMG1_X_3360_Y_5040 714.7m
R_VSMG1_2079 MSMG2_X_3920_Y_5040 MSMG1_X_3920_Y_5040 714.7m
R_VSMG1_2080 MSMG2_X_4480_Y_5040 MSMG1_X_4480_Y_5040 714.7m
R_VSMG1_2081 MSMG2_X_5040_Y_5040 MSMG1_X_5040_Y_5040 714.7m
R_VSMG1_2082 MSMG2_X_5600_Y_5040 MSMG1_X_5600_Y_5040 714.7m
R_VSMG1_2083 MSMG2_X_6160_Y_5040 MSMG1_X_6160_Y_5040 714.7m
R_VSMG1_2084 MSMG2_X_6720_Y_5040 MSMG1_X_6720_Y_5040 714.7m
R_VSMG1_2085 MSMG2_X_7280_Y_5040 MSMG1_X_7280_Y_5040 714.7m
R_VSMG1_2086 MSMG2_X_7840_Y_5040 MSMG1_X_7840_Y_5040 714.7m
R_VSMG1_2087 MSMG2_X_8400_Y_5040 MSMG1_X_8400_Y_5040 714.7m
R_VSMG1_2088 MSMG2_X_8960_Y_5040 MSMG1_X_8960_Y_5040 714.7m
R_VSMG1_2089 MSMG2_X_9520_Y_5040 MSMG1_X_9520_Y_5040 714.7m
R_VSMG1_2090 MSMG2_X_0_Y_5600 MSMG1_X_0_Y_5600 714.7m
R_VSMG1_2091 MSMG2_X_560_Y_5600 MSMG1_X_560_Y_5600 714.7m
R_VSMG1_2092 MSMG2_X_1120_Y_5600 MSMG1_X_1120_Y_5600 714.7m
R_VSMG1_2093 MSMG2_X_1680_Y_5600 MSMG1_X_1680_Y_5600 714.7m
R_VSMG1_2094 MSMG2_X_2240_Y_5600 MSMG1_X_2240_Y_5600 714.7m
R_VSMG1_2095 MSMG2_X_2800_Y_5600 MSMG1_X_2800_Y_5600 714.7m
R_VSMG1_2096 MSMG2_X_3360_Y_5600 MSMG1_X_3360_Y_5600 714.7m
R_VSMG1_2097 MSMG2_X_3920_Y_5600 MSMG1_X_3920_Y_5600 714.7m
R_VSMG1_2098 MSMG2_X_4480_Y_5600 MSMG1_X_4480_Y_5600 714.7m
R_VSMG1_2099 MSMG2_X_5040_Y_5600 MSMG1_X_5040_Y_5600 714.7m
R_VSMG1_2100 MSMG2_X_5600_Y_5600 MSMG1_X_5600_Y_5600 714.7m
R_VSMG1_2101 MSMG2_X_6160_Y_5600 MSMG1_X_6160_Y_5600 714.7m
R_VSMG1_2102 MSMG2_X_6720_Y_5600 MSMG1_X_6720_Y_5600 714.7m
R_VSMG1_2103 MSMG2_X_7280_Y_5600 MSMG1_X_7280_Y_5600 714.7m
R_VSMG1_2104 MSMG2_X_7840_Y_5600 MSMG1_X_7840_Y_5600 714.7m
R_VSMG1_2105 MSMG2_X_8400_Y_5600 MSMG1_X_8400_Y_5600 714.7m
R_VSMG1_2106 MSMG2_X_8960_Y_5600 MSMG1_X_8960_Y_5600 714.7m
R_VSMG1_2107 MSMG2_X_9520_Y_5600 MSMG1_X_9520_Y_5600 714.7m
R_VSMG1_2108 MSMG2_X_0_Y_6160 MSMG1_X_0_Y_6160 714.7m
R_VSMG1_2109 MSMG2_X_560_Y_6160 MSMG1_X_560_Y_6160 714.7m
R_VSMG1_2110 MSMG2_X_1120_Y_6160 MSMG1_X_1120_Y_6160 714.7m
R_VSMG1_2111 MSMG2_X_1680_Y_6160 MSMG1_X_1680_Y_6160 714.7m
R_VSMG1_2112 MSMG2_X_2240_Y_6160 MSMG1_X_2240_Y_6160 714.7m
R_VSMG1_2113 MSMG2_X_2800_Y_6160 MSMG1_X_2800_Y_6160 714.7m
R_VSMG1_2114 MSMG2_X_3360_Y_6160 MSMG1_X_3360_Y_6160 714.7m
R_VSMG1_2115 MSMG2_X_3920_Y_6160 MSMG1_X_3920_Y_6160 714.7m
R_VSMG1_2116 MSMG2_X_4480_Y_6160 MSMG1_X_4480_Y_6160 714.7m
R_VSMG1_2117 MSMG2_X_5040_Y_6160 MSMG1_X_5040_Y_6160 714.7m
R_VSMG1_2118 MSMG2_X_5600_Y_6160 MSMG1_X_5600_Y_6160 714.7m
R_VSMG1_2119 MSMG2_X_6160_Y_6160 MSMG1_X_6160_Y_6160 714.7m
R_VSMG1_2120 MSMG2_X_6720_Y_6160 MSMG1_X_6720_Y_6160 714.7m
R_VSMG1_2121 MSMG2_X_7280_Y_6160 MSMG1_X_7280_Y_6160 714.7m
R_VSMG1_2122 MSMG2_X_7840_Y_6160 MSMG1_X_7840_Y_6160 714.7m
R_VSMG1_2123 MSMG2_X_8400_Y_6160 MSMG1_X_8400_Y_6160 714.7m
R_VSMG1_2124 MSMG2_X_8960_Y_6160 MSMG1_X_8960_Y_6160 714.7m
R_VSMG1_2125 MSMG2_X_9520_Y_6160 MSMG1_X_9520_Y_6160 714.7m
R_VSMG1_2126 MSMG2_X_0_Y_6720 MSMG1_X_0_Y_6720 714.7m
R_VSMG1_2127 MSMG2_X_560_Y_6720 MSMG1_X_560_Y_6720 714.7m
R_VSMG1_2128 MSMG2_X_1120_Y_6720 MSMG1_X_1120_Y_6720 714.7m
R_VSMG1_2129 MSMG2_X_1680_Y_6720 MSMG1_X_1680_Y_6720 714.7m
R_VSMG1_2130 MSMG2_X_2240_Y_6720 MSMG1_X_2240_Y_6720 714.7m
R_VSMG1_2131 MSMG2_X_2800_Y_6720 MSMG1_X_2800_Y_6720 714.7m
R_VSMG1_2132 MSMG2_X_3360_Y_6720 MSMG1_X_3360_Y_6720 714.7m
R_VSMG1_2133 MSMG2_X_3920_Y_6720 MSMG1_X_3920_Y_6720 714.7m
R_VSMG1_2134 MSMG2_X_4480_Y_6720 MSMG1_X_4480_Y_6720 714.7m
R_VSMG1_2135 MSMG2_X_5040_Y_6720 MSMG1_X_5040_Y_6720 714.7m
R_VSMG1_2136 MSMG2_X_5600_Y_6720 MSMG1_X_5600_Y_6720 714.7m
R_VSMG1_2137 MSMG2_X_6160_Y_6720 MSMG1_X_6160_Y_6720 714.7m
R_VSMG1_2138 MSMG2_X_6720_Y_6720 MSMG1_X_6720_Y_6720 714.7m
R_VSMG1_2139 MSMG2_X_7280_Y_6720 MSMG1_X_7280_Y_6720 714.7m
R_VSMG1_2140 MSMG2_X_7840_Y_6720 MSMG1_X_7840_Y_6720 714.7m
R_VSMG1_2141 MSMG2_X_8400_Y_6720 MSMG1_X_8400_Y_6720 714.7m
R_VSMG1_2142 MSMG2_X_8960_Y_6720 MSMG1_X_8960_Y_6720 714.7m
R_VSMG1_2143 MSMG2_X_9520_Y_6720 MSMG1_X_9520_Y_6720 714.7m
R_VSMG1_2144 MSMG2_X_0_Y_7280 MSMG1_X_0_Y_7280 714.7m
R_VSMG1_2145 MSMG2_X_560_Y_7280 MSMG1_X_560_Y_7280 714.7m
R_VSMG1_2146 MSMG2_X_1120_Y_7280 MSMG1_X_1120_Y_7280 714.7m
R_VSMG1_2147 MSMG2_X_1680_Y_7280 MSMG1_X_1680_Y_7280 714.7m
R_VSMG1_2148 MSMG2_X_2240_Y_7280 MSMG1_X_2240_Y_7280 714.7m
R_VSMG1_2149 MSMG2_X_2800_Y_7280 MSMG1_X_2800_Y_7280 714.7m
R_VSMG1_2150 MSMG2_X_3360_Y_7280 MSMG1_X_3360_Y_7280 714.7m
R_VSMG1_2151 MSMG2_X_3920_Y_7280 MSMG1_X_3920_Y_7280 714.7m
R_VSMG1_2152 MSMG2_X_4480_Y_7280 MSMG1_X_4480_Y_7280 714.7m
R_VSMG1_2153 MSMG2_X_5040_Y_7280 MSMG1_X_5040_Y_7280 714.7m
R_VSMG1_2154 MSMG2_X_5600_Y_7280 MSMG1_X_5600_Y_7280 714.7m
R_VSMG1_2155 MSMG2_X_6160_Y_7280 MSMG1_X_6160_Y_7280 714.7m
R_VSMG1_2156 MSMG2_X_6720_Y_7280 MSMG1_X_6720_Y_7280 714.7m
R_VSMG1_2157 MSMG2_X_7280_Y_7280 MSMG1_X_7280_Y_7280 714.7m
R_VSMG1_2158 MSMG2_X_7840_Y_7280 MSMG1_X_7840_Y_7280 714.7m
R_VSMG1_2159 MSMG2_X_8400_Y_7280 MSMG1_X_8400_Y_7280 714.7m
R_VSMG1_2160 MSMG2_X_8960_Y_7280 MSMG1_X_8960_Y_7280 714.7m
R_VSMG1_2161 MSMG2_X_9520_Y_7280 MSMG1_X_9520_Y_7280 714.7m
R_VSMG1_2162 MSMG2_X_0_Y_7840 MSMG1_X_0_Y_7840 714.7m
R_VSMG1_2163 MSMG2_X_560_Y_7840 MSMG1_X_560_Y_7840 714.7m
R_VSMG1_2164 MSMG2_X_1120_Y_7840 MSMG1_X_1120_Y_7840 714.7m
R_VSMG1_2165 MSMG2_X_1680_Y_7840 MSMG1_X_1680_Y_7840 714.7m
R_VSMG1_2166 MSMG2_X_2240_Y_7840 MSMG1_X_2240_Y_7840 714.7m
R_VSMG1_2167 MSMG2_X_2800_Y_7840 MSMG1_X_2800_Y_7840 714.7m
R_VSMG1_2168 MSMG2_X_3360_Y_7840 MSMG1_X_3360_Y_7840 714.7m
R_VSMG1_2169 MSMG2_X_3920_Y_7840 MSMG1_X_3920_Y_7840 714.7m
R_VSMG1_2170 MSMG2_X_4480_Y_7840 MSMG1_X_4480_Y_7840 714.7m
R_VSMG1_2171 MSMG2_X_5040_Y_7840 MSMG1_X_5040_Y_7840 714.7m
R_VSMG1_2172 MSMG2_X_5600_Y_7840 MSMG1_X_5600_Y_7840 714.7m
R_VSMG1_2173 MSMG2_X_6160_Y_7840 MSMG1_X_6160_Y_7840 714.7m
R_VSMG1_2174 MSMG2_X_6720_Y_7840 MSMG1_X_6720_Y_7840 714.7m
R_VSMG1_2175 MSMG2_X_7280_Y_7840 MSMG1_X_7280_Y_7840 714.7m
R_VSMG1_2176 MSMG2_X_7840_Y_7840 MSMG1_X_7840_Y_7840 714.7m
R_VSMG1_2177 MSMG2_X_8400_Y_7840 MSMG1_X_8400_Y_7840 714.7m
R_VSMG1_2178 MSMG2_X_8960_Y_7840 MSMG1_X_8960_Y_7840 714.7m
R_VSMG1_2179 MSMG2_X_9520_Y_7840 MSMG1_X_9520_Y_7840 714.7m
R_VSMG1_2180 MSMG2_X_0_Y_8400 MSMG1_X_0_Y_8400 714.7m
R_VSMG1_2181 MSMG2_X_560_Y_8400 MSMG1_X_560_Y_8400 714.7m
R_VSMG1_2182 MSMG2_X_1120_Y_8400 MSMG1_X_1120_Y_8400 714.7m
R_VSMG1_2183 MSMG2_X_1680_Y_8400 MSMG1_X_1680_Y_8400 714.7m
R_VSMG1_2184 MSMG2_X_2240_Y_8400 MSMG1_X_2240_Y_8400 714.7m
R_VSMG1_2185 MSMG2_X_2800_Y_8400 MSMG1_X_2800_Y_8400 714.7m
R_VSMG1_2186 MSMG2_X_3360_Y_8400 MSMG1_X_3360_Y_8400 714.7m
R_VSMG1_2187 MSMG2_X_3920_Y_8400 MSMG1_X_3920_Y_8400 714.7m
R_VSMG1_2188 MSMG2_X_4480_Y_8400 MSMG1_X_4480_Y_8400 714.7m
R_VSMG1_2189 MSMG2_X_5040_Y_8400 MSMG1_X_5040_Y_8400 714.7m
R_VSMG1_2190 MSMG2_X_5600_Y_8400 MSMG1_X_5600_Y_8400 714.7m
R_VSMG1_2191 MSMG2_X_6160_Y_8400 MSMG1_X_6160_Y_8400 714.7m
R_VSMG1_2192 MSMG2_X_6720_Y_8400 MSMG1_X_6720_Y_8400 714.7m
R_VSMG1_2193 MSMG2_X_7280_Y_8400 MSMG1_X_7280_Y_8400 714.7m
R_VSMG1_2194 MSMG2_X_7840_Y_8400 MSMG1_X_7840_Y_8400 714.7m
R_VSMG1_2195 MSMG2_X_8400_Y_8400 MSMG1_X_8400_Y_8400 714.7m
R_VSMG1_2196 MSMG2_X_8960_Y_8400 MSMG1_X_8960_Y_8400 714.7m
R_VSMG1_2197 MSMG2_X_9520_Y_8400 MSMG1_X_9520_Y_8400 714.7m
R_VSMG1_2198 MSMG2_X_0_Y_8960 MSMG1_X_0_Y_8960 714.7m
R_VSMG1_2199 MSMG2_X_560_Y_8960 MSMG1_X_560_Y_8960 714.7m
R_VSMG1_2200 MSMG2_X_1120_Y_8960 MSMG1_X_1120_Y_8960 714.7m
R_VSMG1_2201 MSMG2_X_1680_Y_8960 MSMG1_X_1680_Y_8960 714.7m
R_VSMG1_2202 MSMG2_X_2240_Y_8960 MSMG1_X_2240_Y_8960 714.7m
R_VSMG1_2203 MSMG2_X_2800_Y_8960 MSMG1_X_2800_Y_8960 714.7m
R_VSMG1_2204 MSMG2_X_3360_Y_8960 MSMG1_X_3360_Y_8960 714.7m
R_VSMG1_2205 MSMG2_X_3920_Y_8960 MSMG1_X_3920_Y_8960 714.7m
R_VSMG1_2206 MSMG2_X_4480_Y_8960 MSMG1_X_4480_Y_8960 714.7m
R_VSMG1_2207 MSMG2_X_5040_Y_8960 MSMG1_X_5040_Y_8960 714.7m
R_VSMG1_2208 MSMG2_X_5600_Y_8960 MSMG1_X_5600_Y_8960 714.7m
R_VSMG1_2209 MSMG2_X_6160_Y_8960 MSMG1_X_6160_Y_8960 714.7m
R_VSMG1_2210 MSMG2_X_6720_Y_8960 MSMG1_X_6720_Y_8960 714.7m
R_VSMG1_2211 MSMG2_X_7280_Y_8960 MSMG1_X_7280_Y_8960 714.7m
R_VSMG1_2212 MSMG2_X_7840_Y_8960 MSMG1_X_7840_Y_8960 714.7m
R_VSMG1_2213 MSMG2_X_8400_Y_8960 MSMG1_X_8400_Y_8960 714.7m
R_VSMG1_2214 MSMG2_X_8960_Y_8960 MSMG1_X_8960_Y_8960 714.7m
R_VSMG1_2215 MSMG2_X_9520_Y_8960 MSMG1_X_9520_Y_8960 714.7m
R_VSMG1_2216 MSMG2_X_0_Y_9520 MSMG1_X_0_Y_9520 714.7m
R_VSMG1_2217 MSMG2_X_560_Y_9520 MSMG1_X_560_Y_9520 714.7m
R_VSMG1_2218 MSMG2_X_1120_Y_9520 MSMG1_X_1120_Y_9520 714.7m
R_VSMG1_2219 MSMG2_X_1680_Y_9520 MSMG1_X_1680_Y_9520 714.7m
R_VSMG1_2220 MSMG2_X_2240_Y_9520 MSMG1_X_2240_Y_9520 714.7m
R_VSMG1_2221 MSMG2_X_2800_Y_9520 MSMG1_X_2800_Y_9520 714.7m
R_VSMG1_2222 MSMG2_X_3360_Y_9520 MSMG1_X_3360_Y_9520 714.7m
R_VSMG1_2223 MSMG2_X_3920_Y_9520 MSMG1_X_3920_Y_9520 714.7m
R_VSMG1_2224 MSMG2_X_4480_Y_9520 MSMG1_X_4480_Y_9520 714.7m
R_VSMG1_2225 MSMG2_X_5040_Y_9520 MSMG1_X_5040_Y_9520 714.7m
R_VSMG1_2226 MSMG2_X_5600_Y_9520 MSMG1_X_5600_Y_9520 714.7m
R_VSMG1_2227 MSMG2_X_6160_Y_9520 MSMG1_X_6160_Y_9520 714.7m
R_VSMG1_2228 MSMG2_X_6720_Y_9520 MSMG1_X_6720_Y_9520 714.7m
R_VSMG1_2229 MSMG2_X_7280_Y_9520 MSMG1_X_7280_Y_9520 714.7m
R_VSMG1_2230 MSMG2_X_7840_Y_9520 MSMG1_X_7840_Y_9520 714.7m
R_VSMG1_2231 MSMG2_X_8400_Y_9520 MSMG1_X_8400_Y_9520 714.7m
R_VSMG1_2232 MSMG2_X_8960_Y_9520 MSMG1_X_8960_Y_9520 714.7m
R_VSMG1_2233 MSMG2_X_9520_Y_9520 MSMG1_X_9520_Y_9520 714.7m
R_VINT5_2234 MSMG1_X_0_Y_0 MINT5_X_0_Y_0 1.319
R_VINT5_2235 MSMG1_X_640_Y_0 MINT5_X_640_Y_0 1.319
R_VINT5_2236 MSMG1_X_1280_Y_0 MINT5_X_1280_Y_0 1.319
R_VINT5_2237 MSMG1_X_1920_Y_0 MINT5_X_1920_Y_0 1.319
R_VINT5_2238 MSMG1_X_2560_Y_0 MINT5_X_2560_Y_0 1.319
R_VINT5_2239 MSMG1_X_3200_Y_0 MINT5_X_3200_Y_0 1.319
R_VINT5_2240 MSMG1_X_3840_Y_0 MINT5_X_3840_Y_0 1.319
R_VINT5_2241 MSMG1_X_4480_Y_0 MINT5_X_4480_Y_0 1.319
R_VINT5_2242 MSMG1_X_5120_Y_0 MINT5_X_5120_Y_0 1.319
R_VINT5_2243 MSMG1_X_5760_Y_0 MINT5_X_5760_Y_0 1.319
R_VINT5_2244 MSMG1_X_6400_Y_0 MINT5_X_6400_Y_0 1.319
R_VINT5_2245 MSMG1_X_7040_Y_0 MINT5_X_7040_Y_0 1.319
R_VINT5_2246 MSMG1_X_7680_Y_0 MINT5_X_7680_Y_0 1.319
R_VINT5_2247 MSMG1_X_8320_Y_0 MINT5_X_8320_Y_0 1.319
R_VINT5_2248 MSMG1_X_8960_Y_0 MINT5_X_8960_Y_0 1.319
R_VINT5_2249 MSMG1_X_9600_Y_0 MINT5_X_9600_Y_0 1.319
R_VINT5_2250 MSMG1_X_320_Y_560 MINT5_X_320_Y_560 1.319
R_VINT5_2251 MSMG1_X_960_Y_560 MINT5_X_960_Y_560 1.319
R_VINT5_2252 MSMG1_X_1600_Y_560 MINT5_X_1600_Y_560 1.319
R_VINT5_2253 MSMG1_X_2240_Y_560 MINT5_X_2240_Y_560 1.319
R_VINT5_2254 MSMG1_X_2880_Y_560 MINT5_X_2880_Y_560 1.319
R_VINT5_2255 MSMG1_X_3520_Y_560 MINT5_X_3520_Y_560 1.319
R_VINT5_2256 MSMG1_X_4160_Y_560 MINT5_X_4160_Y_560 1.319
R_VINT5_2257 MSMG1_X_4800_Y_560 MINT5_X_4800_Y_560 1.319
R_VINT5_2258 MSMG1_X_5440_Y_560 MINT5_X_5440_Y_560 1.319
R_VINT5_2259 MSMG1_X_6080_Y_560 MINT5_X_6080_Y_560 1.319
R_VINT5_2260 MSMG1_X_6720_Y_560 MINT5_X_6720_Y_560 1.319
R_VINT5_2261 MSMG1_X_7360_Y_560 MINT5_X_7360_Y_560 1.319
R_VINT5_2262 MSMG1_X_8000_Y_560 MINT5_X_8000_Y_560 1.319
R_VINT5_2263 MSMG1_X_8640_Y_560 MINT5_X_8640_Y_560 1.319
R_VINT5_2264 MSMG1_X_9280_Y_560 MINT5_X_9280_Y_560 1.319
R_VINT5_2265 MSMG1_X_9920_Y_560 MINT5_X_9920_Y_560 1.319
R_VINT5_2266 MSMG1_X_0_Y_1120 MINT5_X_0_Y_1120 1.319
R_VINT5_2267 MSMG1_X_640_Y_1120 MINT5_X_640_Y_1120 1.319
R_VINT5_2268 MSMG1_X_1280_Y_1120 MINT5_X_1280_Y_1120 1.319
R_VINT5_2269 MSMG1_X_1920_Y_1120 MINT5_X_1920_Y_1120 1.319
R_VINT5_2270 MSMG1_X_2560_Y_1120 MINT5_X_2560_Y_1120 1.319
R_VINT5_2271 MSMG1_X_3200_Y_1120 MINT5_X_3200_Y_1120 1.319
R_VINT5_2272 MSMG1_X_3840_Y_1120 MINT5_X_3840_Y_1120 1.319
R_VINT5_2273 MSMG1_X_4480_Y_1120 MINT5_X_4480_Y_1120 1.319
R_VINT5_2274 MSMG1_X_5120_Y_1120 MINT5_X_5120_Y_1120 1.319
R_VINT5_2275 MSMG1_X_5760_Y_1120 MINT5_X_5760_Y_1120 1.319
R_VINT5_2276 MSMG1_X_6400_Y_1120 MINT5_X_6400_Y_1120 1.319
R_VINT5_2277 MSMG1_X_7040_Y_1120 MINT5_X_7040_Y_1120 1.319
R_VINT5_2278 MSMG1_X_7680_Y_1120 MINT5_X_7680_Y_1120 1.319
R_VINT5_2279 MSMG1_X_8320_Y_1120 MINT5_X_8320_Y_1120 1.319
R_VINT5_2280 MSMG1_X_8960_Y_1120 MINT5_X_8960_Y_1120 1.319
R_VINT5_2281 MSMG1_X_9600_Y_1120 MINT5_X_9600_Y_1120 1.319
R_VINT5_2282 MSMG1_X_320_Y_1680 MINT5_X_320_Y_1680 1.319
R_VINT5_2283 MSMG1_X_960_Y_1680 MINT5_X_960_Y_1680 1.319
R_VINT5_2284 MSMG1_X_1600_Y_1680 MINT5_X_1600_Y_1680 1.319
R_VINT5_2285 MSMG1_X_2240_Y_1680 MINT5_X_2240_Y_1680 1.319
R_VINT5_2286 MSMG1_X_2880_Y_1680 MINT5_X_2880_Y_1680 1.319
R_VINT5_2287 MSMG1_X_3520_Y_1680 MINT5_X_3520_Y_1680 1.319
R_VINT5_2288 MSMG1_X_4160_Y_1680 MINT5_X_4160_Y_1680 1.319
R_VINT5_2289 MSMG1_X_4800_Y_1680 MINT5_X_4800_Y_1680 1.319
R_VINT5_2290 MSMG1_X_5440_Y_1680 MINT5_X_5440_Y_1680 1.319
R_VINT5_2291 MSMG1_X_6080_Y_1680 MINT5_X_6080_Y_1680 1.319
R_VINT5_2292 MSMG1_X_6720_Y_1680 MINT5_X_6720_Y_1680 1.319
R_VINT5_2293 MSMG1_X_7360_Y_1680 MINT5_X_7360_Y_1680 1.319
R_VINT5_2294 MSMG1_X_8000_Y_1680 MINT5_X_8000_Y_1680 1.319
R_VINT5_2295 MSMG1_X_8640_Y_1680 MINT5_X_8640_Y_1680 1.319
R_VINT5_2296 MSMG1_X_9280_Y_1680 MINT5_X_9280_Y_1680 1.319
R_VINT5_2297 MSMG1_X_9920_Y_1680 MINT5_X_9920_Y_1680 1.319
R_VINT5_2298 MSMG1_X_0_Y_2240 MINT5_X_0_Y_2240 1.319
R_VINT5_2299 MSMG1_X_640_Y_2240 MINT5_X_640_Y_2240 1.319
R_VINT5_2300 MSMG1_X_1280_Y_2240 MINT5_X_1280_Y_2240 1.319
R_VINT5_2301 MSMG1_X_1920_Y_2240 MINT5_X_1920_Y_2240 1.319
R_VINT5_2302 MSMG1_X_2560_Y_2240 MINT5_X_2560_Y_2240 1.319
R_VINT5_2303 MSMG1_X_3200_Y_2240 MINT5_X_3200_Y_2240 1.319
R_VINT5_2304 MSMG1_X_3840_Y_2240 MINT5_X_3840_Y_2240 1.319
R_VINT5_2305 MSMG1_X_4480_Y_2240 MINT5_X_4480_Y_2240 1.319
R_VINT5_2306 MSMG1_X_5120_Y_2240 MINT5_X_5120_Y_2240 1.319
R_VINT5_2307 MSMG1_X_5760_Y_2240 MINT5_X_5760_Y_2240 1.319
R_VINT5_2308 MSMG1_X_6400_Y_2240 MINT5_X_6400_Y_2240 1.319
R_VINT5_2309 MSMG1_X_7040_Y_2240 MINT5_X_7040_Y_2240 1.319
R_VINT5_2310 MSMG1_X_7680_Y_2240 MINT5_X_7680_Y_2240 1.319
R_VINT5_2311 MSMG1_X_8320_Y_2240 MINT5_X_8320_Y_2240 1.319
R_VINT5_2312 MSMG1_X_8960_Y_2240 MINT5_X_8960_Y_2240 1.319
R_VINT5_2313 MSMG1_X_9600_Y_2240 MINT5_X_9600_Y_2240 1.319
R_VINT5_2314 MSMG1_X_320_Y_2800 MINT5_X_320_Y_2800 1.319
R_VINT5_2315 MSMG1_X_960_Y_2800 MINT5_X_960_Y_2800 1.319
R_VINT5_2316 MSMG1_X_1600_Y_2800 MINT5_X_1600_Y_2800 1.319
R_VINT5_2317 MSMG1_X_2240_Y_2800 MINT5_X_2240_Y_2800 1.319
R_VINT5_2318 MSMG1_X_2880_Y_2800 MINT5_X_2880_Y_2800 1.319
R_VINT5_2319 MSMG1_X_3520_Y_2800 MINT5_X_3520_Y_2800 1.319
R_VINT5_2320 MSMG1_X_4160_Y_2800 MINT5_X_4160_Y_2800 1.319
R_VINT5_2321 MSMG1_X_4800_Y_2800 MINT5_X_4800_Y_2800 1.319
R_VINT5_2322 MSMG1_X_5440_Y_2800 MINT5_X_5440_Y_2800 1.319
R_VINT5_2323 MSMG1_X_6080_Y_2800 MINT5_X_6080_Y_2800 1.319
R_VINT5_2324 MSMG1_X_6720_Y_2800 MINT5_X_6720_Y_2800 1.319
R_VINT5_2325 MSMG1_X_7360_Y_2800 MINT5_X_7360_Y_2800 1.319
R_VINT5_2326 MSMG1_X_8000_Y_2800 MINT5_X_8000_Y_2800 1.319
R_VINT5_2327 MSMG1_X_8640_Y_2800 MINT5_X_8640_Y_2800 1.319
R_VINT5_2328 MSMG1_X_9280_Y_2800 MINT5_X_9280_Y_2800 1.319
R_VINT5_2329 MSMG1_X_9920_Y_2800 MINT5_X_9920_Y_2800 1.319
R_VINT5_2330 MSMG1_X_0_Y_3360 MINT5_X_0_Y_3360 1.319
R_VINT5_2331 MSMG1_X_640_Y_3360 MINT5_X_640_Y_3360 1.319
R_VINT5_2332 MSMG1_X_1280_Y_3360 MINT5_X_1280_Y_3360 1.319
R_VINT5_2333 MSMG1_X_1920_Y_3360 MINT5_X_1920_Y_3360 1.319
R_VINT5_2334 MSMG1_X_2560_Y_3360 MINT5_X_2560_Y_3360 1.319
R_VINT5_2335 MSMG1_X_3200_Y_3360 MINT5_X_3200_Y_3360 1.319
R_VINT5_2336 MSMG1_X_3840_Y_3360 MINT5_X_3840_Y_3360 1.319
R_VINT5_2337 MSMG1_X_4480_Y_3360 MINT5_X_4480_Y_3360 1.319
R_VINT5_2338 MSMG1_X_5120_Y_3360 MINT5_X_5120_Y_3360 1.319
R_VINT5_2339 MSMG1_X_5760_Y_3360 MINT5_X_5760_Y_3360 1.319
R_VINT5_2340 MSMG1_X_6400_Y_3360 MINT5_X_6400_Y_3360 1.319
R_VINT5_2341 MSMG1_X_7040_Y_3360 MINT5_X_7040_Y_3360 1.319
R_VINT5_2342 MSMG1_X_7680_Y_3360 MINT5_X_7680_Y_3360 1.319
R_VINT5_2343 MSMG1_X_8320_Y_3360 MINT5_X_8320_Y_3360 1.319
R_VINT5_2344 MSMG1_X_8960_Y_3360 MINT5_X_8960_Y_3360 1.319
R_VINT5_2345 MSMG1_X_9600_Y_3360 MINT5_X_9600_Y_3360 1.319
R_VINT5_2346 MSMG1_X_320_Y_3920 MINT5_X_320_Y_3920 1.319
R_VINT5_2347 MSMG1_X_960_Y_3920 MINT5_X_960_Y_3920 1.319
R_VINT5_2348 MSMG1_X_1600_Y_3920 MINT5_X_1600_Y_3920 1.319
R_VINT5_2349 MSMG1_X_2240_Y_3920 MINT5_X_2240_Y_3920 1.319
R_VINT5_2350 MSMG1_X_2880_Y_3920 MINT5_X_2880_Y_3920 1.319
R_VINT5_2351 MSMG1_X_3520_Y_3920 MINT5_X_3520_Y_3920 1.319
R_VINT5_2352 MSMG1_X_4160_Y_3920 MINT5_X_4160_Y_3920 1.319
R_VINT5_2353 MSMG1_X_4800_Y_3920 MINT5_X_4800_Y_3920 1.319
R_VINT5_2354 MSMG1_X_5440_Y_3920 MINT5_X_5440_Y_3920 1.319
R_VINT5_2355 MSMG1_X_6080_Y_3920 MINT5_X_6080_Y_3920 1.319
R_VINT5_2356 MSMG1_X_6720_Y_3920 MINT5_X_6720_Y_3920 1.319
R_VINT5_2357 MSMG1_X_7360_Y_3920 MINT5_X_7360_Y_3920 1.319
R_VINT5_2358 MSMG1_X_8000_Y_3920 MINT5_X_8000_Y_3920 1.319
R_VINT5_2359 MSMG1_X_8640_Y_3920 MINT5_X_8640_Y_3920 1.319
R_VINT5_2360 MSMG1_X_9280_Y_3920 MINT5_X_9280_Y_3920 1.319
R_VINT5_2361 MSMG1_X_9920_Y_3920 MINT5_X_9920_Y_3920 1.319
R_VINT5_2362 MSMG1_X_0_Y_4480 MINT5_X_0_Y_4480 1.319
R_VINT5_2363 MSMG1_X_640_Y_4480 MINT5_X_640_Y_4480 1.319
R_VINT5_2364 MSMG1_X_1280_Y_4480 MINT5_X_1280_Y_4480 1.319
R_VINT5_2365 MSMG1_X_1920_Y_4480 MINT5_X_1920_Y_4480 1.319
R_VINT5_2366 MSMG1_X_2560_Y_4480 MINT5_X_2560_Y_4480 1.319
R_VINT5_2367 MSMG1_X_3200_Y_4480 MINT5_X_3200_Y_4480 1.319
R_VINT5_2368 MSMG1_X_3840_Y_4480 MINT5_X_3840_Y_4480 1.319
R_VINT5_2369 MSMG1_X_4480_Y_4480 MINT5_X_4480_Y_4480 1.319
R_VINT5_2370 MSMG1_X_5120_Y_4480 MINT5_X_5120_Y_4480 1.319
R_VINT5_2371 MSMG1_X_5760_Y_4480 MINT5_X_5760_Y_4480 1.319
R_VINT5_2372 MSMG1_X_6400_Y_4480 MINT5_X_6400_Y_4480 1.319
R_VINT5_2373 MSMG1_X_7040_Y_4480 MINT5_X_7040_Y_4480 1.319
R_VINT5_2374 MSMG1_X_7680_Y_4480 MINT5_X_7680_Y_4480 1.319
R_VINT5_2375 MSMG1_X_8320_Y_4480 MINT5_X_8320_Y_4480 1.319
R_VINT5_2376 MSMG1_X_8960_Y_4480 MINT5_X_8960_Y_4480 1.319
R_VINT5_2377 MSMG1_X_9600_Y_4480 MINT5_X_9600_Y_4480 1.319
R_VINT5_2378 MSMG1_X_320_Y_5040 MINT5_X_320_Y_5040 1.319
R_VINT5_2379 MSMG1_X_960_Y_5040 MINT5_X_960_Y_5040 1.319
R_VINT5_2380 MSMG1_X_1600_Y_5040 MINT5_X_1600_Y_5040 1.319
R_VINT5_2381 MSMG1_X_2240_Y_5040 MINT5_X_2240_Y_5040 1.319
R_VINT5_2382 MSMG1_X_2880_Y_5040 MINT5_X_2880_Y_5040 1.319
R_VINT5_2383 MSMG1_X_3520_Y_5040 MINT5_X_3520_Y_5040 1.319
R_VINT5_2384 MSMG1_X_4160_Y_5040 MINT5_X_4160_Y_5040 1.319
R_VINT5_2385 MSMG1_X_4800_Y_5040 MINT5_X_4800_Y_5040 1.319
R_VINT5_2386 MSMG1_X_5440_Y_5040 MINT5_X_5440_Y_5040 1.319
R_VINT5_2387 MSMG1_X_6080_Y_5040 MINT5_X_6080_Y_5040 1.319
R_VINT5_2388 MSMG1_X_6720_Y_5040 MINT5_X_6720_Y_5040 1.319
R_VINT5_2389 MSMG1_X_7360_Y_5040 MINT5_X_7360_Y_5040 1.319
R_VINT5_2390 MSMG1_X_8000_Y_5040 MINT5_X_8000_Y_5040 1.319
R_VINT5_2391 MSMG1_X_8640_Y_5040 MINT5_X_8640_Y_5040 1.319
R_VINT5_2392 MSMG1_X_9280_Y_5040 MINT5_X_9280_Y_5040 1.319
R_VINT5_2393 MSMG1_X_9920_Y_5040 MINT5_X_9920_Y_5040 1.319
R_VINT5_2394 MSMG1_X_0_Y_5600 MINT5_X_0_Y_5600 1.319
R_VINT5_2395 MSMG1_X_640_Y_5600 MINT5_X_640_Y_5600 1.319
R_VINT5_2396 MSMG1_X_1280_Y_5600 MINT5_X_1280_Y_5600 1.319
R_VINT5_2397 MSMG1_X_1920_Y_5600 MINT5_X_1920_Y_5600 1.319
R_VINT5_2398 MSMG1_X_2560_Y_5600 MINT5_X_2560_Y_5600 1.319
R_VINT5_2399 MSMG1_X_3200_Y_5600 MINT5_X_3200_Y_5600 1.319
R_VINT5_2400 MSMG1_X_3840_Y_5600 MINT5_X_3840_Y_5600 1.319
R_VINT5_2401 MSMG1_X_4480_Y_5600 MINT5_X_4480_Y_5600 1.319
R_VINT5_2402 MSMG1_X_5120_Y_5600 MINT5_X_5120_Y_5600 1.319
R_VINT5_2403 MSMG1_X_5760_Y_5600 MINT5_X_5760_Y_5600 1.319
R_VINT5_2404 MSMG1_X_6400_Y_5600 MINT5_X_6400_Y_5600 1.319
R_VINT5_2405 MSMG1_X_7040_Y_5600 MINT5_X_7040_Y_5600 1.319
R_VINT5_2406 MSMG1_X_7680_Y_5600 MINT5_X_7680_Y_5600 1.319
R_VINT5_2407 MSMG1_X_8320_Y_5600 MINT5_X_8320_Y_5600 1.319
R_VINT5_2408 MSMG1_X_8960_Y_5600 MINT5_X_8960_Y_5600 1.319
R_VINT5_2409 MSMG1_X_9600_Y_5600 MINT5_X_9600_Y_5600 1.319
R_VINT5_2410 MSMG1_X_320_Y_6160 MINT5_X_320_Y_6160 1.319
R_VINT5_2411 MSMG1_X_960_Y_6160 MINT5_X_960_Y_6160 1.319
R_VINT5_2412 MSMG1_X_1600_Y_6160 MINT5_X_1600_Y_6160 1.319
R_VINT5_2413 MSMG1_X_2240_Y_6160 MINT5_X_2240_Y_6160 1.319
R_VINT5_2414 MSMG1_X_2880_Y_6160 MINT5_X_2880_Y_6160 1.319
R_VINT5_2415 MSMG1_X_3520_Y_6160 MINT5_X_3520_Y_6160 1.319
R_VINT5_2416 MSMG1_X_4160_Y_6160 MINT5_X_4160_Y_6160 1.319
R_VINT5_2417 MSMG1_X_4800_Y_6160 MINT5_X_4800_Y_6160 1.319
R_VINT5_2418 MSMG1_X_5440_Y_6160 MINT5_X_5440_Y_6160 1.319
R_VINT5_2419 MSMG1_X_6080_Y_6160 MINT5_X_6080_Y_6160 1.319
R_VINT5_2420 MSMG1_X_6720_Y_6160 MINT5_X_6720_Y_6160 1.319
R_VINT5_2421 MSMG1_X_7360_Y_6160 MINT5_X_7360_Y_6160 1.319
R_VINT5_2422 MSMG1_X_8000_Y_6160 MINT5_X_8000_Y_6160 1.319
R_VINT5_2423 MSMG1_X_8640_Y_6160 MINT5_X_8640_Y_6160 1.319
R_VINT5_2424 MSMG1_X_9280_Y_6160 MINT5_X_9280_Y_6160 1.319
R_VINT5_2425 MSMG1_X_9920_Y_6160 MINT5_X_9920_Y_6160 1.319
R_VINT5_2426 MSMG1_X_0_Y_6720 MINT5_X_0_Y_6720 1.319
R_VINT5_2427 MSMG1_X_640_Y_6720 MINT5_X_640_Y_6720 1.319
R_VINT5_2428 MSMG1_X_1280_Y_6720 MINT5_X_1280_Y_6720 1.319
R_VINT5_2429 MSMG1_X_1920_Y_6720 MINT5_X_1920_Y_6720 1.319
R_VINT5_2430 MSMG1_X_2560_Y_6720 MINT5_X_2560_Y_6720 1.319
R_VINT5_2431 MSMG1_X_3200_Y_6720 MINT5_X_3200_Y_6720 1.319
R_VINT5_2432 MSMG1_X_3840_Y_6720 MINT5_X_3840_Y_6720 1.319
R_VINT5_2433 MSMG1_X_4480_Y_6720 MINT5_X_4480_Y_6720 1.319
R_VINT5_2434 MSMG1_X_5120_Y_6720 MINT5_X_5120_Y_6720 1.319
R_VINT5_2435 MSMG1_X_5760_Y_6720 MINT5_X_5760_Y_6720 1.319
R_VINT5_2436 MSMG1_X_6400_Y_6720 MINT5_X_6400_Y_6720 1.319
R_VINT5_2437 MSMG1_X_7040_Y_6720 MINT5_X_7040_Y_6720 1.319
R_VINT5_2438 MSMG1_X_7680_Y_6720 MINT5_X_7680_Y_6720 1.319
R_VINT5_2439 MSMG1_X_8320_Y_6720 MINT5_X_8320_Y_6720 1.319
R_VINT5_2440 MSMG1_X_8960_Y_6720 MINT5_X_8960_Y_6720 1.319
R_VINT5_2441 MSMG1_X_9600_Y_6720 MINT5_X_9600_Y_6720 1.319
R_VINT5_2442 MSMG1_X_320_Y_7280 MINT5_X_320_Y_7280 1.319
R_VINT5_2443 MSMG1_X_960_Y_7280 MINT5_X_960_Y_7280 1.319
R_VINT5_2444 MSMG1_X_1600_Y_7280 MINT5_X_1600_Y_7280 1.319
R_VINT5_2445 MSMG1_X_2240_Y_7280 MINT5_X_2240_Y_7280 1.319
R_VINT5_2446 MSMG1_X_2880_Y_7280 MINT5_X_2880_Y_7280 1.319
R_VINT5_2447 MSMG1_X_3520_Y_7280 MINT5_X_3520_Y_7280 1.319
R_VINT5_2448 MSMG1_X_4160_Y_7280 MINT5_X_4160_Y_7280 1.319
R_VINT5_2449 MSMG1_X_4800_Y_7280 MINT5_X_4800_Y_7280 1.319
R_VINT5_2450 MSMG1_X_5440_Y_7280 MINT5_X_5440_Y_7280 1.319
R_VINT5_2451 MSMG1_X_6080_Y_7280 MINT5_X_6080_Y_7280 1.319
R_VINT5_2452 MSMG1_X_6720_Y_7280 MINT5_X_6720_Y_7280 1.319
R_VINT5_2453 MSMG1_X_7360_Y_7280 MINT5_X_7360_Y_7280 1.319
R_VINT5_2454 MSMG1_X_8000_Y_7280 MINT5_X_8000_Y_7280 1.319
R_VINT5_2455 MSMG1_X_8640_Y_7280 MINT5_X_8640_Y_7280 1.319
R_VINT5_2456 MSMG1_X_9280_Y_7280 MINT5_X_9280_Y_7280 1.319
R_VINT5_2457 MSMG1_X_9920_Y_7280 MINT5_X_9920_Y_7280 1.319
R_VINT5_2458 MSMG1_X_0_Y_7840 MINT5_X_0_Y_7840 1.319
R_VINT5_2459 MSMG1_X_640_Y_7840 MINT5_X_640_Y_7840 1.319
R_VINT5_2460 MSMG1_X_1280_Y_7840 MINT5_X_1280_Y_7840 1.319
R_VINT5_2461 MSMG1_X_1920_Y_7840 MINT5_X_1920_Y_7840 1.319
R_VINT5_2462 MSMG1_X_2560_Y_7840 MINT5_X_2560_Y_7840 1.319
R_VINT5_2463 MSMG1_X_3200_Y_7840 MINT5_X_3200_Y_7840 1.319
R_VINT5_2464 MSMG1_X_3840_Y_7840 MINT5_X_3840_Y_7840 1.319
R_VINT5_2465 MSMG1_X_4480_Y_7840 MINT5_X_4480_Y_7840 1.319
R_VINT5_2466 MSMG1_X_5120_Y_7840 MINT5_X_5120_Y_7840 1.319
R_VINT5_2467 MSMG1_X_5760_Y_7840 MINT5_X_5760_Y_7840 1.319
R_VINT5_2468 MSMG1_X_6400_Y_7840 MINT5_X_6400_Y_7840 1.319
R_VINT5_2469 MSMG1_X_7040_Y_7840 MINT5_X_7040_Y_7840 1.319
R_VINT5_2470 MSMG1_X_7680_Y_7840 MINT5_X_7680_Y_7840 1.319
R_VINT5_2471 MSMG1_X_8320_Y_7840 MINT5_X_8320_Y_7840 1.319
R_VINT5_2472 MSMG1_X_8960_Y_7840 MINT5_X_8960_Y_7840 1.319
R_VINT5_2473 MSMG1_X_9600_Y_7840 MINT5_X_9600_Y_7840 1.319
R_VINT5_2474 MSMG1_X_320_Y_8400 MINT5_X_320_Y_8400 1.319
R_VINT5_2475 MSMG1_X_960_Y_8400 MINT5_X_960_Y_8400 1.319
R_VINT5_2476 MSMG1_X_1600_Y_8400 MINT5_X_1600_Y_8400 1.319
R_VINT5_2477 MSMG1_X_2240_Y_8400 MINT5_X_2240_Y_8400 1.319
R_VINT5_2478 MSMG1_X_2880_Y_8400 MINT5_X_2880_Y_8400 1.319
R_VINT5_2479 MSMG1_X_3520_Y_8400 MINT5_X_3520_Y_8400 1.319
R_VINT5_2480 MSMG1_X_4160_Y_8400 MINT5_X_4160_Y_8400 1.319
R_VINT5_2481 MSMG1_X_4800_Y_8400 MINT5_X_4800_Y_8400 1.319
R_VINT5_2482 MSMG1_X_5440_Y_8400 MINT5_X_5440_Y_8400 1.319
R_VINT5_2483 MSMG1_X_6080_Y_8400 MINT5_X_6080_Y_8400 1.319
R_VINT5_2484 MSMG1_X_6720_Y_8400 MINT5_X_6720_Y_8400 1.319
R_VINT5_2485 MSMG1_X_7360_Y_8400 MINT5_X_7360_Y_8400 1.319
R_VINT5_2486 MSMG1_X_8000_Y_8400 MINT5_X_8000_Y_8400 1.319
R_VINT5_2487 MSMG1_X_8640_Y_8400 MINT5_X_8640_Y_8400 1.319
R_VINT5_2488 MSMG1_X_9280_Y_8400 MINT5_X_9280_Y_8400 1.319
R_VINT5_2489 MSMG1_X_9920_Y_8400 MINT5_X_9920_Y_8400 1.319
R_VINT5_2490 MSMG1_X_0_Y_8960 MINT5_X_0_Y_8960 1.319
R_VINT5_2491 MSMG1_X_640_Y_8960 MINT5_X_640_Y_8960 1.319
R_VINT5_2492 MSMG1_X_1280_Y_8960 MINT5_X_1280_Y_8960 1.319
R_VINT5_2493 MSMG1_X_1920_Y_8960 MINT5_X_1920_Y_8960 1.319
R_VINT5_2494 MSMG1_X_2560_Y_8960 MINT5_X_2560_Y_8960 1.319
R_VINT5_2495 MSMG1_X_3200_Y_8960 MINT5_X_3200_Y_8960 1.319
R_VINT5_2496 MSMG1_X_3840_Y_8960 MINT5_X_3840_Y_8960 1.319
R_VINT5_2497 MSMG1_X_4480_Y_8960 MINT5_X_4480_Y_8960 1.319
R_VINT5_2498 MSMG1_X_5120_Y_8960 MINT5_X_5120_Y_8960 1.319
R_VINT5_2499 MSMG1_X_5760_Y_8960 MINT5_X_5760_Y_8960 1.319
R_VINT5_2500 MSMG1_X_6400_Y_8960 MINT5_X_6400_Y_8960 1.319
R_VINT5_2501 MSMG1_X_7040_Y_8960 MINT5_X_7040_Y_8960 1.319
R_VINT5_2502 MSMG1_X_7680_Y_8960 MINT5_X_7680_Y_8960 1.319
R_VINT5_2503 MSMG1_X_8320_Y_8960 MINT5_X_8320_Y_8960 1.319
R_VINT5_2504 MSMG1_X_8960_Y_8960 MINT5_X_8960_Y_8960 1.319
R_VINT5_2505 MSMG1_X_9600_Y_8960 MINT5_X_9600_Y_8960 1.319
R_VINT5_2506 MSMG1_X_320_Y_9520 MINT5_X_320_Y_9520 1.319
R_VINT5_2507 MSMG1_X_960_Y_9520 MINT5_X_960_Y_9520 1.319
R_VINT5_2508 MSMG1_X_1600_Y_9520 MINT5_X_1600_Y_9520 1.319
R_VINT5_2509 MSMG1_X_2240_Y_9520 MINT5_X_2240_Y_9520 1.319
R_VINT5_2510 MSMG1_X_2880_Y_9520 MINT5_X_2880_Y_9520 1.319
R_VINT5_2511 MSMG1_X_3520_Y_9520 MINT5_X_3520_Y_9520 1.319
R_VINT5_2512 MSMG1_X_4160_Y_9520 MINT5_X_4160_Y_9520 1.319
R_VINT5_2513 MSMG1_X_4800_Y_9520 MINT5_X_4800_Y_9520 1.319
R_VINT5_2514 MSMG1_X_5440_Y_9520 MINT5_X_5440_Y_9520 1.319
R_VINT5_2515 MSMG1_X_6080_Y_9520 MINT5_X_6080_Y_9520 1.319
R_VINT5_2516 MSMG1_X_6720_Y_9520 MINT5_X_6720_Y_9520 1.319
R_VINT5_2517 MSMG1_X_7360_Y_9520 MINT5_X_7360_Y_9520 1.319
R_VINT5_2518 MSMG1_X_8000_Y_9520 MINT5_X_8000_Y_9520 1.319
R_VINT5_2519 MSMG1_X_8640_Y_9520 MINT5_X_8640_Y_9520 1.319
R_VINT5_2520 MSMG1_X_9280_Y_9520 MINT5_X_9280_Y_9520 1.319
R_VINT5_2521 MSMG1_X_9920_Y_9520 MINT5_X_9920_Y_9520 1.319
R_VINT4_2522 MINT5_X_0_Y_0 MINT4_X_0_Y_0 1.319
R_VINT4_2523 MINT5_X_0_Y_320 MINT4_X_0_Y_320 1.319
R_VINT4_2524 MINT5_X_0_Y_640 MINT4_X_0_Y_640 1.319
R_VINT4_2525 MINT5_X_0_Y_960 MINT4_X_0_Y_960 1.319
R_VINT4_2526 MINT5_X_0_Y_1280 MINT4_X_0_Y_1280 1.319
R_VINT4_2527 MINT5_X_0_Y_1600 MINT4_X_0_Y_1600 1.319
R_VINT4_2528 MINT5_X_0_Y_1920 MINT4_X_0_Y_1920 1.319
R_VINT4_2529 MINT5_X_0_Y_2240 MINT4_X_0_Y_2240 1.319
R_VINT4_2530 MINT5_X_0_Y_2560 MINT4_X_0_Y_2560 1.319
R_VINT4_2531 MINT5_X_0_Y_2880 MINT4_X_0_Y_2880 1.319
R_VINT4_2532 MINT5_X_0_Y_3200 MINT4_X_0_Y_3200 1.319
R_VINT4_2533 MINT5_X_0_Y_3520 MINT4_X_0_Y_3520 1.319
R_VINT4_2534 MINT5_X_0_Y_3840 MINT4_X_0_Y_3840 1.319
R_VINT4_2535 MINT5_X_0_Y_4160 MINT4_X_0_Y_4160 1.319
R_VINT4_2536 MINT5_X_0_Y_4480 MINT4_X_0_Y_4480 1.319
R_VINT4_2537 MINT5_X_0_Y_4800 MINT4_X_0_Y_4800 1.319
R_VINT4_2538 MINT5_X_0_Y_5120 MINT4_X_0_Y_5120 1.319
R_VINT4_2539 MINT5_X_0_Y_5440 MINT4_X_0_Y_5440 1.319
R_VINT4_2540 MINT5_X_0_Y_5760 MINT4_X_0_Y_5760 1.319
R_VINT4_2541 MINT5_X_0_Y_6080 MINT4_X_0_Y_6080 1.319
R_VINT4_2542 MINT5_X_0_Y_6400 MINT4_X_0_Y_6400 1.319
R_VINT4_2543 MINT5_X_0_Y_6720 MINT4_X_0_Y_6720 1.319
R_VINT4_2544 MINT5_X_0_Y_7040 MINT4_X_0_Y_7040 1.319
R_VINT4_2545 MINT5_X_0_Y_7360 MINT4_X_0_Y_7360 1.319
R_VINT4_2546 MINT5_X_0_Y_7680 MINT4_X_0_Y_7680 1.319
R_VINT4_2547 MINT5_X_0_Y_8000 MINT4_X_0_Y_8000 1.319
R_VINT4_2548 MINT5_X_0_Y_8320 MINT4_X_0_Y_8320 1.319
R_VINT4_2549 MINT5_X_0_Y_8640 MINT4_X_0_Y_8640 1.319
R_VINT4_2550 MINT5_X_0_Y_8960 MINT4_X_0_Y_8960 1.319
R_VINT4_2551 MINT5_X_0_Y_9280 MINT4_X_0_Y_9280 1.319
R_VINT4_2552 MINT5_X_0_Y_9600 MINT4_X_0_Y_9600 1.319
R_VINT4_2553 MINT5_X_0_Y_9920 MINT4_X_0_Y_9920 1.319
R_VINT4_2554 MINT5_X_320_Y_0 MINT4_X_320_Y_0 1.319
R_VINT4_2555 MINT5_X_320_Y_320 MINT4_X_320_Y_320 1.319
R_VINT4_2556 MINT5_X_320_Y_640 MINT4_X_320_Y_640 1.319
R_VINT4_2557 MINT5_X_320_Y_960 MINT4_X_320_Y_960 1.319
R_VINT4_2558 MINT5_X_320_Y_1280 MINT4_X_320_Y_1280 1.319
R_VINT4_2559 MINT5_X_320_Y_1600 MINT4_X_320_Y_1600 1.319
R_VINT4_2560 MINT5_X_320_Y_1920 MINT4_X_320_Y_1920 1.319
R_VINT4_2561 MINT5_X_320_Y_2240 MINT4_X_320_Y_2240 1.319
R_VINT4_2562 MINT5_X_320_Y_2560 MINT4_X_320_Y_2560 1.319
R_VINT4_2563 MINT5_X_320_Y_2880 MINT4_X_320_Y_2880 1.319
R_VINT4_2564 MINT5_X_320_Y_3200 MINT4_X_320_Y_3200 1.319
R_VINT4_2565 MINT5_X_320_Y_3520 MINT4_X_320_Y_3520 1.319
R_VINT4_2566 MINT5_X_320_Y_3840 MINT4_X_320_Y_3840 1.319
R_VINT4_2567 MINT5_X_320_Y_4160 MINT4_X_320_Y_4160 1.319
R_VINT4_2568 MINT5_X_320_Y_4480 MINT4_X_320_Y_4480 1.319
R_VINT4_2569 MINT5_X_320_Y_4800 MINT4_X_320_Y_4800 1.319
R_VINT4_2570 MINT5_X_320_Y_5120 MINT4_X_320_Y_5120 1.319
R_VINT4_2571 MINT5_X_320_Y_5440 MINT4_X_320_Y_5440 1.319
R_VINT4_2572 MINT5_X_320_Y_5760 MINT4_X_320_Y_5760 1.319
R_VINT4_2573 MINT5_X_320_Y_6080 MINT4_X_320_Y_6080 1.319
R_VINT4_2574 MINT5_X_320_Y_6400 MINT4_X_320_Y_6400 1.319
R_VINT4_2575 MINT5_X_320_Y_6720 MINT4_X_320_Y_6720 1.319
R_VINT4_2576 MINT5_X_320_Y_7040 MINT4_X_320_Y_7040 1.319
R_VINT4_2577 MINT5_X_320_Y_7360 MINT4_X_320_Y_7360 1.319
R_VINT4_2578 MINT5_X_320_Y_7680 MINT4_X_320_Y_7680 1.319
R_VINT4_2579 MINT5_X_320_Y_8000 MINT4_X_320_Y_8000 1.319
R_VINT4_2580 MINT5_X_320_Y_8320 MINT4_X_320_Y_8320 1.319
R_VINT4_2581 MINT5_X_320_Y_8640 MINT4_X_320_Y_8640 1.319
R_VINT4_2582 MINT5_X_320_Y_8960 MINT4_X_320_Y_8960 1.319
R_VINT4_2583 MINT5_X_320_Y_9280 MINT4_X_320_Y_9280 1.319
R_VINT4_2584 MINT5_X_320_Y_9600 MINT4_X_320_Y_9600 1.319
R_VINT4_2585 MINT5_X_320_Y_9920 MINT4_X_320_Y_9920 1.319
R_VINT4_2586 MINT5_X_640_Y_0 MINT4_X_640_Y_0 1.319
R_VINT4_2587 MINT5_X_640_Y_320 MINT4_X_640_Y_320 1.319
R_VINT4_2588 MINT5_X_640_Y_640 MINT4_X_640_Y_640 1.319
R_VINT4_2589 MINT5_X_640_Y_960 MINT4_X_640_Y_960 1.319
R_VINT4_2590 MINT5_X_640_Y_1280 MINT4_X_640_Y_1280 1.319
R_VINT4_2591 MINT5_X_640_Y_1600 MINT4_X_640_Y_1600 1.319
R_VINT4_2592 MINT5_X_640_Y_1920 MINT4_X_640_Y_1920 1.319
R_VINT4_2593 MINT5_X_640_Y_2240 MINT4_X_640_Y_2240 1.319
R_VINT4_2594 MINT5_X_640_Y_2560 MINT4_X_640_Y_2560 1.319
R_VINT4_2595 MINT5_X_640_Y_2880 MINT4_X_640_Y_2880 1.319
R_VINT4_2596 MINT5_X_640_Y_3200 MINT4_X_640_Y_3200 1.319
R_VINT4_2597 MINT5_X_640_Y_3520 MINT4_X_640_Y_3520 1.319
R_VINT4_2598 MINT5_X_640_Y_3840 MINT4_X_640_Y_3840 1.319
R_VINT4_2599 MINT5_X_640_Y_4160 MINT4_X_640_Y_4160 1.319
R_VINT4_2600 MINT5_X_640_Y_4480 MINT4_X_640_Y_4480 1.319
R_VINT4_2601 MINT5_X_640_Y_4800 MINT4_X_640_Y_4800 1.319
R_VINT4_2602 MINT5_X_640_Y_5120 MINT4_X_640_Y_5120 1.319
R_VINT4_2603 MINT5_X_640_Y_5440 MINT4_X_640_Y_5440 1.319
R_VINT4_2604 MINT5_X_640_Y_5760 MINT4_X_640_Y_5760 1.319
R_VINT4_2605 MINT5_X_640_Y_6080 MINT4_X_640_Y_6080 1.319
R_VINT4_2606 MINT5_X_640_Y_6400 MINT4_X_640_Y_6400 1.319
R_VINT4_2607 MINT5_X_640_Y_6720 MINT4_X_640_Y_6720 1.319
R_VINT4_2608 MINT5_X_640_Y_7040 MINT4_X_640_Y_7040 1.319
R_VINT4_2609 MINT5_X_640_Y_7360 MINT4_X_640_Y_7360 1.319
R_VINT4_2610 MINT5_X_640_Y_7680 MINT4_X_640_Y_7680 1.319
R_VINT4_2611 MINT5_X_640_Y_8000 MINT4_X_640_Y_8000 1.319
R_VINT4_2612 MINT5_X_640_Y_8320 MINT4_X_640_Y_8320 1.319
R_VINT4_2613 MINT5_X_640_Y_8640 MINT4_X_640_Y_8640 1.319
R_VINT4_2614 MINT5_X_640_Y_8960 MINT4_X_640_Y_8960 1.319
R_VINT4_2615 MINT5_X_640_Y_9280 MINT4_X_640_Y_9280 1.319
R_VINT4_2616 MINT5_X_640_Y_9600 MINT4_X_640_Y_9600 1.319
R_VINT4_2617 MINT5_X_640_Y_9920 MINT4_X_640_Y_9920 1.319
R_VINT4_2618 MINT5_X_960_Y_0 MINT4_X_960_Y_0 1.319
R_VINT4_2619 MINT5_X_960_Y_320 MINT4_X_960_Y_320 1.319
R_VINT4_2620 MINT5_X_960_Y_640 MINT4_X_960_Y_640 1.319
R_VINT4_2621 MINT5_X_960_Y_960 MINT4_X_960_Y_960 1.319
R_VINT4_2622 MINT5_X_960_Y_1280 MINT4_X_960_Y_1280 1.319
R_VINT4_2623 MINT5_X_960_Y_1600 MINT4_X_960_Y_1600 1.319
R_VINT4_2624 MINT5_X_960_Y_1920 MINT4_X_960_Y_1920 1.319
R_VINT4_2625 MINT5_X_960_Y_2240 MINT4_X_960_Y_2240 1.319
R_VINT4_2626 MINT5_X_960_Y_2560 MINT4_X_960_Y_2560 1.319
R_VINT4_2627 MINT5_X_960_Y_2880 MINT4_X_960_Y_2880 1.319
R_VINT4_2628 MINT5_X_960_Y_3200 MINT4_X_960_Y_3200 1.319
R_VINT4_2629 MINT5_X_960_Y_3520 MINT4_X_960_Y_3520 1.319
R_VINT4_2630 MINT5_X_960_Y_3840 MINT4_X_960_Y_3840 1.319
R_VINT4_2631 MINT5_X_960_Y_4160 MINT4_X_960_Y_4160 1.319
R_VINT4_2632 MINT5_X_960_Y_4480 MINT4_X_960_Y_4480 1.319
R_VINT4_2633 MINT5_X_960_Y_4800 MINT4_X_960_Y_4800 1.319
R_VINT4_2634 MINT5_X_960_Y_5120 MINT4_X_960_Y_5120 1.319
R_VINT4_2635 MINT5_X_960_Y_5440 MINT4_X_960_Y_5440 1.319
R_VINT4_2636 MINT5_X_960_Y_5760 MINT4_X_960_Y_5760 1.319
R_VINT4_2637 MINT5_X_960_Y_6080 MINT4_X_960_Y_6080 1.319
R_VINT4_2638 MINT5_X_960_Y_6400 MINT4_X_960_Y_6400 1.319
R_VINT4_2639 MINT5_X_960_Y_6720 MINT4_X_960_Y_6720 1.319
R_VINT4_2640 MINT5_X_960_Y_7040 MINT4_X_960_Y_7040 1.319
R_VINT4_2641 MINT5_X_960_Y_7360 MINT4_X_960_Y_7360 1.319
R_VINT4_2642 MINT5_X_960_Y_7680 MINT4_X_960_Y_7680 1.319
R_VINT4_2643 MINT5_X_960_Y_8000 MINT4_X_960_Y_8000 1.319
R_VINT4_2644 MINT5_X_960_Y_8320 MINT4_X_960_Y_8320 1.319
R_VINT4_2645 MINT5_X_960_Y_8640 MINT4_X_960_Y_8640 1.319
R_VINT4_2646 MINT5_X_960_Y_8960 MINT4_X_960_Y_8960 1.319
R_VINT4_2647 MINT5_X_960_Y_9280 MINT4_X_960_Y_9280 1.319
R_VINT4_2648 MINT5_X_960_Y_9600 MINT4_X_960_Y_9600 1.319
R_VINT4_2649 MINT5_X_960_Y_9920 MINT4_X_960_Y_9920 1.319
R_VINT4_2650 MINT5_X_1280_Y_0 MINT4_X_1280_Y_0 1.319
R_VINT4_2651 MINT5_X_1280_Y_320 MINT4_X_1280_Y_320 1.319
R_VINT4_2652 MINT5_X_1280_Y_640 MINT4_X_1280_Y_640 1.319
R_VINT4_2653 MINT5_X_1280_Y_960 MINT4_X_1280_Y_960 1.319
R_VINT4_2654 MINT5_X_1280_Y_1280 MINT4_X_1280_Y_1280 1.319
R_VINT4_2655 MINT5_X_1280_Y_1600 MINT4_X_1280_Y_1600 1.319
R_VINT4_2656 MINT5_X_1280_Y_1920 MINT4_X_1280_Y_1920 1.319
R_VINT4_2657 MINT5_X_1280_Y_2240 MINT4_X_1280_Y_2240 1.319
R_VINT4_2658 MINT5_X_1280_Y_2560 MINT4_X_1280_Y_2560 1.319
R_VINT4_2659 MINT5_X_1280_Y_2880 MINT4_X_1280_Y_2880 1.319
R_VINT4_2660 MINT5_X_1280_Y_3200 MINT4_X_1280_Y_3200 1.319
R_VINT4_2661 MINT5_X_1280_Y_3520 MINT4_X_1280_Y_3520 1.319
R_VINT4_2662 MINT5_X_1280_Y_3840 MINT4_X_1280_Y_3840 1.319
R_VINT4_2663 MINT5_X_1280_Y_4160 MINT4_X_1280_Y_4160 1.319
R_VINT4_2664 MINT5_X_1280_Y_4480 MINT4_X_1280_Y_4480 1.319
R_VINT4_2665 MINT5_X_1280_Y_4800 MINT4_X_1280_Y_4800 1.319
R_VINT4_2666 MINT5_X_1280_Y_5120 MINT4_X_1280_Y_5120 1.319
R_VINT4_2667 MINT5_X_1280_Y_5440 MINT4_X_1280_Y_5440 1.319
R_VINT4_2668 MINT5_X_1280_Y_5760 MINT4_X_1280_Y_5760 1.319
R_VINT4_2669 MINT5_X_1280_Y_6080 MINT4_X_1280_Y_6080 1.319
R_VINT4_2670 MINT5_X_1280_Y_6400 MINT4_X_1280_Y_6400 1.319
R_VINT4_2671 MINT5_X_1280_Y_6720 MINT4_X_1280_Y_6720 1.319
R_VINT4_2672 MINT5_X_1280_Y_7040 MINT4_X_1280_Y_7040 1.319
R_VINT4_2673 MINT5_X_1280_Y_7360 MINT4_X_1280_Y_7360 1.319
R_VINT4_2674 MINT5_X_1280_Y_7680 MINT4_X_1280_Y_7680 1.319
R_VINT4_2675 MINT5_X_1280_Y_8000 MINT4_X_1280_Y_8000 1.319
R_VINT4_2676 MINT5_X_1280_Y_8320 MINT4_X_1280_Y_8320 1.319
R_VINT4_2677 MINT5_X_1280_Y_8640 MINT4_X_1280_Y_8640 1.319
R_VINT4_2678 MINT5_X_1280_Y_8960 MINT4_X_1280_Y_8960 1.319
R_VINT4_2679 MINT5_X_1280_Y_9280 MINT4_X_1280_Y_9280 1.319
R_VINT4_2680 MINT5_X_1280_Y_9600 MINT4_X_1280_Y_9600 1.319
R_VINT4_2681 MINT5_X_1280_Y_9920 MINT4_X_1280_Y_9920 1.319
R_VINT4_2682 MINT5_X_1600_Y_0 MINT4_X_1600_Y_0 1.319
R_VINT4_2683 MINT5_X_1600_Y_320 MINT4_X_1600_Y_320 1.319
R_VINT4_2684 MINT5_X_1600_Y_640 MINT4_X_1600_Y_640 1.319
R_VINT4_2685 MINT5_X_1600_Y_960 MINT4_X_1600_Y_960 1.319
R_VINT4_2686 MINT5_X_1600_Y_1280 MINT4_X_1600_Y_1280 1.319
R_VINT4_2687 MINT5_X_1600_Y_1600 MINT4_X_1600_Y_1600 1.319
R_VINT4_2688 MINT5_X_1600_Y_1920 MINT4_X_1600_Y_1920 1.319
R_VINT4_2689 MINT5_X_1600_Y_2240 MINT4_X_1600_Y_2240 1.319
R_VINT4_2690 MINT5_X_1600_Y_2560 MINT4_X_1600_Y_2560 1.319
R_VINT4_2691 MINT5_X_1600_Y_2880 MINT4_X_1600_Y_2880 1.319
R_VINT4_2692 MINT5_X_1600_Y_3200 MINT4_X_1600_Y_3200 1.319
R_VINT4_2693 MINT5_X_1600_Y_3520 MINT4_X_1600_Y_3520 1.319
R_VINT4_2694 MINT5_X_1600_Y_3840 MINT4_X_1600_Y_3840 1.319
R_VINT4_2695 MINT5_X_1600_Y_4160 MINT4_X_1600_Y_4160 1.319
R_VINT4_2696 MINT5_X_1600_Y_4480 MINT4_X_1600_Y_4480 1.319
R_VINT4_2697 MINT5_X_1600_Y_4800 MINT4_X_1600_Y_4800 1.319
R_VINT4_2698 MINT5_X_1600_Y_5120 MINT4_X_1600_Y_5120 1.319
R_VINT4_2699 MINT5_X_1600_Y_5440 MINT4_X_1600_Y_5440 1.319
R_VINT4_2700 MINT5_X_1600_Y_5760 MINT4_X_1600_Y_5760 1.319
R_VINT4_2701 MINT5_X_1600_Y_6080 MINT4_X_1600_Y_6080 1.319
R_VINT4_2702 MINT5_X_1600_Y_6400 MINT4_X_1600_Y_6400 1.319
R_VINT4_2703 MINT5_X_1600_Y_6720 MINT4_X_1600_Y_6720 1.319
R_VINT4_2704 MINT5_X_1600_Y_7040 MINT4_X_1600_Y_7040 1.319
R_VINT4_2705 MINT5_X_1600_Y_7360 MINT4_X_1600_Y_7360 1.319
R_VINT4_2706 MINT5_X_1600_Y_7680 MINT4_X_1600_Y_7680 1.319
R_VINT4_2707 MINT5_X_1600_Y_8000 MINT4_X_1600_Y_8000 1.319
R_VINT4_2708 MINT5_X_1600_Y_8320 MINT4_X_1600_Y_8320 1.319
R_VINT4_2709 MINT5_X_1600_Y_8640 MINT4_X_1600_Y_8640 1.319
R_VINT4_2710 MINT5_X_1600_Y_8960 MINT4_X_1600_Y_8960 1.319
R_VINT4_2711 MINT5_X_1600_Y_9280 MINT4_X_1600_Y_9280 1.319
R_VINT4_2712 MINT5_X_1600_Y_9600 MINT4_X_1600_Y_9600 1.319
R_VINT4_2713 MINT5_X_1600_Y_9920 MINT4_X_1600_Y_9920 1.319
R_VINT4_2714 MINT5_X_1920_Y_0 MINT4_X_1920_Y_0 1.319
R_VINT4_2715 MINT5_X_1920_Y_320 MINT4_X_1920_Y_320 1.319
R_VINT4_2716 MINT5_X_1920_Y_640 MINT4_X_1920_Y_640 1.319
R_VINT4_2717 MINT5_X_1920_Y_960 MINT4_X_1920_Y_960 1.319
R_VINT4_2718 MINT5_X_1920_Y_1280 MINT4_X_1920_Y_1280 1.319
R_VINT4_2719 MINT5_X_1920_Y_1600 MINT4_X_1920_Y_1600 1.319
R_VINT4_2720 MINT5_X_1920_Y_1920 MINT4_X_1920_Y_1920 1.319
R_VINT4_2721 MINT5_X_1920_Y_2240 MINT4_X_1920_Y_2240 1.319
R_VINT4_2722 MINT5_X_1920_Y_2560 MINT4_X_1920_Y_2560 1.319
R_VINT4_2723 MINT5_X_1920_Y_2880 MINT4_X_1920_Y_2880 1.319
R_VINT4_2724 MINT5_X_1920_Y_3200 MINT4_X_1920_Y_3200 1.319
R_VINT4_2725 MINT5_X_1920_Y_3520 MINT4_X_1920_Y_3520 1.319
R_VINT4_2726 MINT5_X_1920_Y_3840 MINT4_X_1920_Y_3840 1.319
R_VINT4_2727 MINT5_X_1920_Y_4160 MINT4_X_1920_Y_4160 1.319
R_VINT4_2728 MINT5_X_1920_Y_4480 MINT4_X_1920_Y_4480 1.319
R_VINT4_2729 MINT5_X_1920_Y_4800 MINT4_X_1920_Y_4800 1.319
R_VINT4_2730 MINT5_X_1920_Y_5120 MINT4_X_1920_Y_5120 1.319
R_VINT4_2731 MINT5_X_1920_Y_5440 MINT4_X_1920_Y_5440 1.319
R_VINT4_2732 MINT5_X_1920_Y_5760 MINT4_X_1920_Y_5760 1.319
R_VINT4_2733 MINT5_X_1920_Y_6080 MINT4_X_1920_Y_6080 1.319
R_VINT4_2734 MINT5_X_1920_Y_6400 MINT4_X_1920_Y_6400 1.319
R_VINT4_2735 MINT5_X_1920_Y_6720 MINT4_X_1920_Y_6720 1.319
R_VINT4_2736 MINT5_X_1920_Y_7040 MINT4_X_1920_Y_7040 1.319
R_VINT4_2737 MINT5_X_1920_Y_7360 MINT4_X_1920_Y_7360 1.319
R_VINT4_2738 MINT5_X_1920_Y_7680 MINT4_X_1920_Y_7680 1.319
R_VINT4_2739 MINT5_X_1920_Y_8000 MINT4_X_1920_Y_8000 1.319
R_VINT4_2740 MINT5_X_1920_Y_8320 MINT4_X_1920_Y_8320 1.319
R_VINT4_2741 MINT5_X_1920_Y_8640 MINT4_X_1920_Y_8640 1.319
R_VINT4_2742 MINT5_X_1920_Y_8960 MINT4_X_1920_Y_8960 1.319
R_VINT4_2743 MINT5_X_1920_Y_9280 MINT4_X_1920_Y_9280 1.319
R_VINT4_2744 MINT5_X_1920_Y_9600 MINT4_X_1920_Y_9600 1.319
R_VINT4_2745 MINT5_X_1920_Y_9920 MINT4_X_1920_Y_9920 1.319
R_VINT4_2746 MINT5_X_2240_Y_0 MINT4_X_2240_Y_0 1.319
R_VINT4_2747 MINT5_X_2240_Y_320 MINT4_X_2240_Y_320 1.319
R_VINT4_2748 MINT5_X_2240_Y_640 MINT4_X_2240_Y_640 1.319
R_VINT4_2749 MINT5_X_2240_Y_960 MINT4_X_2240_Y_960 1.319
R_VINT4_2750 MINT5_X_2240_Y_1280 MINT4_X_2240_Y_1280 1.319
R_VINT4_2751 MINT5_X_2240_Y_1600 MINT4_X_2240_Y_1600 1.319
R_VINT4_2752 MINT5_X_2240_Y_1920 MINT4_X_2240_Y_1920 1.319
R_VINT4_2753 MINT5_X_2240_Y_2240 MINT4_X_2240_Y_2240 1.319
R_VINT4_2754 MINT5_X_2240_Y_2560 MINT4_X_2240_Y_2560 1.319
R_VINT4_2755 MINT5_X_2240_Y_2880 MINT4_X_2240_Y_2880 1.319
R_VINT4_2756 MINT5_X_2240_Y_3200 MINT4_X_2240_Y_3200 1.319
R_VINT4_2757 MINT5_X_2240_Y_3520 MINT4_X_2240_Y_3520 1.319
R_VINT4_2758 MINT5_X_2240_Y_3840 MINT4_X_2240_Y_3840 1.319
R_VINT4_2759 MINT5_X_2240_Y_4160 MINT4_X_2240_Y_4160 1.319
R_VINT4_2760 MINT5_X_2240_Y_4480 MINT4_X_2240_Y_4480 1.319
R_VINT4_2761 MINT5_X_2240_Y_4800 MINT4_X_2240_Y_4800 1.319
R_VINT4_2762 MINT5_X_2240_Y_5120 MINT4_X_2240_Y_5120 1.319
R_VINT4_2763 MINT5_X_2240_Y_5440 MINT4_X_2240_Y_5440 1.319
R_VINT4_2764 MINT5_X_2240_Y_5760 MINT4_X_2240_Y_5760 1.319
R_VINT4_2765 MINT5_X_2240_Y_6080 MINT4_X_2240_Y_6080 1.319
R_VINT4_2766 MINT5_X_2240_Y_6400 MINT4_X_2240_Y_6400 1.319
R_VINT4_2767 MINT5_X_2240_Y_6720 MINT4_X_2240_Y_6720 1.319
R_VINT4_2768 MINT5_X_2240_Y_7040 MINT4_X_2240_Y_7040 1.319
R_VINT4_2769 MINT5_X_2240_Y_7360 MINT4_X_2240_Y_7360 1.319
R_VINT4_2770 MINT5_X_2240_Y_7680 MINT4_X_2240_Y_7680 1.319
R_VINT4_2771 MINT5_X_2240_Y_8000 MINT4_X_2240_Y_8000 1.319
R_VINT4_2772 MINT5_X_2240_Y_8320 MINT4_X_2240_Y_8320 1.319
R_VINT4_2773 MINT5_X_2240_Y_8640 MINT4_X_2240_Y_8640 1.319
R_VINT4_2774 MINT5_X_2240_Y_8960 MINT4_X_2240_Y_8960 1.319
R_VINT4_2775 MINT5_X_2240_Y_9280 MINT4_X_2240_Y_9280 1.319
R_VINT4_2776 MINT5_X_2240_Y_9600 MINT4_X_2240_Y_9600 1.319
R_VINT4_2777 MINT5_X_2240_Y_9920 MINT4_X_2240_Y_9920 1.319
R_VINT4_2778 MINT5_X_2560_Y_0 MINT4_X_2560_Y_0 1.319
R_VINT4_2779 MINT5_X_2560_Y_320 MINT4_X_2560_Y_320 1.319
R_VINT4_2780 MINT5_X_2560_Y_640 MINT4_X_2560_Y_640 1.319
R_VINT4_2781 MINT5_X_2560_Y_960 MINT4_X_2560_Y_960 1.319
R_VINT4_2782 MINT5_X_2560_Y_1280 MINT4_X_2560_Y_1280 1.319
R_VINT4_2783 MINT5_X_2560_Y_1600 MINT4_X_2560_Y_1600 1.319
R_VINT4_2784 MINT5_X_2560_Y_1920 MINT4_X_2560_Y_1920 1.319
R_VINT4_2785 MINT5_X_2560_Y_2240 MINT4_X_2560_Y_2240 1.319
R_VINT4_2786 MINT5_X_2560_Y_2560 MINT4_X_2560_Y_2560 1.319
R_VINT4_2787 MINT5_X_2560_Y_2880 MINT4_X_2560_Y_2880 1.319
R_VINT4_2788 MINT5_X_2560_Y_3200 MINT4_X_2560_Y_3200 1.319
R_VINT4_2789 MINT5_X_2560_Y_3520 MINT4_X_2560_Y_3520 1.319
R_VINT4_2790 MINT5_X_2560_Y_3840 MINT4_X_2560_Y_3840 1.319
R_VINT4_2791 MINT5_X_2560_Y_4160 MINT4_X_2560_Y_4160 1.319
R_VINT4_2792 MINT5_X_2560_Y_4480 MINT4_X_2560_Y_4480 1.319
R_VINT4_2793 MINT5_X_2560_Y_4800 MINT4_X_2560_Y_4800 1.319
R_VINT4_2794 MINT5_X_2560_Y_5120 MINT4_X_2560_Y_5120 1.319
R_VINT4_2795 MINT5_X_2560_Y_5440 MINT4_X_2560_Y_5440 1.319
R_VINT4_2796 MINT5_X_2560_Y_5760 MINT4_X_2560_Y_5760 1.319
R_VINT4_2797 MINT5_X_2560_Y_6080 MINT4_X_2560_Y_6080 1.319
R_VINT4_2798 MINT5_X_2560_Y_6400 MINT4_X_2560_Y_6400 1.319
R_VINT4_2799 MINT5_X_2560_Y_6720 MINT4_X_2560_Y_6720 1.319
R_VINT4_2800 MINT5_X_2560_Y_7040 MINT4_X_2560_Y_7040 1.319
R_VINT4_2801 MINT5_X_2560_Y_7360 MINT4_X_2560_Y_7360 1.319
R_VINT4_2802 MINT5_X_2560_Y_7680 MINT4_X_2560_Y_7680 1.319
R_VINT4_2803 MINT5_X_2560_Y_8000 MINT4_X_2560_Y_8000 1.319
R_VINT4_2804 MINT5_X_2560_Y_8320 MINT4_X_2560_Y_8320 1.319
R_VINT4_2805 MINT5_X_2560_Y_8640 MINT4_X_2560_Y_8640 1.319
R_VINT4_2806 MINT5_X_2560_Y_8960 MINT4_X_2560_Y_8960 1.319
R_VINT4_2807 MINT5_X_2560_Y_9280 MINT4_X_2560_Y_9280 1.319
R_VINT4_2808 MINT5_X_2560_Y_9600 MINT4_X_2560_Y_9600 1.319
R_VINT4_2809 MINT5_X_2560_Y_9920 MINT4_X_2560_Y_9920 1.319
R_VINT4_2810 MINT5_X_2880_Y_0 MINT4_X_2880_Y_0 1.319
R_VINT4_2811 MINT5_X_2880_Y_320 MINT4_X_2880_Y_320 1.319
R_VINT4_2812 MINT5_X_2880_Y_640 MINT4_X_2880_Y_640 1.319
R_VINT4_2813 MINT5_X_2880_Y_960 MINT4_X_2880_Y_960 1.319
R_VINT4_2814 MINT5_X_2880_Y_1280 MINT4_X_2880_Y_1280 1.319
R_VINT4_2815 MINT5_X_2880_Y_1600 MINT4_X_2880_Y_1600 1.319
R_VINT4_2816 MINT5_X_2880_Y_1920 MINT4_X_2880_Y_1920 1.319
R_VINT4_2817 MINT5_X_2880_Y_2240 MINT4_X_2880_Y_2240 1.319
R_VINT4_2818 MINT5_X_2880_Y_2560 MINT4_X_2880_Y_2560 1.319
R_VINT4_2819 MINT5_X_2880_Y_2880 MINT4_X_2880_Y_2880 1.319
R_VINT4_2820 MINT5_X_2880_Y_3200 MINT4_X_2880_Y_3200 1.319
R_VINT4_2821 MINT5_X_2880_Y_3520 MINT4_X_2880_Y_3520 1.319
R_VINT4_2822 MINT5_X_2880_Y_3840 MINT4_X_2880_Y_3840 1.319
R_VINT4_2823 MINT5_X_2880_Y_4160 MINT4_X_2880_Y_4160 1.319
R_VINT4_2824 MINT5_X_2880_Y_4480 MINT4_X_2880_Y_4480 1.319
R_VINT4_2825 MINT5_X_2880_Y_4800 MINT4_X_2880_Y_4800 1.319
R_VINT4_2826 MINT5_X_2880_Y_5120 MINT4_X_2880_Y_5120 1.319
R_VINT4_2827 MINT5_X_2880_Y_5440 MINT4_X_2880_Y_5440 1.319
R_VINT4_2828 MINT5_X_2880_Y_5760 MINT4_X_2880_Y_5760 1.319
R_VINT4_2829 MINT5_X_2880_Y_6080 MINT4_X_2880_Y_6080 1.319
R_VINT4_2830 MINT5_X_2880_Y_6400 MINT4_X_2880_Y_6400 1.319
R_VINT4_2831 MINT5_X_2880_Y_6720 MINT4_X_2880_Y_6720 1.319
R_VINT4_2832 MINT5_X_2880_Y_7040 MINT4_X_2880_Y_7040 1.319
R_VINT4_2833 MINT5_X_2880_Y_7360 MINT4_X_2880_Y_7360 1.319
R_VINT4_2834 MINT5_X_2880_Y_7680 MINT4_X_2880_Y_7680 1.319
R_VINT4_2835 MINT5_X_2880_Y_8000 MINT4_X_2880_Y_8000 1.319
R_VINT4_2836 MINT5_X_2880_Y_8320 MINT4_X_2880_Y_8320 1.319
R_VINT4_2837 MINT5_X_2880_Y_8640 MINT4_X_2880_Y_8640 1.319
R_VINT4_2838 MINT5_X_2880_Y_8960 MINT4_X_2880_Y_8960 1.319
R_VINT4_2839 MINT5_X_2880_Y_9280 MINT4_X_2880_Y_9280 1.319
R_VINT4_2840 MINT5_X_2880_Y_9600 MINT4_X_2880_Y_9600 1.319
R_VINT4_2841 MINT5_X_2880_Y_9920 MINT4_X_2880_Y_9920 1.319
R_VINT4_2842 MINT5_X_3200_Y_0 MINT4_X_3200_Y_0 1.319
R_VINT4_2843 MINT5_X_3200_Y_320 MINT4_X_3200_Y_320 1.319
R_VINT4_2844 MINT5_X_3200_Y_640 MINT4_X_3200_Y_640 1.319
R_VINT4_2845 MINT5_X_3200_Y_960 MINT4_X_3200_Y_960 1.319
R_VINT4_2846 MINT5_X_3200_Y_1280 MINT4_X_3200_Y_1280 1.319
R_VINT4_2847 MINT5_X_3200_Y_1600 MINT4_X_3200_Y_1600 1.319
R_VINT4_2848 MINT5_X_3200_Y_1920 MINT4_X_3200_Y_1920 1.319
R_VINT4_2849 MINT5_X_3200_Y_2240 MINT4_X_3200_Y_2240 1.319
R_VINT4_2850 MINT5_X_3200_Y_2560 MINT4_X_3200_Y_2560 1.319
R_VINT4_2851 MINT5_X_3200_Y_2880 MINT4_X_3200_Y_2880 1.319
R_VINT4_2852 MINT5_X_3200_Y_3200 MINT4_X_3200_Y_3200 1.319
R_VINT4_2853 MINT5_X_3200_Y_3520 MINT4_X_3200_Y_3520 1.319
R_VINT4_2854 MINT5_X_3200_Y_3840 MINT4_X_3200_Y_3840 1.319
R_VINT4_2855 MINT5_X_3200_Y_4160 MINT4_X_3200_Y_4160 1.319
R_VINT4_2856 MINT5_X_3200_Y_4480 MINT4_X_3200_Y_4480 1.319
R_VINT4_2857 MINT5_X_3200_Y_4800 MINT4_X_3200_Y_4800 1.319
R_VINT4_2858 MINT5_X_3200_Y_5120 MINT4_X_3200_Y_5120 1.319
R_VINT4_2859 MINT5_X_3200_Y_5440 MINT4_X_3200_Y_5440 1.319
R_VINT4_2860 MINT5_X_3200_Y_5760 MINT4_X_3200_Y_5760 1.319
R_VINT4_2861 MINT5_X_3200_Y_6080 MINT4_X_3200_Y_6080 1.319
R_VINT4_2862 MINT5_X_3200_Y_6400 MINT4_X_3200_Y_6400 1.319
R_VINT4_2863 MINT5_X_3200_Y_6720 MINT4_X_3200_Y_6720 1.319
R_VINT4_2864 MINT5_X_3200_Y_7040 MINT4_X_3200_Y_7040 1.319
R_VINT4_2865 MINT5_X_3200_Y_7360 MINT4_X_3200_Y_7360 1.319
R_VINT4_2866 MINT5_X_3200_Y_7680 MINT4_X_3200_Y_7680 1.319
R_VINT4_2867 MINT5_X_3200_Y_8000 MINT4_X_3200_Y_8000 1.319
R_VINT4_2868 MINT5_X_3200_Y_8320 MINT4_X_3200_Y_8320 1.319
R_VINT4_2869 MINT5_X_3200_Y_8640 MINT4_X_3200_Y_8640 1.319
R_VINT4_2870 MINT5_X_3200_Y_8960 MINT4_X_3200_Y_8960 1.319
R_VINT4_2871 MINT5_X_3200_Y_9280 MINT4_X_3200_Y_9280 1.319
R_VINT4_2872 MINT5_X_3200_Y_9600 MINT4_X_3200_Y_9600 1.319
R_VINT4_2873 MINT5_X_3200_Y_9920 MINT4_X_3200_Y_9920 1.319
R_VINT4_2874 MINT5_X_3520_Y_0 MINT4_X_3520_Y_0 1.319
R_VINT4_2875 MINT5_X_3520_Y_320 MINT4_X_3520_Y_320 1.319
R_VINT4_2876 MINT5_X_3520_Y_640 MINT4_X_3520_Y_640 1.319
R_VINT4_2877 MINT5_X_3520_Y_960 MINT4_X_3520_Y_960 1.319
R_VINT4_2878 MINT5_X_3520_Y_1280 MINT4_X_3520_Y_1280 1.319
R_VINT4_2879 MINT5_X_3520_Y_1600 MINT4_X_3520_Y_1600 1.319
R_VINT4_2880 MINT5_X_3520_Y_1920 MINT4_X_3520_Y_1920 1.319
R_VINT4_2881 MINT5_X_3520_Y_2240 MINT4_X_3520_Y_2240 1.319
R_VINT4_2882 MINT5_X_3520_Y_2560 MINT4_X_3520_Y_2560 1.319
R_VINT4_2883 MINT5_X_3520_Y_2880 MINT4_X_3520_Y_2880 1.319
R_VINT4_2884 MINT5_X_3520_Y_3200 MINT4_X_3520_Y_3200 1.319
R_VINT4_2885 MINT5_X_3520_Y_3520 MINT4_X_3520_Y_3520 1.319
R_VINT4_2886 MINT5_X_3520_Y_3840 MINT4_X_3520_Y_3840 1.319
R_VINT4_2887 MINT5_X_3520_Y_4160 MINT4_X_3520_Y_4160 1.319
R_VINT4_2888 MINT5_X_3520_Y_4480 MINT4_X_3520_Y_4480 1.319
R_VINT4_2889 MINT5_X_3520_Y_4800 MINT4_X_3520_Y_4800 1.319
R_VINT4_2890 MINT5_X_3520_Y_5120 MINT4_X_3520_Y_5120 1.319
R_VINT4_2891 MINT5_X_3520_Y_5440 MINT4_X_3520_Y_5440 1.319
R_VINT4_2892 MINT5_X_3520_Y_5760 MINT4_X_3520_Y_5760 1.319
R_VINT4_2893 MINT5_X_3520_Y_6080 MINT4_X_3520_Y_6080 1.319
R_VINT4_2894 MINT5_X_3520_Y_6400 MINT4_X_3520_Y_6400 1.319
R_VINT4_2895 MINT5_X_3520_Y_6720 MINT4_X_3520_Y_6720 1.319
R_VINT4_2896 MINT5_X_3520_Y_7040 MINT4_X_3520_Y_7040 1.319
R_VINT4_2897 MINT5_X_3520_Y_7360 MINT4_X_3520_Y_7360 1.319
R_VINT4_2898 MINT5_X_3520_Y_7680 MINT4_X_3520_Y_7680 1.319
R_VINT4_2899 MINT5_X_3520_Y_8000 MINT4_X_3520_Y_8000 1.319
R_VINT4_2900 MINT5_X_3520_Y_8320 MINT4_X_3520_Y_8320 1.319
R_VINT4_2901 MINT5_X_3520_Y_8640 MINT4_X_3520_Y_8640 1.319
R_VINT4_2902 MINT5_X_3520_Y_8960 MINT4_X_3520_Y_8960 1.319
R_VINT4_2903 MINT5_X_3520_Y_9280 MINT4_X_3520_Y_9280 1.319
R_VINT4_2904 MINT5_X_3520_Y_9600 MINT4_X_3520_Y_9600 1.319
R_VINT4_2905 MINT5_X_3520_Y_9920 MINT4_X_3520_Y_9920 1.319
R_VINT4_2906 MINT5_X_3840_Y_0 MINT4_X_3840_Y_0 1.319
R_VINT4_2907 MINT5_X_3840_Y_320 MINT4_X_3840_Y_320 1.319
R_VINT4_2908 MINT5_X_3840_Y_640 MINT4_X_3840_Y_640 1.319
R_VINT4_2909 MINT5_X_3840_Y_960 MINT4_X_3840_Y_960 1.319
R_VINT4_2910 MINT5_X_3840_Y_1280 MINT4_X_3840_Y_1280 1.319
R_VINT4_2911 MINT5_X_3840_Y_1600 MINT4_X_3840_Y_1600 1.319
R_VINT4_2912 MINT5_X_3840_Y_1920 MINT4_X_3840_Y_1920 1.319
R_VINT4_2913 MINT5_X_3840_Y_2240 MINT4_X_3840_Y_2240 1.319
R_VINT4_2914 MINT5_X_3840_Y_2560 MINT4_X_3840_Y_2560 1.319
R_VINT4_2915 MINT5_X_3840_Y_2880 MINT4_X_3840_Y_2880 1.319
R_VINT4_2916 MINT5_X_3840_Y_3200 MINT4_X_3840_Y_3200 1.319
R_VINT4_2917 MINT5_X_3840_Y_3520 MINT4_X_3840_Y_3520 1.319
R_VINT4_2918 MINT5_X_3840_Y_3840 MINT4_X_3840_Y_3840 1.319
R_VINT4_2919 MINT5_X_3840_Y_4160 MINT4_X_3840_Y_4160 1.319
R_VINT4_2920 MINT5_X_3840_Y_4480 MINT4_X_3840_Y_4480 1.319
R_VINT4_2921 MINT5_X_3840_Y_4800 MINT4_X_3840_Y_4800 1.319
R_VINT4_2922 MINT5_X_3840_Y_5120 MINT4_X_3840_Y_5120 1.319
R_VINT4_2923 MINT5_X_3840_Y_5440 MINT4_X_3840_Y_5440 1.319
R_VINT4_2924 MINT5_X_3840_Y_5760 MINT4_X_3840_Y_5760 1.319
R_VINT4_2925 MINT5_X_3840_Y_6080 MINT4_X_3840_Y_6080 1.319
R_VINT4_2926 MINT5_X_3840_Y_6400 MINT4_X_3840_Y_6400 1.319
R_VINT4_2927 MINT5_X_3840_Y_6720 MINT4_X_3840_Y_6720 1.319
R_VINT4_2928 MINT5_X_3840_Y_7040 MINT4_X_3840_Y_7040 1.319
R_VINT4_2929 MINT5_X_3840_Y_7360 MINT4_X_3840_Y_7360 1.319
R_VINT4_2930 MINT5_X_3840_Y_7680 MINT4_X_3840_Y_7680 1.319
R_VINT4_2931 MINT5_X_3840_Y_8000 MINT4_X_3840_Y_8000 1.319
R_VINT4_2932 MINT5_X_3840_Y_8320 MINT4_X_3840_Y_8320 1.319
R_VINT4_2933 MINT5_X_3840_Y_8640 MINT4_X_3840_Y_8640 1.319
R_VINT4_2934 MINT5_X_3840_Y_8960 MINT4_X_3840_Y_8960 1.319
R_VINT4_2935 MINT5_X_3840_Y_9280 MINT4_X_3840_Y_9280 1.319
R_VINT4_2936 MINT5_X_3840_Y_9600 MINT4_X_3840_Y_9600 1.319
R_VINT4_2937 MINT5_X_3840_Y_9920 MINT4_X_3840_Y_9920 1.319
R_VINT4_2938 MINT5_X_4160_Y_0 MINT4_X_4160_Y_0 1.319
R_VINT4_2939 MINT5_X_4160_Y_320 MINT4_X_4160_Y_320 1.319
R_VINT4_2940 MINT5_X_4160_Y_640 MINT4_X_4160_Y_640 1.319
R_VINT4_2941 MINT5_X_4160_Y_960 MINT4_X_4160_Y_960 1.319
R_VINT4_2942 MINT5_X_4160_Y_1280 MINT4_X_4160_Y_1280 1.319
R_VINT4_2943 MINT5_X_4160_Y_1600 MINT4_X_4160_Y_1600 1.319
R_VINT4_2944 MINT5_X_4160_Y_1920 MINT4_X_4160_Y_1920 1.319
R_VINT4_2945 MINT5_X_4160_Y_2240 MINT4_X_4160_Y_2240 1.319
R_VINT4_2946 MINT5_X_4160_Y_2560 MINT4_X_4160_Y_2560 1.319
R_VINT4_2947 MINT5_X_4160_Y_2880 MINT4_X_4160_Y_2880 1.319
R_VINT4_2948 MINT5_X_4160_Y_3200 MINT4_X_4160_Y_3200 1.319
R_VINT4_2949 MINT5_X_4160_Y_3520 MINT4_X_4160_Y_3520 1.319
R_VINT4_2950 MINT5_X_4160_Y_3840 MINT4_X_4160_Y_3840 1.319
R_VINT4_2951 MINT5_X_4160_Y_4160 MINT4_X_4160_Y_4160 1.319
R_VINT4_2952 MINT5_X_4160_Y_4480 MINT4_X_4160_Y_4480 1.319
R_VINT4_2953 MINT5_X_4160_Y_4800 MINT4_X_4160_Y_4800 1.319
R_VINT4_2954 MINT5_X_4160_Y_5120 MINT4_X_4160_Y_5120 1.319
R_VINT4_2955 MINT5_X_4160_Y_5440 MINT4_X_4160_Y_5440 1.319
R_VINT4_2956 MINT5_X_4160_Y_5760 MINT4_X_4160_Y_5760 1.319
R_VINT4_2957 MINT5_X_4160_Y_6080 MINT4_X_4160_Y_6080 1.319
R_VINT4_2958 MINT5_X_4160_Y_6400 MINT4_X_4160_Y_6400 1.319
R_VINT4_2959 MINT5_X_4160_Y_6720 MINT4_X_4160_Y_6720 1.319
R_VINT4_2960 MINT5_X_4160_Y_7040 MINT4_X_4160_Y_7040 1.319
R_VINT4_2961 MINT5_X_4160_Y_7360 MINT4_X_4160_Y_7360 1.319
R_VINT4_2962 MINT5_X_4160_Y_7680 MINT4_X_4160_Y_7680 1.319
R_VINT4_2963 MINT5_X_4160_Y_8000 MINT4_X_4160_Y_8000 1.319
R_VINT4_2964 MINT5_X_4160_Y_8320 MINT4_X_4160_Y_8320 1.319
R_VINT4_2965 MINT5_X_4160_Y_8640 MINT4_X_4160_Y_8640 1.319
R_VINT4_2966 MINT5_X_4160_Y_8960 MINT4_X_4160_Y_8960 1.319
R_VINT4_2967 MINT5_X_4160_Y_9280 MINT4_X_4160_Y_9280 1.319
R_VINT4_2968 MINT5_X_4160_Y_9600 MINT4_X_4160_Y_9600 1.319
R_VINT4_2969 MINT5_X_4160_Y_9920 MINT4_X_4160_Y_9920 1.319
R_VINT4_2970 MINT5_X_4480_Y_0 MINT4_X_4480_Y_0 1.319
R_VINT4_2971 MINT5_X_4480_Y_320 MINT4_X_4480_Y_320 1.319
R_VINT4_2972 MINT5_X_4480_Y_640 MINT4_X_4480_Y_640 1.319
R_VINT4_2973 MINT5_X_4480_Y_960 MINT4_X_4480_Y_960 1.319
R_VINT4_2974 MINT5_X_4480_Y_1280 MINT4_X_4480_Y_1280 1.319
R_VINT4_2975 MINT5_X_4480_Y_1600 MINT4_X_4480_Y_1600 1.319
R_VINT4_2976 MINT5_X_4480_Y_1920 MINT4_X_4480_Y_1920 1.319
R_VINT4_2977 MINT5_X_4480_Y_2240 MINT4_X_4480_Y_2240 1.319
R_VINT4_2978 MINT5_X_4480_Y_2560 MINT4_X_4480_Y_2560 1.319
R_VINT4_2979 MINT5_X_4480_Y_2880 MINT4_X_4480_Y_2880 1.319
R_VINT4_2980 MINT5_X_4480_Y_3200 MINT4_X_4480_Y_3200 1.319
R_VINT4_2981 MINT5_X_4480_Y_3520 MINT4_X_4480_Y_3520 1.319
R_VINT4_2982 MINT5_X_4480_Y_3840 MINT4_X_4480_Y_3840 1.319
R_VINT4_2983 MINT5_X_4480_Y_4160 MINT4_X_4480_Y_4160 1.319
R_VINT4_2984 MINT5_X_4480_Y_4480 MINT4_X_4480_Y_4480 1.319
R_VINT4_2985 MINT5_X_4480_Y_4800 MINT4_X_4480_Y_4800 1.319
R_VINT4_2986 MINT5_X_4480_Y_5120 MINT4_X_4480_Y_5120 1.319
R_VINT4_2987 MINT5_X_4480_Y_5440 MINT4_X_4480_Y_5440 1.319
R_VINT4_2988 MINT5_X_4480_Y_5760 MINT4_X_4480_Y_5760 1.319
R_VINT4_2989 MINT5_X_4480_Y_6080 MINT4_X_4480_Y_6080 1.319
R_VINT4_2990 MINT5_X_4480_Y_6400 MINT4_X_4480_Y_6400 1.319
R_VINT4_2991 MINT5_X_4480_Y_6720 MINT4_X_4480_Y_6720 1.319
R_VINT4_2992 MINT5_X_4480_Y_7040 MINT4_X_4480_Y_7040 1.319
R_VINT4_2993 MINT5_X_4480_Y_7360 MINT4_X_4480_Y_7360 1.319
R_VINT4_2994 MINT5_X_4480_Y_7680 MINT4_X_4480_Y_7680 1.319
R_VINT4_2995 MINT5_X_4480_Y_8000 MINT4_X_4480_Y_8000 1.319
R_VINT4_2996 MINT5_X_4480_Y_8320 MINT4_X_4480_Y_8320 1.319
R_VINT4_2997 MINT5_X_4480_Y_8640 MINT4_X_4480_Y_8640 1.319
R_VINT4_2998 MINT5_X_4480_Y_8960 MINT4_X_4480_Y_8960 1.319
R_VINT4_2999 MINT5_X_4480_Y_9280 MINT4_X_4480_Y_9280 1.319
R_VINT4_3000 MINT5_X_4480_Y_9600 MINT4_X_4480_Y_9600 1.319
R_VINT4_3001 MINT5_X_4480_Y_9920 MINT4_X_4480_Y_9920 1.319
R_VINT4_3002 MINT5_X_4800_Y_0 MINT4_X_4800_Y_0 1.319
R_VINT4_3003 MINT5_X_4800_Y_320 MINT4_X_4800_Y_320 1.319
R_VINT4_3004 MINT5_X_4800_Y_640 MINT4_X_4800_Y_640 1.319
R_VINT4_3005 MINT5_X_4800_Y_960 MINT4_X_4800_Y_960 1.319
R_VINT4_3006 MINT5_X_4800_Y_1280 MINT4_X_4800_Y_1280 1.319
R_VINT4_3007 MINT5_X_4800_Y_1600 MINT4_X_4800_Y_1600 1.319
R_VINT4_3008 MINT5_X_4800_Y_1920 MINT4_X_4800_Y_1920 1.319
R_VINT4_3009 MINT5_X_4800_Y_2240 MINT4_X_4800_Y_2240 1.319
R_VINT4_3010 MINT5_X_4800_Y_2560 MINT4_X_4800_Y_2560 1.319
R_VINT4_3011 MINT5_X_4800_Y_2880 MINT4_X_4800_Y_2880 1.319
R_VINT4_3012 MINT5_X_4800_Y_3200 MINT4_X_4800_Y_3200 1.319
R_VINT4_3013 MINT5_X_4800_Y_3520 MINT4_X_4800_Y_3520 1.319
R_VINT4_3014 MINT5_X_4800_Y_3840 MINT4_X_4800_Y_3840 1.319
R_VINT4_3015 MINT5_X_4800_Y_4160 MINT4_X_4800_Y_4160 1.319
R_VINT4_3016 MINT5_X_4800_Y_4480 MINT4_X_4800_Y_4480 1.319
R_VINT4_3017 MINT5_X_4800_Y_4800 MINT4_X_4800_Y_4800 1.319
R_VINT4_3018 MINT5_X_4800_Y_5120 MINT4_X_4800_Y_5120 1.319
R_VINT4_3019 MINT5_X_4800_Y_5440 MINT4_X_4800_Y_5440 1.319
R_VINT4_3020 MINT5_X_4800_Y_5760 MINT4_X_4800_Y_5760 1.319
R_VINT4_3021 MINT5_X_4800_Y_6080 MINT4_X_4800_Y_6080 1.319
R_VINT4_3022 MINT5_X_4800_Y_6400 MINT4_X_4800_Y_6400 1.319
R_VINT4_3023 MINT5_X_4800_Y_6720 MINT4_X_4800_Y_6720 1.319
R_VINT4_3024 MINT5_X_4800_Y_7040 MINT4_X_4800_Y_7040 1.319
R_VINT4_3025 MINT5_X_4800_Y_7360 MINT4_X_4800_Y_7360 1.319
R_VINT4_3026 MINT5_X_4800_Y_7680 MINT4_X_4800_Y_7680 1.319
R_VINT4_3027 MINT5_X_4800_Y_8000 MINT4_X_4800_Y_8000 1.319
R_VINT4_3028 MINT5_X_4800_Y_8320 MINT4_X_4800_Y_8320 1.319
R_VINT4_3029 MINT5_X_4800_Y_8640 MINT4_X_4800_Y_8640 1.319
R_VINT4_3030 MINT5_X_4800_Y_8960 MINT4_X_4800_Y_8960 1.319
R_VINT4_3031 MINT5_X_4800_Y_9280 MINT4_X_4800_Y_9280 1.319
R_VINT4_3032 MINT5_X_4800_Y_9600 MINT4_X_4800_Y_9600 1.319
R_VINT4_3033 MINT5_X_4800_Y_9920 MINT4_X_4800_Y_9920 1.319
R_VINT4_3034 MINT5_X_5120_Y_0 MINT4_X_5120_Y_0 1.319
R_VINT4_3035 MINT5_X_5120_Y_320 MINT4_X_5120_Y_320 1.319
R_VINT4_3036 MINT5_X_5120_Y_640 MINT4_X_5120_Y_640 1.319
R_VINT4_3037 MINT5_X_5120_Y_960 MINT4_X_5120_Y_960 1.319
R_VINT4_3038 MINT5_X_5120_Y_1280 MINT4_X_5120_Y_1280 1.319
R_VINT4_3039 MINT5_X_5120_Y_1600 MINT4_X_5120_Y_1600 1.319
R_VINT4_3040 MINT5_X_5120_Y_1920 MINT4_X_5120_Y_1920 1.319
R_VINT4_3041 MINT5_X_5120_Y_2240 MINT4_X_5120_Y_2240 1.319
R_VINT4_3042 MINT5_X_5120_Y_2560 MINT4_X_5120_Y_2560 1.319
R_VINT4_3043 MINT5_X_5120_Y_2880 MINT4_X_5120_Y_2880 1.319
R_VINT4_3044 MINT5_X_5120_Y_3200 MINT4_X_5120_Y_3200 1.319
R_VINT4_3045 MINT5_X_5120_Y_3520 MINT4_X_5120_Y_3520 1.319
R_VINT4_3046 MINT5_X_5120_Y_3840 MINT4_X_5120_Y_3840 1.319
R_VINT4_3047 MINT5_X_5120_Y_4160 MINT4_X_5120_Y_4160 1.319
R_VINT4_3048 MINT5_X_5120_Y_4480 MINT4_X_5120_Y_4480 1.319
R_VINT4_3049 MINT5_X_5120_Y_4800 MINT4_X_5120_Y_4800 1.319
R_VINT4_3050 MINT5_X_5120_Y_5120 MINT4_X_5120_Y_5120 1.319
R_VINT4_3051 MINT5_X_5120_Y_5440 MINT4_X_5120_Y_5440 1.319
R_VINT4_3052 MINT5_X_5120_Y_5760 MINT4_X_5120_Y_5760 1.319
R_VINT4_3053 MINT5_X_5120_Y_6080 MINT4_X_5120_Y_6080 1.319
R_VINT4_3054 MINT5_X_5120_Y_6400 MINT4_X_5120_Y_6400 1.319
R_VINT4_3055 MINT5_X_5120_Y_6720 MINT4_X_5120_Y_6720 1.319
R_VINT4_3056 MINT5_X_5120_Y_7040 MINT4_X_5120_Y_7040 1.319
R_VINT4_3057 MINT5_X_5120_Y_7360 MINT4_X_5120_Y_7360 1.319
R_VINT4_3058 MINT5_X_5120_Y_7680 MINT4_X_5120_Y_7680 1.319
R_VINT4_3059 MINT5_X_5120_Y_8000 MINT4_X_5120_Y_8000 1.319
R_VINT4_3060 MINT5_X_5120_Y_8320 MINT4_X_5120_Y_8320 1.319
R_VINT4_3061 MINT5_X_5120_Y_8640 MINT4_X_5120_Y_8640 1.319
R_VINT4_3062 MINT5_X_5120_Y_8960 MINT4_X_5120_Y_8960 1.319
R_VINT4_3063 MINT5_X_5120_Y_9280 MINT4_X_5120_Y_9280 1.319
R_VINT4_3064 MINT5_X_5120_Y_9600 MINT4_X_5120_Y_9600 1.319
R_VINT4_3065 MINT5_X_5120_Y_9920 MINT4_X_5120_Y_9920 1.319
R_VINT4_3066 MINT5_X_5440_Y_0 MINT4_X_5440_Y_0 1.319
R_VINT4_3067 MINT5_X_5440_Y_320 MINT4_X_5440_Y_320 1.319
R_VINT4_3068 MINT5_X_5440_Y_640 MINT4_X_5440_Y_640 1.319
R_VINT4_3069 MINT5_X_5440_Y_960 MINT4_X_5440_Y_960 1.319
R_VINT4_3070 MINT5_X_5440_Y_1280 MINT4_X_5440_Y_1280 1.319
R_VINT4_3071 MINT5_X_5440_Y_1600 MINT4_X_5440_Y_1600 1.319
R_VINT4_3072 MINT5_X_5440_Y_1920 MINT4_X_5440_Y_1920 1.319
R_VINT4_3073 MINT5_X_5440_Y_2240 MINT4_X_5440_Y_2240 1.319
R_VINT4_3074 MINT5_X_5440_Y_2560 MINT4_X_5440_Y_2560 1.319
R_VINT4_3075 MINT5_X_5440_Y_2880 MINT4_X_5440_Y_2880 1.319
R_VINT4_3076 MINT5_X_5440_Y_3200 MINT4_X_5440_Y_3200 1.319
R_VINT4_3077 MINT5_X_5440_Y_3520 MINT4_X_5440_Y_3520 1.319
R_VINT4_3078 MINT5_X_5440_Y_3840 MINT4_X_5440_Y_3840 1.319
R_VINT4_3079 MINT5_X_5440_Y_4160 MINT4_X_5440_Y_4160 1.319
R_VINT4_3080 MINT5_X_5440_Y_4480 MINT4_X_5440_Y_4480 1.319
R_VINT4_3081 MINT5_X_5440_Y_4800 MINT4_X_5440_Y_4800 1.319
R_VINT4_3082 MINT5_X_5440_Y_5120 MINT4_X_5440_Y_5120 1.319
R_VINT4_3083 MINT5_X_5440_Y_5440 MINT4_X_5440_Y_5440 1.319
R_VINT4_3084 MINT5_X_5440_Y_5760 MINT4_X_5440_Y_5760 1.319
R_VINT4_3085 MINT5_X_5440_Y_6080 MINT4_X_5440_Y_6080 1.319
R_VINT4_3086 MINT5_X_5440_Y_6400 MINT4_X_5440_Y_6400 1.319
R_VINT4_3087 MINT5_X_5440_Y_6720 MINT4_X_5440_Y_6720 1.319
R_VINT4_3088 MINT5_X_5440_Y_7040 MINT4_X_5440_Y_7040 1.319
R_VINT4_3089 MINT5_X_5440_Y_7360 MINT4_X_5440_Y_7360 1.319
R_VINT4_3090 MINT5_X_5440_Y_7680 MINT4_X_5440_Y_7680 1.319
R_VINT4_3091 MINT5_X_5440_Y_8000 MINT4_X_5440_Y_8000 1.319
R_VINT4_3092 MINT5_X_5440_Y_8320 MINT4_X_5440_Y_8320 1.319
R_VINT4_3093 MINT5_X_5440_Y_8640 MINT4_X_5440_Y_8640 1.319
R_VINT4_3094 MINT5_X_5440_Y_8960 MINT4_X_5440_Y_8960 1.319
R_VINT4_3095 MINT5_X_5440_Y_9280 MINT4_X_5440_Y_9280 1.319
R_VINT4_3096 MINT5_X_5440_Y_9600 MINT4_X_5440_Y_9600 1.319
R_VINT4_3097 MINT5_X_5440_Y_9920 MINT4_X_5440_Y_9920 1.319
R_VINT4_3098 MINT5_X_5760_Y_0 MINT4_X_5760_Y_0 1.319
R_VINT4_3099 MINT5_X_5760_Y_320 MINT4_X_5760_Y_320 1.319
R_VINT4_3100 MINT5_X_5760_Y_640 MINT4_X_5760_Y_640 1.319
R_VINT4_3101 MINT5_X_5760_Y_960 MINT4_X_5760_Y_960 1.319
R_VINT4_3102 MINT5_X_5760_Y_1280 MINT4_X_5760_Y_1280 1.319
R_VINT4_3103 MINT5_X_5760_Y_1600 MINT4_X_5760_Y_1600 1.319
R_VINT4_3104 MINT5_X_5760_Y_1920 MINT4_X_5760_Y_1920 1.319
R_VINT4_3105 MINT5_X_5760_Y_2240 MINT4_X_5760_Y_2240 1.319
R_VINT4_3106 MINT5_X_5760_Y_2560 MINT4_X_5760_Y_2560 1.319
R_VINT4_3107 MINT5_X_5760_Y_2880 MINT4_X_5760_Y_2880 1.319
R_VINT4_3108 MINT5_X_5760_Y_3200 MINT4_X_5760_Y_3200 1.319
R_VINT4_3109 MINT5_X_5760_Y_3520 MINT4_X_5760_Y_3520 1.319
R_VINT4_3110 MINT5_X_5760_Y_3840 MINT4_X_5760_Y_3840 1.319
R_VINT4_3111 MINT5_X_5760_Y_4160 MINT4_X_5760_Y_4160 1.319
R_VINT4_3112 MINT5_X_5760_Y_4480 MINT4_X_5760_Y_4480 1.319
R_VINT4_3113 MINT5_X_5760_Y_4800 MINT4_X_5760_Y_4800 1.319
R_VINT4_3114 MINT5_X_5760_Y_5120 MINT4_X_5760_Y_5120 1.319
R_VINT4_3115 MINT5_X_5760_Y_5440 MINT4_X_5760_Y_5440 1.319
R_VINT4_3116 MINT5_X_5760_Y_5760 MINT4_X_5760_Y_5760 1.319
R_VINT4_3117 MINT5_X_5760_Y_6080 MINT4_X_5760_Y_6080 1.319
R_VINT4_3118 MINT5_X_5760_Y_6400 MINT4_X_5760_Y_6400 1.319
R_VINT4_3119 MINT5_X_5760_Y_6720 MINT4_X_5760_Y_6720 1.319
R_VINT4_3120 MINT5_X_5760_Y_7040 MINT4_X_5760_Y_7040 1.319
R_VINT4_3121 MINT5_X_5760_Y_7360 MINT4_X_5760_Y_7360 1.319
R_VINT4_3122 MINT5_X_5760_Y_7680 MINT4_X_5760_Y_7680 1.319
R_VINT4_3123 MINT5_X_5760_Y_8000 MINT4_X_5760_Y_8000 1.319
R_VINT4_3124 MINT5_X_5760_Y_8320 MINT4_X_5760_Y_8320 1.319
R_VINT4_3125 MINT5_X_5760_Y_8640 MINT4_X_5760_Y_8640 1.319
R_VINT4_3126 MINT5_X_5760_Y_8960 MINT4_X_5760_Y_8960 1.319
R_VINT4_3127 MINT5_X_5760_Y_9280 MINT4_X_5760_Y_9280 1.319
R_VINT4_3128 MINT5_X_5760_Y_9600 MINT4_X_5760_Y_9600 1.319
R_VINT4_3129 MINT5_X_5760_Y_9920 MINT4_X_5760_Y_9920 1.319
R_VINT4_3130 MINT5_X_6080_Y_0 MINT4_X_6080_Y_0 1.319
R_VINT4_3131 MINT5_X_6080_Y_320 MINT4_X_6080_Y_320 1.319
R_VINT4_3132 MINT5_X_6080_Y_640 MINT4_X_6080_Y_640 1.319
R_VINT4_3133 MINT5_X_6080_Y_960 MINT4_X_6080_Y_960 1.319
R_VINT4_3134 MINT5_X_6080_Y_1280 MINT4_X_6080_Y_1280 1.319
R_VINT4_3135 MINT5_X_6080_Y_1600 MINT4_X_6080_Y_1600 1.319
R_VINT4_3136 MINT5_X_6080_Y_1920 MINT4_X_6080_Y_1920 1.319
R_VINT4_3137 MINT5_X_6080_Y_2240 MINT4_X_6080_Y_2240 1.319
R_VINT4_3138 MINT5_X_6080_Y_2560 MINT4_X_6080_Y_2560 1.319
R_VINT4_3139 MINT5_X_6080_Y_2880 MINT4_X_6080_Y_2880 1.319
R_VINT4_3140 MINT5_X_6080_Y_3200 MINT4_X_6080_Y_3200 1.319
R_VINT4_3141 MINT5_X_6080_Y_3520 MINT4_X_6080_Y_3520 1.319
R_VINT4_3142 MINT5_X_6080_Y_3840 MINT4_X_6080_Y_3840 1.319
R_VINT4_3143 MINT5_X_6080_Y_4160 MINT4_X_6080_Y_4160 1.319
R_VINT4_3144 MINT5_X_6080_Y_4480 MINT4_X_6080_Y_4480 1.319
R_VINT4_3145 MINT5_X_6080_Y_4800 MINT4_X_6080_Y_4800 1.319
R_VINT4_3146 MINT5_X_6080_Y_5120 MINT4_X_6080_Y_5120 1.319
R_VINT4_3147 MINT5_X_6080_Y_5440 MINT4_X_6080_Y_5440 1.319
R_VINT4_3148 MINT5_X_6080_Y_5760 MINT4_X_6080_Y_5760 1.319
R_VINT4_3149 MINT5_X_6080_Y_6080 MINT4_X_6080_Y_6080 1.319
R_VINT4_3150 MINT5_X_6080_Y_6400 MINT4_X_6080_Y_6400 1.319
R_VINT4_3151 MINT5_X_6080_Y_6720 MINT4_X_6080_Y_6720 1.319
R_VINT4_3152 MINT5_X_6080_Y_7040 MINT4_X_6080_Y_7040 1.319
R_VINT4_3153 MINT5_X_6080_Y_7360 MINT4_X_6080_Y_7360 1.319
R_VINT4_3154 MINT5_X_6080_Y_7680 MINT4_X_6080_Y_7680 1.319
R_VINT4_3155 MINT5_X_6080_Y_8000 MINT4_X_6080_Y_8000 1.319
R_VINT4_3156 MINT5_X_6080_Y_8320 MINT4_X_6080_Y_8320 1.319
R_VINT4_3157 MINT5_X_6080_Y_8640 MINT4_X_6080_Y_8640 1.319
R_VINT4_3158 MINT5_X_6080_Y_8960 MINT4_X_6080_Y_8960 1.319
R_VINT4_3159 MINT5_X_6080_Y_9280 MINT4_X_6080_Y_9280 1.319
R_VINT4_3160 MINT5_X_6080_Y_9600 MINT4_X_6080_Y_9600 1.319
R_VINT4_3161 MINT5_X_6080_Y_9920 MINT4_X_6080_Y_9920 1.319
R_VINT4_3162 MINT5_X_6400_Y_0 MINT4_X_6400_Y_0 1.319
R_VINT4_3163 MINT5_X_6400_Y_320 MINT4_X_6400_Y_320 1.319
R_VINT4_3164 MINT5_X_6400_Y_640 MINT4_X_6400_Y_640 1.319
R_VINT4_3165 MINT5_X_6400_Y_960 MINT4_X_6400_Y_960 1.319
R_VINT4_3166 MINT5_X_6400_Y_1280 MINT4_X_6400_Y_1280 1.319
R_VINT4_3167 MINT5_X_6400_Y_1600 MINT4_X_6400_Y_1600 1.319
R_VINT4_3168 MINT5_X_6400_Y_1920 MINT4_X_6400_Y_1920 1.319
R_VINT4_3169 MINT5_X_6400_Y_2240 MINT4_X_6400_Y_2240 1.319
R_VINT4_3170 MINT5_X_6400_Y_2560 MINT4_X_6400_Y_2560 1.319
R_VINT4_3171 MINT5_X_6400_Y_2880 MINT4_X_6400_Y_2880 1.319
R_VINT4_3172 MINT5_X_6400_Y_3200 MINT4_X_6400_Y_3200 1.319
R_VINT4_3173 MINT5_X_6400_Y_3520 MINT4_X_6400_Y_3520 1.319
R_VINT4_3174 MINT5_X_6400_Y_3840 MINT4_X_6400_Y_3840 1.319
R_VINT4_3175 MINT5_X_6400_Y_4160 MINT4_X_6400_Y_4160 1.319
R_VINT4_3176 MINT5_X_6400_Y_4480 MINT4_X_6400_Y_4480 1.319
R_VINT4_3177 MINT5_X_6400_Y_4800 MINT4_X_6400_Y_4800 1.319
R_VINT4_3178 MINT5_X_6400_Y_5120 MINT4_X_6400_Y_5120 1.319
R_VINT4_3179 MINT5_X_6400_Y_5440 MINT4_X_6400_Y_5440 1.319
R_VINT4_3180 MINT5_X_6400_Y_5760 MINT4_X_6400_Y_5760 1.319
R_VINT4_3181 MINT5_X_6400_Y_6080 MINT4_X_6400_Y_6080 1.319
R_VINT4_3182 MINT5_X_6400_Y_6400 MINT4_X_6400_Y_6400 1.319
R_VINT4_3183 MINT5_X_6400_Y_6720 MINT4_X_6400_Y_6720 1.319
R_VINT4_3184 MINT5_X_6400_Y_7040 MINT4_X_6400_Y_7040 1.319
R_VINT4_3185 MINT5_X_6400_Y_7360 MINT4_X_6400_Y_7360 1.319
R_VINT4_3186 MINT5_X_6400_Y_7680 MINT4_X_6400_Y_7680 1.319
R_VINT4_3187 MINT5_X_6400_Y_8000 MINT4_X_6400_Y_8000 1.319
R_VINT4_3188 MINT5_X_6400_Y_8320 MINT4_X_6400_Y_8320 1.319
R_VINT4_3189 MINT5_X_6400_Y_8640 MINT4_X_6400_Y_8640 1.319
R_VINT4_3190 MINT5_X_6400_Y_8960 MINT4_X_6400_Y_8960 1.319
R_VINT4_3191 MINT5_X_6400_Y_9280 MINT4_X_6400_Y_9280 1.319
R_VINT4_3192 MINT5_X_6400_Y_9600 MINT4_X_6400_Y_9600 1.319
R_VINT4_3193 MINT5_X_6400_Y_9920 MINT4_X_6400_Y_9920 1.319
R_VINT4_3194 MINT5_X_6720_Y_0 MINT4_X_6720_Y_0 1.319
R_VINT4_3195 MINT5_X_6720_Y_320 MINT4_X_6720_Y_320 1.319
R_VINT4_3196 MINT5_X_6720_Y_640 MINT4_X_6720_Y_640 1.319
R_VINT4_3197 MINT5_X_6720_Y_960 MINT4_X_6720_Y_960 1.319
R_VINT4_3198 MINT5_X_6720_Y_1280 MINT4_X_6720_Y_1280 1.319
R_VINT4_3199 MINT5_X_6720_Y_1600 MINT4_X_6720_Y_1600 1.319
R_VINT4_3200 MINT5_X_6720_Y_1920 MINT4_X_6720_Y_1920 1.319
R_VINT4_3201 MINT5_X_6720_Y_2240 MINT4_X_6720_Y_2240 1.319
R_VINT4_3202 MINT5_X_6720_Y_2560 MINT4_X_6720_Y_2560 1.319
R_VINT4_3203 MINT5_X_6720_Y_2880 MINT4_X_6720_Y_2880 1.319
R_VINT4_3204 MINT5_X_6720_Y_3200 MINT4_X_6720_Y_3200 1.319
R_VINT4_3205 MINT5_X_6720_Y_3520 MINT4_X_6720_Y_3520 1.319
R_VINT4_3206 MINT5_X_6720_Y_3840 MINT4_X_6720_Y_3840 1.319
R_VINT4_3207 MINT5_X_6720_Y_4160 MINT4_X_6720_Y_4160 1.319
R_VINT4_3208 MINT5_X_6720_Y_4480 MINT4_X_6720_Y_4480 1.319
R_VINT4_3209 MINT5_X_6720_Y_4800 MINT4_X_6720_Y_4800 1.319
R_VINT4_3210 MINT5_X_6720_Y_5120 MINT4_X_6720_Y_5120 1.319
R_VINT4_3211 MINT5_X_6720_Y_5440 MINT4_X_6720_Y_5440 1.319
R_VINT4_3212 MINT5_X_6720_Y_5760 MINT4_X_6720_Y_5760 1.319
R_VINT4_3213 MINT5_X_6720_Y_6080 MINT4_X_6720_Y_6080 1.319
R_VINT4_3214 MINT5_X_6720_Y_6400 MINT4_X_6720_Y_6400 1.319
R_VINT4_3215 MINT5_X_6720_Y_6720 MINT4_X_6720_Y_6720 1.319
R_VINT4_3216 MINT5_X_6720_Y_7040 MINT4_X_6720_Y_7040 1.319
R_VINT4_3217 MINT5_X_6720_Y_7360 MINT4_X_6720_Y_7360 1.319
R_VINT4_3218 MINT5_X_6720_Y_7680 MINT4_X_6720_Y_7680 1.319
R_VINT4_3219 MINT5_X_6720_Y_8000 MINT4_X_6720_Y_8000 1.319
R_VINT4_3220 MINT5_X_6720_Y_8320 MINT4_X_6720_Y_8320 1.319
R_VINT4_3221 MINT5_X_6720_Y_8640 MINT4_X_6720_Y_8640 1.319
R_VINT4_3222 MINT5_X_6720_Y_8960 MINT4_X_6720_Y_8960 1.319
R_VINT4_3223 MINT5_X_6720_Y_9280 MINT4_X_6720_Y_9280 1.319
R_VINT4_3224 MINT5_X_6720_Y_9600 MINT4_X_6720_Y_9600 1.319
R_VINT4_3225 MINT5_X_6720_Y_9920 MINT4_X_6720_Y_9920 1.319
R_VINT4_3226 MINT5_X_7040_Y_0 MINT4_X_7040_Y_0 1.319
R_VINT4_3227 MINT5_X_7040_Y_320 MINT4_X_7040_Y_320 1.319
R_VINT4_3228 MINT5_X_7040_Y_640 MINT4_X_7040_Y_640 1.319
R_VINT4_3229 MINT5_X_7040_Y_960 MINT4_X_7040_Y_960 1.319
R_VINT4_3230 MINT5_X_7040_Y_1280 MINT4_X_7040_Y_1280 1.319
R_VINT4_3231 MINT5_X_7040_Y_1600 MINT4_X_7040_Y_1600 1.319
R_VINT4_3232 MINT5_X_7040_Y_1920 MINT4_X_7040_Y_1920 1.319
R_VINT4_3233 MINT5_X_7040_Y_2240 MINT4_X_7040_Y_2240 1.319
R_VINT4_3234 MINT5_X_7040_Y_2560 MINT4_X_7040_Y_2560 1.319
R_VINT4_3235 MINT5_X_7040_Y_2880 MINT4_X_7040_Y_2880 1.319
R_VINT4_3236 MINT5_X_7040_Y_3200 MINT4_X_7040_Y_3200 1.319
R_VINT4_3237 MINT5_X_7040_Y_3520 MINT4_X_7040_Y_3520 1.319
R_VINT4_3238 MINT5_X_7040_Y_3840 MINT4_X_7040_Y_3840 1.319
R_VINT4_3239 MINT5_X_7040_Y_4160 MINT4_X_7040_Y_4160 1.319
R_VINT4_3240 MINT5_X_7040_Y_4480 MINT4_X_7040_Y_4480 1.319
R_VINT4_3241 MINT5_X_7040_Y_4800 MINT4_X_7040_Y_4800 1.319
R_VINT4_3242 MINT5_X_7040_Y_5120 MINT4_X_7040_Y_5120 1.319
R_VINT4_3243 MINT5_X_7040_Y_5440 MINT4_X_7040_Y_5440 1.319
R_VINT4_3244 MINT5_X_7040_Y_5760 MINT4_X_7040_Y_5760 1.319
R_VINT4_3245 MINT5_X_7040_Y_6080 MINT4_X_7040_Y_6080 1.319
R_VINT4_3246 MINT5_X_7040_Y_6400 MINT4_X_7040_Y_6400 1.319
R_VINT4_3247 MINT5_X_7040_Y_6720 MINT4_X_7040_Y_6720 1.319
R_VINT4_3248 MINT5_X_7040_Y_7040 MINT4_X_7040_Y_7040 1.319
R_VINT4_3249 MINT5_X_7040_Y_7360 MINT4_X_7040_Y_7360 1.319
R_VINT4_3250 MINT5_X_7040_Y_7680 MINT4_X_7040_Y_7680 1.319
R_VINT4_3251 MINT5_X_7040_Y_8000 MINT4_X_7040_Y_8000 1.319
R_VINT4_3252 MINT5_X_7040_Y_8320 MINT4_X_7040_Y_8320 1.319
R_VINT4_3253 MINT5_X_7040_Y_8640 MINT4_X_7040_Y_8640 1.319
R_VINT4_3254 MINT5_X_7040_Y_8960 MINT4_X_7040_Y_8960 1.319
R_VINT4_3255 MINT5_X_7040_Y_9280 MINT4_X_7040_Y_9280 1.319
R_VINT4_3256 MINT5_X_7040_Y_9600 MINT4_X_7040_Y_9600 1.319
R_VINT4_3257 MINT5_X_7040_Y_9920 MINT4_X_7040_Y_9920 1.319
R_VINT4_3258 MINT5_X_7360_Y_0 MINT4_X_7360_Y_0 1.319
R_VINT4_3259 MINT5_X_7360_Y_320 MINT4_X_7360_Y_320 1.319
R_VINT4_3260 MINT5_X_7360_Y_640 MINT4_X_7360_Y_640 1.319
R_VINT4_3261 MINT5_X_7360_Y_960 MINT4_X_7360_Y_960 1.319
R_VINT4_3262 MINT5_X_7360_Y_1280 MINT4_X_7360_Y_1280 1.319
R_VINT4_3263 MINT5_X_7360_Y_1600 MINT4_X_7360_Y_1600 1.319
R_VINT4_3264 MINT5_X_7360_Y_1920 MINT4_X_7360_Y_1920 1.319
R_VINT4_3265 MINT5_X_7360_Y_2240 MINT4_X_7360_Y_2240 1.319
R_VINT4_3266 MINT5_X_7360_Y_2560 MINT4_X_7360_Y_2560 1.319
R_VINT4_3267 MINT5_X_7360_Y_2880 MINT4_X_7360_Y_2880 1.319
R_VINT4_3268 MINT5_X_7360_Y_3200 MINT4_X_7360_Y_3200 1.319
R_VINT4_3269 MINT5_X_7360_Y_3520 MINT4_X_7360_Y_3520 1.319
R_VINT4_3270 MINT5_X_7360_Y_3840 MINT4_X_7360_Y_3840 1.319
R_VINT4_3271 MINT5_X_7360_Y_4160 MINT4_X_7360_Y_4160 1.319
R_VINT4_3272 MINT5_X_7360_Y_4480 MINT4_X_7360_Y_4480 1.319
R_VINT4_3273 MINT5_X_7360_Y_4800 MINT4_X_7360_Y_4800 1.319
R_VINT4_3274 MINT5_X_7360_Y_5120 MINT4_X_7360_Y_5120 1.319
R_VINT4_3275 MINT5_X_7360_Y_5440 MINT4_X_7360_Y_5440 1.319
R_VINT4_3276 MINT5_X_7360_Y_5760 MINT4_X_7360_Y_5760 1.319
R_VINT4_3277 MINT5_X_7360_Y_6080 MINT4_X_7360_Y_6080 1.319
R_VINT4_3278 MINT5_X_7360_Y_6400 MINT4_X_7360_Y_6400 1.319
R_VINT4_3279 MINT5_X_7360_Y_6720 MINT4_X_7360_Y_6720 1.319
R_VINT4_3280 MINT5_X_7360_Y_7040 MINT4_X_7360_Y_7040 1.319
R_VINT4_3281 MINT5_X_7360_Y_7360 MINT4_X_7360_Y_7360 1.319
R_VINT4_3282 MINT5_X_7360_Y_7680 MINT4_X_7360_Y_7680 1.319
R_VINT4_3283 MINT5_X_7360_Y_8000 MINT4_X_7360_Y_8000 1.319
R_VINT4_3284 MINT5_X_7360_Y_8320 MINT4_X_7360_Y_8320 1.319
R_VINT4_3285 MINT5_X_7360_Y_8640 MINT4_X_7360_Y_8640 1.319
R_VINT4_3286 MINT5_X_7360_Y_8960 MINT4_X_7360_Y_8960 1.319
R_VINT4_3287 MINT5_X_7360_Y_9280 MINT4_X_7360_Y_9280 1.319
R_VINT4_3288 MINT5_X_7360_Y_9600 MINT4_X_7360_Y_9600 1.319
R_VINT4_3289 MINT5_X_7360_Y_9920 MINT4_X_7360_Y_9920 1.319
R_VINT4_3290 MINT5_X_7680_Y_0 MINT4_X_7680_Y_0 1.319
R_VINT4_3291 MINT5_X_7680_Y_320 MINT4_X_7680_Y_320 1.319
R_VINT4_3292 MINT5_X_7680_Y_640 MINT4_X_7680_Y_640 1.319
R_VINT4_3293 MINT5_X_7680_Y_960 MINT4_X_7680_Y_960 1.319
R_VINT4_3294 MINT5_X_7680_Y_1280 MINT4_X_7680_Y_1280 1.319
R_VINT4_3295 MINT5_X_7680_Y_1600 MINT4_X_7680_Y_1600 1.319
R_VINT4_3296 MINT5_X_7680_Y_1920 MINT4_X_7680_Y_1920 1.319
R_VINT4_3297 MINT5_X_7680_Y_2240 MINT4_X_7680_Y_2240 1.319
R_VINT4_3298 MINT5_X_7680_Y_2560 MINT4_X_7680_Y_2560 1.319
R_VINT4_3299 MINT5_X_7680_Y_2880 MINT4_X_7680_Y_2880 1.319
R_VINT4_3300 MINT5_X_7680_Y_3200 MINT4_X_7680_Y_3200 1.319
R_VINT4_3301 MINT5_X_7680_Y_3520 MINT4_X_7680_Y_3520 1.319
R_VINT4_3302 MINT5_X_7680_Y_3840 MINT4_X_7680_Y_3840 1.319
R_VINT4_3303 MINT5_X_7680_Y_4160 MINT4_X_7680_Y_4160 1.319
R_VINT4_3304 MINT5_X_7680_Y_4480 MINT4_X_7680_Y_4480 1.319
R_VINT4_3305 MINT5_X_7680_Y_4800 MINT4_X_7680_Y_4800 1.319
R_VINT4_3306 MINT5_X_7680_Y_5120 MINT4_X_7680_Y_5120 1.319
R_VINT4_3307 MINT5_X_7680_Y_5440 MINT4_X_7680_Y_5440 1.319
R_VINT4_3308 MINT5_X_7680_Y_5760 MINT4_X_7680_Y_5760 1.319
R_VINT4_3309 MINT5_X_7680_Y_6080 MINT4_X_7680_Y_6080 1.319
R_VINT4_3310 MINT5_X_7680_Y_6400 MINT4_X_7680_Y_6400 1.319
R_VINT4_3311 MINT5_X_7680_Y_6720 MINT4_X_7680_Y_6720 1.319
R_VINT4_3312 MINT5_X_7680_Y_7040 MINT4_X_7680_Y_7040 1.319
R_VINT4_3313 MINT5_X_7680_Y_7360 MINT4_X_7680_Y_7360 1.319
R_VINT4_3314 MINT5_X_7680_Y_7680 MINT4_X_7680_Y_7680 1.319
R_VINT4_3315 MINT5_X_7680_Y_8000 MINT4_X_7680_Y_8000 1.319
R_VINT4_3316 MINT5_X_7680_Y_8320 MINT4_X_7680_Y_8320 1.319
R_VINT4_3317 MINT5_X_7680_Y_8640 MINT4_X_7680_Y_8640 1.319
R_VINT4_3318 MINT5_X_7680_Y_8960 MINT4_X_7680_Y_8960 1.319
R_VINT4_3319 MINT5_X_7680_Y_9280 MINT4_X_7680_Y_9280 1.319
R_VINT4_3320 MINT5_X_7680_Y_9600 MINT4_X_7680_Y_9600 1.319
R_VINT4_3321 MINT5_X_7680_Y_9920 MINT4_X_7680_Y_9920 1.319
R_VINT4_3322 MINT5_X_8000_Y_0 MINT4_X_8000_Y_0 1.319
R_VINT4_3323 MINT5_X_8000_Y_320 MINT4_X_8000_Y_320 1.319
R_VINT4_3324 MINT5_X_8000_Y_640 MINT4_X_8000_Y_640 1.319
R_VINT4_3325 MINT5_X_8000_Y_960 MINT4_X_8000_Y_960 1.319
R_VINT4_3326 MINT5_X_8000_Y_1280 MINT4_X_8000_Y_1280 1.319
R_VINT4_3327 MINT5_X_8000_Y_1600 MINT4_X_8000_Y_1600 1.319
R_VINT4_3328 MINT5_X_8000_Y_1920 MINT4_X_8000_Y_1920 1.319
R_VINT4_3329 MINT5_X_8000_Y_2240 MINT4_X_8000_Y_2240 1.319
R_VINT4_3330 MINT5_X_8000_Y_2560 MINT4_X_8000_Y_2560 1.319
R_VINT4_3331 MINT5_X_8000_Y_2880 MINT4_X_8000_Y_2880 1.319
R_VINT4_3332 MINT5_X_8000_Y_3200 MINT4_X_8000_Y_3200 1.319
R_VINT4_3333 MINT5_X_8000_Y_3520 MINT4_X_8000_Y_3520 1.319
R_VINT4_3334 MINT5_X_8000_Y_3840 MINT4_X_8000_Y_3840 1.319
R_VINT4_3335 MINT5_X_8000_Y_4160 MINT4_X_8000_Y_4160 1.319
R_VINT4_3336 MINT5_X_8000_Y_4480 MINT4_X_8000_Y_4480 1.319
R_VINT4_3337 MINT5_X_8000_Y_4800 MINT4_X_8000_Y_4800 1.319
R_VINT4_3338 MINT5_X_8000_Y_5120 MINT4_X_8000_Y_5120 1.319
R_VINT4_3339 MINT5_X_8000_Y_5440 MINT4_X_8000_Y_5440 1.319
R_VINT4_3340 MINT5_X_8000_Y_5760 MINT4_X_8000_Y_5760 1.319
R_VINT4_3341 MINT5_X_8000_Y_6080 MINT4_X_8000_Y_6080 1.319
R_VINT4_3342 MINT5_X_8000_Y_6400 MINT4_X_8000_Y_6400 1.319
R_VINT4_3343 MINT5_X_8000_Y_6720 MINT4_X_8000_Y_6720 1.319
R_VINT4_3344 MINT5_X_8000_Y_7040 MINT4_X_8000_Y_7040 1.319
R_VINT4_3345 MINT5_X_8000_Y_7360 MINT4_X_8000_Y_7360 1.319
R_VINT4_3346 MINT5_X_8000_Y_7680 MINT4_X_8000_Y_7680 1.319
R_VINT4_3347 MINT5_X_8000_Y_8000 MINT4_X_8000_Y_8000 1.319
R_VINT4_3348 MINT5_X_8000_Y_8320 MINT4_X_8000_Y_8320 1.319
R_VINT4_3349 MINT5_X_8000_Y_8640 MINT4_X_8000_Y_8640 1.319
R_VINT4_3350 MINT5_X_8000_Y_8960 MINT4_X_8000_Y_8960 1.319
R_VINT4_3351 MINT5_X_8000_Y_9280 MINT4_X_8000_Y_9280 1.319
R_VINT4_3352 MINT5_X_8000_Y_9600 MINT4_X_8000_Y_9600 1.319
R_VINT4_3353 MINT5_X_8000_Y_9920 MINT4_X_8000_Y_9920 1.319
R_VINT4_3354 MINT5_X_8320_Y_0 MINT4_X_8320_Y_0 1.319
R_VINT4_3355 MINT5_X_8320_Y_320 MINT4_X_8320_Y_320 1.319
R_VINT4_3356 MINT5_X_8320_Y_640 MINT4_X_8320_Y_640 1.319
R_VINT4_3357 MINT5_X_8320_Y_960 MINT4_X_8320_Y_960 1.319
R_VINT4_3358 MINT5_X_8320_Y_1280 MINT4_X_8320_Y_1280 1.319
R_VINT4_3359 MINT5_X_8320_Y_1600 MINT4_X_8320_Y_1600 1.319
R_VINT4_3360 MINT5_X_8320_Y_1920 MINT4_X_8320_Y_1920 1.319
R_VINT4_3361 MINT5_X_8320_Y_2240 MINT4_X_8320_Y_2240 1.319
R_VINT4_3362 MINT5_X_8320_Y_2560 MINT4_X_8320_Y_2560 1.319
R_VINT4_3363 MINT5_X_8320_Y_2880 MINT4_X_8320_Y_2880 1.319
R_VINT4_3364 MINT5_X_8320_Y_3200 MINT4_X_8320_Y_3200 1.319
R_VINT4_3365 MINT5_X_8320_Y_3520 MINT4_X_8320_Y_3520 1.319
R_VINT4_3366 MINT5_X_8320_Y_3840 MINT4_X_8320_Y_3840 1.319
R_VINT4_3367 MINT5_X_8320_Y_4160 MINT4_X_8320_Y_4160 1.319
R_VINT4_3368 MINT5_X_8320_Y_4480 MINT4_X_8320_Y_4480 1.319
R_VINT4_3369 MINT5_X_8320_Y_4800 MINT4_X_8320_Y_4800 1.319
R_VINT4_3370 MINT5_X_8320_Y_5120 MINT4_X_8320_Y_5120 1.319
R_VINT4_3371 MINT5_X_8320_Y_5440 MINT4_X_8320_Y_5440 1.319
R_VINT4_3372 MINT5_X_8320_Y_5760 MINT4_X_8320_Y_5760 1.319
R_VINT4_3373 MINT5_X_8320_Y_6080 MINT4_X_8320_Y_6080 1.319
R_VINT4_3374 MINT5_X_8320_Y_6400 MINT4_X_8320_Y_6400 1.319
R_VINT4_3375 MINT5_X_8320_Y_6720 MINT4_X_8320_Y_6720 1.319
R_VINT4_3376 MINT5_X_8320_Y_7040 MINT4_X_8320_Y_7040 1.319
R_VINT4_3377 MINT5_X_8320_Y_7360 MINT4_X_8320_Y_7360 1.319
R_VINT4_3378 MINT5_X_8320_Y_7680 MINT4_X_8320_Y_7680 1.319
R_VINT4_3379 MINT5_X_8320_Y_8000 MINT4_X_8320_Y_8000 1.319
R_VINT4_3380 MINT5_X_8320_Y_8320 MINT4_X_8320_Y_8320 1.319
R_VINT4_3381 MINT5_X_8320_Y_8640 MINT4_X_8320_Y_8640 1.319
R_VINT4_3382 MINT5_X_8320_Y_8960 MINT4_X_8320_Y_8960 1.319
R_VINT4_3383 MINT5_X_8320_Y_9280 MINT4_X_8320_Y_9280 1.319
R_VINT4_3384 MINT5_X_8320_Y_9600 MINT4_X_8320_Y_9600 1.319
R_VINT4_3385 MINT5_X_8320_Y_9920 MINT4_X_8320_Y_9920 1.319
R_VINT4_3386 MINT5_X_8640_Y_0 MINT4_X_8640_Y_0 1.319
R_VINT4_3387 MINT5_X_8640_Y_320 MINT4_X_8640_Y_320 1.319
R_VINT4_3388 MINT5_X_8640_Y_640 MINT4_X_8640_Y_640 1.319
R_VINT4_3389 MINT5_X_8640_Y_960 MINT4_X_8640_Y_960 1.319
R_VINT4_3390 MINT5_X_8640_Y_1280 MINT4_X_8640_Y_1280 1.319
R_VINT4_3391 MINT5_X_8640_Y_1600 MINT4_X_8640_Y_1600 1.319
R_VINT4_3392 MINT5_X_8640_Y_1920 MINT4_X_8640_Y_1920 1.319
R_VINT4_3393 MINT5_X_8640_Y_2240 MINT4_X_8640_Y_2240 1.319
R_VINT4_3394 MINT5_X_8640_Y_2560 MINT4_X_8640_Y_2560 1.319
R_VINT4_3395 MINT5_X_8640_Y_2880 MINT4_X_8640_Y_2880 1.319
R_VINT4_3396 MINT5_X_8640_Y_3200 MINT4_X_8640_Y_3200 1.319
R_VINT4_3397 MINT5_X_8640_Y_3520 MINT4_X_8640_Y_3520 1.319
R_VINT4_3398 MINT5_X_8640_Y_3840 MINT4_X_8640_Y_3840 1.319
R_VINT4_3399 MINT5_X_8640_Y_4160 MINT4_X_8640_Y_4160 1.319
R_VINT4_3400 MINT5_X_8640_Y_4480 MINT4_X_8640_Y_4480 1.319
R_VINT4_3401 MINT5_X_8640_Y_4800 MINT4_X_8640_Y_4800 1.319
R_VINT4_3402 MINT5_X_8640_Y_5120 MINT4_X_8640_Y_5120 1.319
R_VINT4_3403 MINT5_X_8640_Y_5440 MINT4_X_8640_Y_5440 1.319
R_VINT4_3404 MINT5_X_8640_Y_5760 MINT4_X_8640_Y_5760 1.319
R_VINT4_3405 MINT5_X_8640_Y_6080 MINT4_X_8640_Y_6080 1.319
R_VINT4_3406 MINT5_X_8640_Y_6400 MINT4_X_8640_Y_6400 1.319
R_VINT4_3407 MINT5_X_8640_Y_6720 MINT4_X_8640_Y_6720 1.319
R_VINT4_3408 MINT5_X_8640_Y_7040 MINT4_X_8640_Y_7040 1.319
R_VINT4_3409 MINT5_X_8640_Y_7360 MINT4_X_8640_Y_7360 1.319
R_VINT4_3410 MINT5_X_8640_Y_7680 MINT4_X_8640_Y_7680 1.319
R_VINT4_3411 MINT5_X_8640_Y_8000 MINT4_X_8640_Y_8000 1.319
R_VINT4_3412 MINT5_X_8640_Y_8320 MINT4_X_8640_Y_8320 1.319
R_VINT4_3413 MINT5_X_8640_Y_8640 MINT4_X_8640_Y_8640 1.319
R_VINT4_3414 MINT5_X_8640_Y_8960 MINT4_X_8640_Y_8960 1.319
R_VINT4_3415 MINT5_X_8640_Y_9280 MINT4_X_8640_Y_9280 1.319
R_VINT4_3416 MINT5_X_8640_Y_9600 MINT4_X_8640_Y_9600 1.319
R_VINT4_3417 MINT5_X_8640_Y_9920 MINT4_X_8640_Y_9920 1.319
R_VINT4_3418 MINT5_X_8960_Y_0 MINT4_X_8960_Y_0 1.319
R_VINT4_3419 MINT5_X_8960_Y_320 MINT4_X_8960_Y_320 1.319
R_VINT4_3420 MINT5_X_8960_Y_640 MINT4_X_8960_Y_640 1.319
R_VINT4_3421 MINT5_X_8960_Y_960 MINT4_X_8960_Y_960 1.319
R_VINT4_3422 MINT5_X_8960_Y_1280 MINT4_X_8960_Y_1280 1.319
R_VINT4_3423 MINT5_X_8960_Y_1600 MINT4_X_8960_Y_1600 1.319
R_VINT4_3424 MINT5_X_8960_Y_1920 MINT4_X_8960_Y_1920 1.319
R_VINT4_3425 MINT5_X_8960_Y_2240 MINT4_X_8960_Y_2240 1.319
R_VINT4_3426 MINT5_X_8960_Y_2560 MINT4_X_8960_Y_2560 1.319
R_VINT4_3427 MINT5_X_8960_Y_2880 MINT4_X_8960_Y_2880 1.319
R_VINT4_3428 MINT5_X_8960_Y_3200 MINT4_X_8960_Y_3200 1.319
R_VINT4_3429 MINT5_X_8960_Y_3520 MINT4_X_8960_Y_3520 1.319
R_VINT4_3430 MINT5_X_8960_Y_3840 MINT4_X_8960_Y_3840 1.319
R_VINT4_3431 MINT5_X_8960_Y_4160 MINT4_X_8960_Y_4160 1.319
R_VINT4_3432 MINT5_X_8960_Y_4480 MINT4_X_8960_Y_4480 1.319
R_VINT4_3433 MINT5_X_8960_Y_4800 MINT4_X_8960_Y_4800 1.319
R_VINT4_3434 MINT5_X_8960_Y_5120 MINT4_X_8960_Y_5120 1.319
R_VINT4_3435 MINT5_X_8960_Y_5440 MINT4_X_8960_Y_5440 1.319
R_VINT4_3436 MINT5_X_8960_Y_5760 MINT4_X_8960_Y_5760 1.319
R_VINT4_3437 MINT5_X_8960_Y_6080 MINT4_X_8960_Y_6080 1.319
R_VINT4_3438 MINT5_X_8960_Y_6400 MINT4_X_8960_Y_6400 1.319
R_VINT4_3439 MINT5_X_8960_Y_6720 MINT4_X_8960_Y_6720 1.319
R_VINT4_3440 MINT5_X_8960_Y_7040 MINT4_X_8960_Y_7040 1.319
R_VINT4_3441 MINT5_X_8960_Y_7360 MINT4_X_8960_Y_7360 1.319
R_VINT4_3442 MINT5_X_8960_Y_7680 MINT4_X_8960_Y_7680 1.319
R_VINT4_3443 MINT5_X_8960_Y_8000 MINT4_X_8960_Y_8000 1.319
R_VINT4_3444 MINT5_X_8960_Y_8320 MINT4_X_8960_Y_8320 1.319
R_VINT4_3445 MINT5_X_8960_Y_8640 MINT4_X_8960_Y_8640 1.319
R_VINT4_3446 MINT5_X_8960_Y_8960 MINT4_X_8960_Y_8960 1.319
R_VINT4_3447 MINT5_X_8960_Y_9280 MINT4_X_8960_Y_9280 1.319
R_VINT4_3448 MINT5_X_8960_Y_9600 MINT4_X_8960_Y_9600 1.319
R_VINT4_3449 MINT5_X_8960_Y_9920 MINT4_X_8960_Y_9920 1.319
R_VINT4_3450 MINT5_X_9280_Y_0 MINT4_X_9280_Y_0 1.319
R_VINT4_3451 MINT5_X_9280_Y_320 MINT4_X_9280_Y_320 1.319
R_VINT4_3452 MINT5_X_9280_Y_640 MINT4_X_9280_Y_640 1.319
R_VINT4_3453 MINT5_X_9280_Y_960 MINT4_X_9280_Y_960 1.319
R_VINT4_3454 MINT5_X_9280_Y_1280 MINT4_X_9280_Y_1280 1.319
R_VINT4_3455 MINT5_X_9280_Y_1600 MINT4_X_9280_Y_1600 1.319
R_VINT4_3456 MINT5_X_9280_Y_1920 MINT4_X_9280_Y_1920 1.319
R_VINT4_3457 MINT5_X_9280_Y_2240 MINT4_X_9280_Y_2240 1.319
R_VINT4_3458 MINT5_X_9280_Y_2560 MINT4_X_9280_Y_2560 1.319
R_VINT4_3459 MINT5_X_9280_Y_2880 MINT4_X_9280_Y_2880 1.319
R_VINT4_3460 MINT5_X_9280_Y_3200 MINT4_X_9280_Y_3200 1.319
R_VINT4_3461 MINT5_X_9280_Y_3520 MINT4_X_9280_Y_3520 1.319
R_VINT4_3462 MINT5_X_9280_Y_3840 MINT4_X_9280_Y_3840 1.319
R_VINT4_3463 MINT5_X_9280_Y_4160 MINT4_X_9280_Y_4160 1.319
R_VINT4_3464 MINT5_X_9280_Y_4480 MINT4_X_9280_Y_4480 1.319
R_VINT4_3465 MINT5_X_9280_Y_4800 MINT4_X_9280_Y_4800 1.319
R_VINT4_3466 MINT5_X_9280_Y_5120 MINT4_X_9280_Y_5120 1.319
R_VINT4_3467 MINT5_X_9280_Y_5440 MINT4_X_9280_Y_5440 1.319
R_VINT4_3468 MINT5_X_9280_Y_5760 MINT4_X_9280_Y_5760 1.319
R_VINT4_3469 MINT5_X_9280_Y_6080 MINT4_X_9280_Y_6080 1.319
R_VINT4_3470 MINT5_X_9280_Y_6400 MINT4_X_9280_Y_6400 1.319
R_VINT4_3471 MINT5_X_9280_Y_6720 MINT4_X_9280_Y_6720 1.319
R_VINT4_3472 MINT5_X_9280_Y_7040 MINT4_X_9280_Y_7040 1.319
R_VINT4_3473 MINT5_X_9280_Y_7360 MINT4_X_9280_Y_7360 1.319
R_VINT4_3474 MINT5_X_9280_Y_7680 MINT4_X_9280_Y_7680 1.319
R_VINT4_3475 MINT5_X_9280_Y_8000 MINT4_X_9280_Y_8000 1.319
R_VINT4_3476 MINT5_X_9280_Y_8320 MINT4_X_9280_Y_8320 1.319
R_VINT4_3477 MINT5_X_9280_Y_8640 MINT4_X_9280_Y_8640 1.319
R_VINT4_3478 MINT5_X_9280_Y_8960 MINT4_X_9280_Y_8960 1.319
R_VINT4_3479 MINT5_X_9280_Y_9280 MINT4_X_9280_Y_9280 1.319
R_VINT4_3480 MINT5_X_9280_Y_9600 MINT4_X_9280_Y_9600 1.319
R_VINT4_3481 MINT5_X_9280_Y_9920 MINT4_X_9280_Y_9920 1.319
R_VINT4_3482 MINT5_X_9600_Y_0 MINT4_X_9600_Y_0 1.319
R_VINT4_3483 MINT5_X_9600_Y_320 MINT4_X_9600_Y_320 1.319
R_VINT4_3484 MINT5_X_9600_Y_640 MINT4_X_9600_Y_640 1.319
R_VINT4_3485 MINT5_X_9600_Y_960 MINT4_X_9600_Y_960 1.319
R_VINT4_3486 MINT5_X_9600_Y_1280 MINT4_X_9600_Y_1280 1.319
R_VINT4_3487 MINT5_X_9600_Y_1600 MINT4_X_9600_Y_1600 1.319
R_VINT4_3488 MINT5_X_9600_Y_1920 MINT4_X_9600_Y_1920 1.319
R_VINT4_3489 MINT5_X_9600_Y_2240 MINT4_X_9600_Y_2240 1.319
R_VINT4_3490 MINT5_X_9600_Y_2560 MINT4_X_9600_Y_2560 1.319
R_VINT4_3491 MINT5_X_9600_Y_2880 MINT4_X_9600_Y_2880 1.319
R_VINT4_3492 MINT5_X_9600_Y_3200 MINT4_X_9600_Y_3200 1.319
R_VINT4_3493 MINT5_X_9600_Y_3520 MINT4_X_9600_Y_3520 1.319
R_VINT4_3494 MINT5_X_9600_Y_3840 MINT4_X_9600_Y_3840 1.319
R_VINT4_3495 MINT5_X_9600_Y_4160 MINT4_X_9600_Y_4160 1.319
R_VINT4_3496 MINT5_X_9600_Y_4480 MINT4_X_9600_Y_4480 1.319
R_VINT4_3497 MINT5_X_9600_Y_4800 MINT4_X_9600_Y_4800 1.319
R_VINT4_3498 MINT5_X_9600_Y_5120 MINT4_X_9600_Y_5120 1.319
R_VINT4_3499 MINT5_X_9600_Y_5440 MINT4_X_9600_Y_5440 1.319
R_VINT4_3500 MINT5_X_9600_Y_5760 MINT4_X_9600_Y_5760 1.319
R_VINT4_3501 MINT5_X_9600_Y_6080 MINT4_X_9600_Y_6080 1.319
R_VINT4_3502 MINT5_X_9600_Y_6400 MINT4_X_9600_Y_6400 1.319
R_VINT4_3503 MINT5_X_9600_Y_6720 MINT4_X_9600_Y_6720 1.319
R_VINT4_3504 MINT5_X_9600_Y_7040 MINT4_X_9600_Y_7040 1.319
R_VINT4_3505 MINT5_X_9600_Y_7360 MINT4_X_9600_Y_7360 1.319
R_VINT4_3506 MINT5_X_9600_Y_7680 MINT4_X_9600_Y_7680 1.319
R_VINT4_3507 MINT5_X_9600_Y_8000 MINT4_X_9600_Y_8000 1.319
R_VINT4_3508 MINT5_X_9600_Y_8320 MINT4_X_9600_Y_8320 1.319
R_VINT4_3509 MINT5_X_9600_Y_8640 MINT4_X_9600_Y_8640 1.319
R_VINT4_3510 MINT5_X_9600_Y_8960 MINT4_X_9600_Y_8960 1.319
R_VINT4_3511 MINT5_X_9600_Y_9280 MINT4_X_9600_Y_9280 1.319
R_VINT4_3512 MINT5_X_9600_Y_9600 MINT4_X_9600_Y_9600 1.319
R_VINT4_3513 MINT5_X_9600_Y_9920 MINT4_X_9600_Y_9920 1.319
R_VINT4_3514 MINT5_X_9920_Y_0 MINT4_X_9920_Y_0 1.319
R_VINT4_3515 MINT5_X_9920_Y_320 MINT4_X_9920_Y_320 1.319
R_VINT4_3516 MINT5_X_9920_Y_640 MINT4_X_9920_Y_640 1.319
R_VINT4_3517 MINT5_X_9920_Y_960 MINT4_X_9920_Y_960 1.319
R_VINT4_3518 MINT5_X_9920_Y_1280 MINT4_X_9920_Y_1280 1.319
R_VINT4_3519 MINT5_X_9920_Y_1600 MINT4_X_9920_Y_1600 1.319
R_VINT4_3520 MINT5_X_9920_Y_1920 MINT4_X_9920_Y_1920 1.319
R_VINT4_3521 MINT5_X_9920_Y_2240 MINT4_X_9920_Y_2240 1.319
R_VINT4_3522 MINT5_X_9920_Y_2560 MINT4_X_9920_Y_2560 1.319
R_VINT4_3523 MINT5_X_9920_Y_2880 MINT4_X_9920_Y_2880 1.319
R_VINT4_3524 MINT5_X_9920_Y_3200 MINT4_X_9920_Y_3200 1.319
R_VINT4_3525 MINT5_X_9920_Y_3520 MINT4_X_9920_Y_3520 1.319
R_VINT4_3526 MINT5_X_9920_Y_3840 MINT4_X_9920_Y_3840 1.319
R_VINT4_3527 MINT5_X_9920_Y_4160 MINT4_X_9920_Y_4160 1.319
R_VINT4_3528 MINT5_X_9920_Y_4480 MINT4_X_9920_Y_4480 1.319
R_VINT4_3529 MINT5_X_9920_Y_4800 MINT4_X_9920_Y_4800 1.319
R_VINT4_3530 MINT5_X_9920_Y_5120 MINT4_X_9920_Y_5120 1.319
R_VINT4_3531 MINT5_X_9920_Y_5440 MINT4_X_9920_Y_5440 1.319
R_VINT4_3532 MINT5_X_9920_Y_5760 MINT4_X_9920_Y_5760 1.319
R_VINT4_3533 MINT5_X_9920_Y_6080 MINT4_X_9920_Y_6080 1.319
R_VINT4_3534 MINT5_X_9920_Y_6400 MINT4_X_9920_Y_6400 1.319
R_VINT4_3535 MINT5_X_9920_Y_6720 MINT4_X_9920_Y_6720 1.319
R_VINT4_3536 MINT5_X_9920_Y_7040 MINT4_X_9920_Y_7040 1.319
R_VINT4_3537 MINT5_X_9920_Y_7360 MINT4_X_9920_Y_7360 1.319
R_VINT4_3538 MINT5_X_9920_Y_7680 MINT4_X_9920_Y_7680 1.319
R_VINT4_3539 MINT5_X_9920_Y_8000 MINT4_X_9920_Y_8000 1.319
R_VINT4_3540 MINT5_X_9920_Y_8320 MINT4_X_9920_Y_8320 1.319
R_VINT4_3541 MINT5_X_9920_Y_8640 MINT4_X_9920_Y_8640 1.319
R_VINT4_3542 MINT5_X_9920_Y_8960 MINT4_X_9920_Y_8960 1.319
R_VINT4_3543 MINT5_X_9920_Y_9280 MINT4_X_9920_Y_9280 1.319
R_VINT4_3544 MINT5_X_9920_Y_9600 MINT4_X_9920_Y_9600 1.319
R_VINT4_3545 MINT5_X_9920_Y_9920 MINT4_X_9920_Y_9920 1.319
R_VINT3_3546 MINT4_X_0_Y_0 MINT3_X_0_Y_0 1.319
R_VINT3_3547 MINT4_X_0_Y_320 MINT3_X_0_Y_320 1.319
R_VINT3_3548 MINT4_X_0_Y_640 MINT3_X_0_Y_640 1.319
R_VINT3_3549 MINT4_X_0_Y_960 MINT3_X_0_Y_960 1.319
R_VINT3_3550 MINT4_X_0_Y_1280 MINT3_X_0_Y_1280 1.319
R_VINT3_3551 MINT4_X_0_Y_1600 MINT3_X_0_Y_1600 1.319
R_VINT3_3552 MINT4_X_0_Y_1920 MINT3_X_0_Y_1920 1.319
R_VINT3_3553 MINT4_X_0_Y_2240 MINT3_X_0_Y_2240 1.319
R_VINT3_3554 MINT4_X_0_Y_2560 MINT3_X_0_Y_2560 1.319
R_VINT3_3555 MINT4_X_0_Y_2880 MINT3_X_0_Y_2880 1.319
R_VINT3_3556 MINT4_X_0_Y_3200 MINT3_X_0_Y_3200 1.319
R_VINT3_3557 MINT4_X_0_Y_3520 MINT3_X_0_Y_3520 1.319
R_VINT3_3558 MINT4_X_0_Y_3840 MINT3_X_0_Y_3840 1.319
R_VINT3_3559 MINT4_X_0_Y_4160 MINT3_X_0_Y_4160 1.319
R_VINT3_3560 MINT4_X_0_Y_4480 MINT3_X_0_Y_4480 1.319
R_VINT3_3561 MINT4_X_0_Y_4800 MINT3_X_0_Y_4800 1.319
R_VINT3_3562 MINT4_X_0_Y_5120 MINT3_X_0_Y_5120 1.319
R_VINT3_3563 MINT4_X_0_Y_5440 MINT3_X_0_Y_5440 1.319
R_VINT3_3564 MINT4_X_0_Y_5760 MINT3_X_0_Y_5760 1.319
R_VINT3_3565 MINT4_X_0_Y_6080 MINT3_X_0_Y_6080 1.319
R_VINT3_3566 MINT4_X_0_Y_6400 MINT3_X_0_Y_6400 1.319
R_VINT3_3567 MINT4_X_0_Y_6720 MINT3_X_0_Y_6720 1.319
R_VINT3_3568 MINT4_X_0_Y_7040 MINT3_X_0_Y_7040 1.319
R_VINT3_3569 MINT4_X_0_Y_7360 MINT3_X_0_Y_7360 1.319
R_VINT3_3570 MINT4_X_0_Y_7680 MINT3_X_0_Y_7680 1.319
R_VINT3_3571 MINT4_X_0_Y_8000 MINT3_X_0_Y_8000 1.319
R_VINT3_3572 MINT4_X_0_Y_8320 MINT3_X_0_Y_8320 1.319
R_VINT3_3573 MINT4_X_0_Y_8640 MINT3_X_0_Y_8640 1.319
R_VINT3_3574 MINT4_X_0_Y_8960 MINT3_X_0_Y_8960 1.319
R_VINT3_3575 MINT4_X_0_Y_9280 MINT3_X_0_Y_9280 1.319
R_VINT3_3576 MINT4_X_0_Y_9600 MINT3_X_0_Y_9600 1.319
R_VINT3_3577 MINT4_X_0_Y_9920 MINT3_X_0_Y_9920 1.319
R_VINT3_3578 MINT4_X_320_Y_0 MINT3_X_320_Y_0 1.319
R_VINT3_3579 MINT4_X_320_Y_320 MINT3_X_320_Y_320 1.319
R_VINT3_3580 MINT4_X_320_Y_640 MINT3_X_320_Y_640 1.319
R_VINT3_3581 MINT4_X_320_Y_960 MINT3_X_320_Y_960 1.319
R_VINT3_3582 MINT4_X_320_Y_1280 MINT3_X_320_Y_1280 1.319
R_VINT3_3583 MINT4_X_320_Y_1600 MINT3_X_320_Y_1600 1.319
R_VINT3_3584 MINT4_X_320_Y_1920 MINT3_X_320_Y_1920 1.319
R_VINT3_3585 MINT4_X_320_Y_2240 MINT3_X_320_Y_2240 1.319
R_VINT3_3586 MINT4_X_320_Y_2560 MINT3_X_320_Y_2560 1.319
R_VINT3_3587 MINT4_X_320_Y_2880 MINT3_X_320_Y_2880 1.319
R_VINT3_3588 MINT4_X_320_Y_3200 MINT3_X_320_Y_3200 1.319
R_VINT3_3589 MINT4_X_320_Y_3520 MINT3_X_320_Y_3520 1.319
R_VINT3_3590 MINT4_X_320_Y_3840 MINT3_X_320_Y_3840 1.319
R_VINT3_3591 MINT4_X_320_Y_4160 MINT3_X_320_Y_4160 1.319
R_VINT3_3592 MINT4_X_320_Y_4480 MINT3_X_320_Y_4480 1.319
R_VINT3_3593 MINT4_X_320_Y_4800 MINT3_X_320_Y_4800 1.319
R_VINT3_3594 MINT4_X_320_Y_5120 MINT3_X_320_Y_5120 1.319
R_VINT3_3595 MINT4_X_320_Y_5440 MINT3_X_320_Y_5440 1.319
R_VINT3_3596 MINT4_X_320_Y_5760 MINT3_X_320_Y_5760 1.319
R_VINT3_3597 MINT4_X_320_Y_6080 MINT3_X_320_Y_6080 1.319
R_VINT3_3598 MINT4_X_320_Y_6400 MINT3_X_320_Y_6400 1.319
R_VINT3_3599 MINT4_X_320_Y_6720 MINT3_X_320_Y_6720 1.319
R_VINT3_3600 MINT4_X_320_Y_7040 MINT3_X_320_Y_7040 1.319
R_VINT3_3601 MINT4_X_320_Y_7360 MINT3_X_320_Y_7360 1.319
R_VINT3_3602 MINT4_X_320_Y_7680 MINT3_X_320_Y_7680 1.319
R_VINT3_3603 MINT4_X_320_Y_8000 MINT3_X_320_Y_8000 1.319
R_VINT3_3604 MINT4_X_320_Y_8320 MINT3_X_320_Y_8320 1.319
R_VINT3_3605 MINT4_X_320_Y_8640 MINT3_X_320_Y_8640 1.319
R_VINT3_3606 MINT4_X_320_Y_8960 MINT3_X_320_Y_8960 1.319
R_VINT3_3607 MINT4_X_320_Y_9280 MINT3_X_320_Y_9280 1.319
R_VINT3_3608 MINT4_X_320_Y_9600 MINT3_X_320_Y_9600 1.319
R_VINT3_3609 MINT4_X_320_Y_9920 MINT3_X_320_Y_9920 1.319
R_VINT3_3610 MINT4_X_640_Y_0 MINT3_X_640_Y_0 1.319
R_VINT3_3611 MINT4_X_640_Y_320 MINT3_X_640_Y_320 1.319
R_VINT3_3612 MINT4_X_640_Y_640 MINT3_X_640_Y_640 1.319
R_VINT3_3613 MINT4_X_640_Y_960 MINT3_X_640_Y_960 1.319
R_VINT3_3614 MINT4_X_640_Y_1280 MINT3_X_640_Y_1280 1.319
R_VINT3_3615 MINT4_X_640_Y_1600 MINT3_X_640_Y_1600 1.319
R_VINT3_3616 MINT4_X_640_Y_1920 MINT3_X_640_Y_1920 1.319
R_VINT3_3617 MINT4_X_640_Y_2240 MINT3_X_640_Y_2240 1.319
R_VINT3_3618 MINT4_X_640_Y_2560 MINT3_X_640_Y_2560 1.319
R_VINT3_3619 MINT4_X_640_Y_2880 MINT3_X_640_Y_2880 1.319
R_VINT3_3620 MINT4_X_640_Y_3200 MINT3_X_640_Y_3200 1.319
R_VINT3_3621 MINT4_X_640_Y_3520 MINT3_X_640_Y_3520 1.319
R_VINT3_3622 MINT4_X_640_Y_3840 MINT3_X_640_Y_3840 1.319
R_VINT3_3623 MINT4_X_640_Y_4160 MINT3_X_640_Y_4160 1.319
R_VINT3_3624 MINT4_X_640_Y_4480 MINT3_X_640_Y_4480 1.319
R_VINT3_3625 MINT4_X_640_Y_4800 MINT3_X_640_Y_4800 1.319
R_VINT3_3626 MINT4_X_640_Y_5120 MINT3_X_640_Y_5120 1.319
R_VINT3_3627 MINT4_X_640_Y_5440 MINT3_X_640_Y_5440 1.319
R_VINT3_3628 MINT4_X_640_Y_5760 MINT3_X_640_Y_5760 1.319
R_VINT3_3629 MINT4_X_640_Y_6080 MINT3_X_640_Y_6080 1.319
R_VINT3_3630 MINT4_X_640_Y_6400 MINT3_X_640_Y_6400 1.319
R_VINT3_3631 MINT4_X_640_Y_6720 MINT3_X_640_Y_6720 1.319
R_VINT3_3632 MINT4_X_640_Y_7040 MINT3_X_640_Y_7040 1.319
R_VINT3_3633 MINT4_X_640_Y_7360 MINT3_X_640_Y_7360 1.319
R_VINT3_3634 MINT4_X_640_Y_7680 MINT3_X_640_Y_7680 1.319
R_VINT3_3635 MINT4_X_640_Y_8000 MINT3_X_640_Y_8000 1.319
R_VINT3_3636 MINT4_X_640_Y_8320 MINT3_X_640_Y_8320 1.319
R_VINT3_3637 MINT4_X_640_Y_8640 MINT3_X_640_Y_8640 1.319
R_VINT3_3638 MINT4_X_640_Y_8960 MINT3_X_640_Y_8960 1.319
R_VINT3_3639 MINT4_X_640_Y_9280 MINT3_X_640_Y_9280 1.319
R_VINT3_3640 MINT4_X_640_Y_9600 MINT3_X_640_Y_9600 1.319
R_VINT3_3641 MINT4_X_640_Y_9920 MINT3_X_640_Y_9920 1.319
R_VINT3_3642 MINT4_X_960_Y_0 MINT3_X_960_Y_0 1.319
R_VINT3_3643 MINT4_X_960_Y_320 MINT3_X_960_Y_320 1.319
R_VINT3_3644 MINT4_X_960_Y_640 MINT3_X_960_Y_640 1.319
R_VINT3_3645 MINT4_X_960_Y_960 MINT3_X_960_Y_960 1.319
R_VINT3_3646 MINT4_X_960_Y_1280 MINT3_X_960_Y_1280 1.319
R_VINT3_3647 MINT4_X_960_Y_1600 MINT3_X_960_Y_1600 1.319
R_VINT3_3648 MINT4_X_960_Y_1920 MINT3_X_960_Y_1920 1.319
R_VINT3_3649 MINT4_X_960_Y_2240 MINT3_X_960_Y_2240 1.319
R_VINT3_3650 MINT4_X_960_Y_2560 MINT3_X_960_Y_2560 1.319
R_VINT3_3651 MINT4_X_960_Y_2880 MINT3_X_960_Y_2880 1.319
R_VINT3_3652 MINT4_X_960_Y_3200 MINT3_X_960_Y_3200 1.319
R_VINT3_3653 MINT4_X_960_Y_3520 MINT3_X_960_Y_3520 1.319
R_VINT3_3654 MINT4_X_960_Y_3840 MINT3_X_960_Y_3840 1.319
R_VINT3_3655 MINT4_X_960_Y_4160 MINT3_X_960_Y_4160 1.319
R_VINT3_3656 MINT4_X_960_Y_4480 MINT3_X_960_Y_4480 1.319
R_VINT3_3657 MINT4_X_960_Y_4800 MINT3_X_960_Y_4800 1.319
R_VINT3_3658 MINT4_X_960_Y_5120 MINT3_X_960_Y_5120 1.319
R_VINT3_3659 MINT4_X_960_Y_5440 MINT3_X_960_Y_5440 1.319
R_VINT3_3660 MINT4_X_960_Y_5760 MINT3_X_960_Y_5760 1.319
R_VINT3_3661 MINT4_X_960_Y_6080 MINT3_X_960_Y_6080 1.319
R_VINT3_3662 MINT4_X_960_Y_6400 MINT3_X_960_Y_6400 1.319
R_VINT3_3663 MINT4_X_960_Y_6720 MINT3_X_960_Y_6720 1.319
R_VINT3_3664 MINT4_X_960_Y_7040 MINT3_X_960_Y_7040 1.319
R_VINT3_3665 MINT4_X_960_Y_7360 MINT3_X_960_Y_7360 1.319
R_VINT3_3666 MINT4_X_960_Y_7680 MINT3_X_960_Y_7680 1.319
R_VINT3_3667 MINT4_X_960_Y_8000 MINT3_X_960_Y_8000 1.319
R_VINT3_3668 MINT4_X_960_Y_8320 MINT3_X_960_Y_8320 1.319
R_VINT3_3669 MINT4_X_960_Y_8640 MINT3_X_960_Y_8640 1.319
R_VINT3_3670 MINT4_X_960_Y_8960 MINT3_X_960_Y_8960 1.319
R_VINT3_3671 MINT4_X_960_Y_9280 MINT3_X_960_Y_9280 1.319
R_VINT3_3672 MINT4_X_960_Y_9600 MINT3_X_960_Y_9600 1.319
R_VINT3_3673 MINT4_X_960_Y_9920 MINT3_X_960_Y_9920 1.319
R_VINT3_3674 MINT4_X_1280_Y_0 MINT3_X_1280_Y_0 1.319
R_VINT3_3675 MINT4_X_1280_Y_320 MINT3_X_1280_Y_320 1.319
R_VINT3_3676 MINT4_X_1280_Y_640 MINT3_X_1280_Y_640 1.319
R_VINT3_3677 MINT4_X_1280_Y_960 MINT3_X_1280_Y_960 1.319
R_VINT3_3678 MINT4_X_1280_Y_1280 MINT3_X_1280_Y_1280 1.319
R_VINT3_3679 MINT4_X_1280_Y_1600 MINT3_X_1280_Y_1600 1.319
R_VINT3_3680 MINT4_X_1280_Y_1920 MINT3_X_1280_Y_1920 1.319
R_VINT3_3681 MINT4_X_1280_Y_2240 MINT3_X_1280_Y_2240 1.319
R_VINT3_3682 MINT4_X_1280_Y_2560 MINT3_X_1280_Y_2560 1.319
R_VINT3_3683 MINT4_X_1280_Y_2880 MINT3_X_1280_Y_2880 1.319
R_VINT3_3684 MINT4_X_1280_Y_3200 MINT3_X_1280_Y_3200 1.319
R_VINT3_3685 MINT4_X_1280_Y_3520 MINT3_X_1280_Y_3520 1.319
R_VINT3_3686 MINT4_X_1280_Y_3840 MINT3_X_1280_Y_3840 1.319
R_VINT3_3687 MINT4_X_1280_Y_4160 MINT3_X_1280_Y_4160 1.319
R_VINT3_3688 MINT4_X_1280_Y_4480 MINT3_X_1280_Y_4480 1.319
R_VINT3_3689 MINT4_X_1280_Y_4800 MINT3_X_1280_Y_4800 1.319
R_VINT3_3690 MINT4_X_1280_Y_5120 MINT3_X_1280_Y_5120 1.319
R_VINT3_3691 MINT4_X_1280_Y_5440 MINT3_X_1280_Y_5440 1.319
R_VINT3_3692 MINT4_X_1280_Y_5760 MINT3_X_1280_Y_5760 1.319
R_VINT3_3693 MINT4_X_1280_Y_6080 MINT3_X_1280_Y_6080 1.319
R_VINT3_3694 MINT4_X_1280_Y_6400 MINT3_X_1280_Y_6400 1.319
R_VINT3_3695 MINT4_X_1280_Y_6720 MINT3_X_1280_Y_6720 1.319
R_VINT3_3696 MINT4_X_1280_Y_7040 MINT3_X_1280_Y_7040 1.319
R_VINT3_3697 MINT4_X_1280_Y_7360 MINT3_X_1280_Y_7360 1.319
R_VINT3_3698 MINT4_X_1280_Y_7680 MINT3_X_1280_Y_7680 1.319
R_VINT3_3699 MINT4_X_1280_Y_8000 MINT3_X_1280_Y_8000 1.319
R_VINT3_3700 MINT4_X_1280_Y_8320 MINT3_X_1280_Y_8320 1.319
R_VINT3_3701 MINT4_X_1280_Y_8640 MINT3_X_1280_Y_8640 1.319
R_VINT3_3702 MINT4_X_1280_Y_8960 MINT3_X_1280_Y_8960 1.319
R_VINT3_3703 MINT4_X_1280_Y_9280 MINT3_X_1280_Y_9280 1.319
R_VINT3_3704 MINT4_X_1280_Y_9600 MINT3_X_1280_Y_9600 1.319
R_VINT3_3705 MINT4_X_1280_Y_9920 MINT3_X_1280_Y_9920 1.319
R_VINT3_3706 MINT4_X_1600_Y_0 MINT3_X_1600_Y_0 1.319
R_VINT3_3707 MINT4_X_1600_Y_320 MINT3_X_1600_Y_320 1.319
R_VINT3_3708 MINT4_X_1600_Y_640 MINT3_X_1600_Y_640 1.319
R_VINT3_3709 MINT4_X_1600_Y_960 MINT3_X_1600_Y_960 1.319
R_VINT3_3710 MINT4_X_1600_Y_1280 MINT3_X_1600_Y_1280 1.319
R_VINT3_3711 MINT4_X_1600_Y_1600 MINT3_X_1600_Y_1600 1.319
R_VINT3_3712 MINT4_X_1600_Y_1920 MINT3_X_1600_Y_1920 1.319
R_VINT3_3713 MINT4_X_1600_Y_2240 MINT3_X_1600_Y_2240 1.319
R_VINT3_3714 MINT4_X_1600_Y_2560 MINT3_X_1600_Y_2560 1.319
R_VINT3_3715 MINT4_X_1600_Y_2880 MINT3_X_1600_Y_2880 1.319
R_VINT3_3716 MINT4_X_1600_Y_3200 MINT3_X_1600_Y_3200 1.319
R_VINT3_3717 MINT4_X_1600_Y_3520 MINT3_X_1600_Y_3520 1.319
R_VINT3_3718 MINT4_X_1600_Y_3840 MINT3_X_1600_Y_3840 1.319
R_VINT3_3719 MINT4_X_1600_Y_4160 MINT3_X_1600_Y_4160 1.319
R_VINT3_3720 MINT4_X_1600_Y_4480 MINT3_X_1600_Y_4480 1.319
R_VINT3_3721 MINT4_X_1600_Y_4800 MINT3_X_1600_Y_4800 1.319
R_VINT3_3722 MINT4_X_1600_Y_5120 MINT3_X_1600_Y_5120 1.319
R_VINT3_3723 MINT4_X_1600_Y_5440 MINT3_X_1600_Y_5440 1.319
R_VINT3_3724 MINT4_X_1600_Y_5760 MINT3_X_1600_Y_5760 1.319
R_VINT3_3725 MINT4_X_1600_Y_6080 MINT3_X_1600_Y_6080 1.319
R_VINT3_3726 MINT4_X_1600_Y_6400 MINT3_X_1600_Y_6400 1.319
R_VINT3_3727 MINT4_X_1600_Y_6720 MINT3_X_1600_Y_6720 1.319
R_VINT3_3728 MINT4_X_1600_Y_7040 MINT3_X_1600_Y_7040 1.319
R_VINT3_3729 MINT4_X_1600_Y_7360 MINT3_X_1600_Y_7360 1.319
R_VINT3_3730 MINT4_X_1600_Y_7680 MINT3_X_1600_Y_7680 1.319
R_VINT3_3731 MINT4_X_1600_Y_8000 MINT3_X_1600_Y_8000 1.319
R_VINT3_3732 MINT4_X_1600_Y_8320 MINT3_X_1600_Y_8320 1.319
R_VINT3_3733 MINT4_X_1600_Y_8640 MINT3_X_1600_Y_8640 1.319
R_VINT3_3734 MINT4_X_1600_Y_8960 MINT3_X_1600_Y_8960 1.319
R_VINT3_3735 MINT4_X_1600_Y_9280 MINT3_X_1600_Y_9280 1.319
R_VINT3_3736 MINT4_X_1600_Y_9600 MINT3_X_1600_Y_9600 1.319
R_VINT3_3737 MINT4_X_1600_Y_9920 MINT3_X_1600_Y_9920 1.319
R_VINT3_3738 MINT4_X_1920_Y_0 MINT3_X_1920_Y_0 1.319
R_VINT3_3739 MINT4_X_1920_Y_320 MINT3_X_1920_Y_320 1.319
R_VINT3_3740 MINT4_X_1920_Y_640 MINT3_X_1920_Y_640 1.319
R_VINT3_3741 MINT4_X_1920_Y_960 MINT3_X_1920_Y_960 1.319
R_VINT3_3742 MINT4_X_1920_Y_1280 MINT3_X_1920_Y_1280 1.319
R_VINT3_3743 MINT4_X_1920_Y_1600 MINT3_X_1920_Y_1600 1.319
R_VINT3_3744 MINT4_X_1920_Y_1920 MINT3_X_1920_Y_1920 1.319
R_VINT3_3745 MINT4_X_1920_Y_2240 MINT3_X_1920_Y_2240 1.319
R_VINT3_3746 MINT4_X_1920_Y_2560 MINT3_X_1920_Y_2560 1.319
R_VINT3_3747 MINT4_X_1920_Y_2880 MINT3_X_1920_Y_2880 1.319
R_VINT3_3748 MINT4_X_1920_Y_3200 MINT3_X_1920_Y_3200 1.319
R_VINT3_3749 MINT4_X_1920_Y_3520 MINT3_X_1920_Y_3520 1.319
R_VINT3_3750 MINT4_X_1920_Y_3840 MINT3_X_1920_Y_3840 1.319
R_VINT3_3751 MINT4_X_1920_Y_4160 MINT3_X_1920_Y_4160 1.319
R_VINT3_3752 MINT4_X_1920_Y_4480 MINT3_X_1920_Y_4480 1.319
R_VINT3_3753 MINT4_X_1920_Y_4800 MINT3_X_1920_Y_4800 1.319
R_VINT3_3754 MINT4_X_1920_Y_5120 MINT3_X_1920_Y_5120 1.319
R_VINT3_3755 MINT4_X_1920_Y_5440 MINT3_X_1920_Y_5440 1.319
R_VINT3_3756 MINT4_X_1920_Y_5760 MINT3_X_1920_Y_5760 1.319
R_VINT3_3757 MINT4_X_1920_Y_6080 MINT3_X_1920_Y_6080 1.319
R_VINT3_3758 MINT4_X_1920_Y_6400 MINT3_X_1920_Y_6400 1.319
R_VINT3_3759 MINT4_X_1920_Y_6720 MINT3_X_1920_Y_6720 1.319
R_VINT3_3760 MINT4_X_1920_Y_7040 MINT3_X_1920_Y_7040 1.319
R_VINT3_3761 MINT4_X_1920_Y_7360 MINT3_X_1920_Y_7360 1.319
R_VINT3_3762 MINT4_X_1920_Y_7680 MINT3_X_1920_Y_7680 1.319
R_VINT3_3763 MINT4_X_1920_Y_8000 MINT3_X_1920_Y_8000 1.319
R_VINT3_3764 MINT4_X_1920_Y_8320 MINT3_X_1920_Y_8320 1.319
R_VINT3_3765 MINT4_X_1920_Y_8640 MINT3_X_1920_Y_8640 1.319
R_VINT3_3766 MINT4_X_1920_Y_8960 MINT3_X_1920_Y_8960 1.319
R_VINT3_3767 MINT4_X_1920_Y_9280 MINT3_X_1920_Y_9280 1.319
R_VINT3_3768 MINT4_X_1920_Y_9600 MINT3_X_1920_Y_9600 1.319
R_VINT3_3769 MINT4_X_1920_Y_9920 MINT3_X_1920_Y_9920 1.319
R_VINT3_3770 MINT4_X_2240_Y_0 MINT3_X_2240_Y_0 1.319
R_VINT3_3771 MINT4_X_2240_Y_320 MINT3_X_2240_Y_320 1.319
R_VINT3_3772 MINT4_X_2240_Y_640 MINT3_X_2240_Y_640 1.319
R_VINT3_3773 MINT4_X_2240_Y_960 MINT3_X_2240_Y_960 1.319
R_VINT3_3774 MINT4_X_2240_Y_1280 MINT3_X_2240_Y_1280 1.319
R_VINT3_3775 MINT4_X_2240_Y_1600 MINT3_X_2240_Y_1600 1.319
R_VINT3_3776 MINT4_X_2240_Y_1920 MINT3_X_2240_Y_1920 1.319
R_VINT3_3777 MINT4_X_2240_Y_2240 MINT3_X_2240_Y_2240 1.319
R_VINT3_3778 MINT4_X_2240_Y_2560 MINT3_X_2240_Y_2560 1.319
R_VINT3_3779 MINT4_X_2240_Y_2880 MINT3_X_2240_Y_2880 1.319
R_VINT3_3780 MINT4_X_2240_Y_3200 MINT3_X_2240_Y_3200 1.319
R_VINT3_3781 MINT4_X_2240_Y_3520 MINT3_X_2240_Y_3520 1.319
R_VINT3_3782 MINT4_X_2240_Y_3840 MINT3_X_2240_Y_3840 1.319
R_VINT3_3783 MINT4_X_2240_Y_4160 MINT3_X_2240_Y_4160 1.319
R_VINT3_3784 MINT4_X_2240_Y_4480 MINT3_X_2240_Y_4480 1.319
R_VINT3_3785 MINT4_X_2240_Y_4800 MINT3_X_2240_Y_4800 1.319
R_VINT3_3786 MINT4_X_2240_Y_5120 MINT3_X_2240_Y_5120 1.319
R_VINT3_3787 MINT4_X_2240_Y_5440 MINT3_X_2240_Y_5440 1.319
R_VINT3_3788 MINT4_X_2240_Y_5760 MINT3_X_2240_Y_5760 1.319
R_VINT3_3789 MINT4_X_2240_Y_6080 MINT3_X_2240_Y_6080 1.319
R_VINT3_3790 MINT4_X_2240_Y_6400 MINT3_X_2240_Y_6400 1.319
R_VINT3_3791 MINT4_X_2240_Y_6720 MINT3_X_2240_Y_6720 1.319
R_VINT3_3792 MINT4_X_2240_Y_7040 MINT3_X_2240_Y_7040 1.319
R_VINT3_3793 MINT4_X_2240_Y_7360 MINT3_X_2240_Y_7360 1.319
R_VINT3_3794 MINT4_X_2240_Y_7680 MINT3_X_2240_Y_7680 1.319
R_VINT3_3795 MINT4_X_2240_Y_8000 MINT3_X_2240_Y_8000 1.319
R_VINT3_3796 MINT4_X_2240_Y_8320 MINT3_X_2240_Y_8320 1.319
R_VINT3_3797 MINT4_X_2240_Y_8640 MINT3_X_2240_Y_8640 1.319
R_VINT3_3798 MINT4_X_2240_Y_8960 MINT3_X_2240_Y_8960 1.319
R_VINT3_3799 MINT4_X_2240_Y_9280 MINT3_X_2240_Y_9280 1.319
R_VINT3_3800 MINT4_X_2240_Y_9600 MINT3_X_2240_Y_9600 1.319
R_VINT3_3801 MINT4_X_2240_Y_9920 MINT3_X_2240_Y_9920 1.319
R_VINT3_3802 MINT4_X_2560_Y_0 MINT3_X_2560_Y_0 1.319
R_VINT3_3803 MINT4_X_2560_Y_320 MINT3_X_2560_Y_320 1.319
R_VINT3_3804 MINT4_X_2560_Y_640 MINT3_X_2560_Y_640 1.319
R_VINT3_3805 MINT4_X_2560_Y_960 MINT3_X_2560_Y_960 1.319
R_VINT3_3806 MINT4_X_2560_Y_1280 MINT3_X_2560_Y_1280 1.319
R_VINT3_3807 MINT4_X_2560_Y_1600 MINT3_X_2560_Y_1600 1.319
R_VINT3_3808 MINT4_X_2560_Y_1920 MINT3_X_2560_Y_1920 1.319
R_VINT3_3809 MINT4_X_2560_Y_2240 MINT3_X_2560_Y_2240 1.319
R_VINT3_3810 MINT4_X_2560_Y_2560 MINT3_X_2560_Y_2560 1.319
R_VINT3_3811 MINT4_X_2560_Y_2880 MINT3_X_2560_Y_2880 1.319
R_VINT3_3812 MINT4_X_2560_Y_3200 MINT3_X_2560_Y_3200 1.319
R_VINT3_3813 MINT4_X_2560_Y_3520 MINT3_X_2560_Y_3520 1.319
R_VINT3_3814 MINT4_X_2560_Y_3840 MINT3_X_2560_Y_3840 1.319
R_VINT3_3815 MINT4_X_2560_Y_4160 MINT3_X_2560_Y_4160 1.319
R_VINT3_3816 MINT4_X_2560_Y_4480 MINT3_X_2560_Y_4480 1.319
R_VINT3_3817 MINT4_X_2560_Y_4800 MINT3_X_2560_Y_4800 1.319
R_VINT3_3818 MINT4_X_2560_Y_5120 MINT3_X_2560_Y_5120 1.319
R_VINT3_3819 MINT4_X_2560_Y_5440 MINT3_X_2560_Y_5440 1.319
R_VINT3_3820 MINT4_X_2560_Y_5760 MINT3_X_2560_Y_5760 1.319
R_VINT3_3821 MINT4_X_2560_Y_6080 MINT3_X_2560_Y_6080 1.319
R_VINT3_3822 MINT4_X_2560_Y_6400 MINT3_X_2560_Y_6400 1.319
R_VINT3_3823 MINT4_X_2560_Y_6720 MINT3_X_2560_Y_6720 1.319
R_VINT3_3824 MINT4_X_2560_Y_7040 MINT3_X_2560_Y_7040 1.319
R_VINT3_3825 MINT4_X_2560_Y_7360 MINT3_X_2560_Y_7360 1.319
R_VINT3_3826 MINT4_X_2560_Y_7680 MINT3_X_2560_Y_7680 1.319
R_VINT3_3827 MINT4_X_2560_Y_8000 MINT3_X_2560_Y_8000 1.319
R_VINT3_3828 MINT4_X_2560_Y_8320 MINT3_X_2560_Y_8320 1.319
R_VINT3_3829 MINT4_X_2560_Y_8640 MINT3_X_2560_Y_8640 1.319
R_VINT3_3830 MINT4_X_2560_Y_8960 MINT3_X_2560_Y_8960 1.319
R_VINT3_3831 MINT4_X_2560_Y_9280 MINT3_X_2560_Y_9280 1.319
R_VINT3_3832 MINT4_X_2560_Y_9600 MINT3_X_2560_Y_9600 1.319
R_VINT3_3833 MINT4_X_2560_Y_9920 MINT3_X_2560_Y_9920 1.319
R_VINT3_3834 MINT4_X_2880_Y_0 MINT3_X_2880_Y_0 1.319
R_VINT3_3835 MINT4_X_2880_Y_320 MINT3_X_2880_Y_320 1.319
R_VINT3_3836 MINT4_X_2880_Y_640 MINT3_X_2880_Y_640 1.319
R_VINT3_3837 MINT4_X_2880_Y_960 MINT3_X_2880_Y_960 1.319
R_VINT3_3838 MINT4_X_2880_Y_1280 MINT3_X_2880_Y_1280 1.319
R_VINT3_3839 MINT4_X_2880_Y_1600 MINT3_X_2880_Y_1600 1.319
R_VINT3_3840 MINT4_X_2880_Y_1920 MINT3_X_2880_Y_1920 1.319
R_VINT3_3841 MINT4_X_2880_Y_2240 MINT3_X_2880_Y_2240 1.319
R_VINT3_3842 MINT4_X_2880_Y_2560 MINT3_X_2880_Y_2560 1.319
R_VINT3_3843 MINT4_X_2880_Y_2880 MINT3_X_2880_Y_2880 1.319
R_VINT3_3844 MINT4_X_2880_Y_3200 MINT3_X_2880_Y_3200 1.319
R_VINT3_3845 MINT4_X_2880_Y_3520 MINT3_X_2880_Y_3520 1.319
R_VINT3_3846 MINT4_X_2880_Y_3840 MINT3_X_2880_Y_3840 1.319
R_VINT3_3847 MINT4_X_2880_Y_4160 MINT3_X_2880_Y_4160 1.319
R_VINT3_3848 MINT4_X_2880_Y_4480 MINT3_X_2880_Y_4480 1.319
R_VINT3_3849 MINT4_X_2880_Y_4800 MINT3_X_2880_Y_4800 1.319
R_VINT3_3850 MINT4_X_2880_Y_5120 MINT3_X_2880_Y_5120 1.319
R_VINT3_3851 MINT4_X_2880_Y_5440 MINT3_X_2880_Y_5440 1.319
R_VINT3_3852 MINT4_X_2880_Y_5760 MINT3_X_2880_Y_5760 1.319
R_VINT3_3853 MINT4_X_2880_Y_6080 MINT3_X_2880_Y_6080 1.319
R_VINT3_3854 MINT4_X_2880_Y_6400 MINT3_X_2880_Y_6400 1.319
R_VINT3_3855 MINT4_X_2880_Y_6720 MINT3_X_2880_Y_6720 1.319
R_VINT3_3856 MINT4_X_2880_Y_7040 MINT3_X_2880_Y_7040 1.319
R_VINT3_3857 MINT4_X_2880_Y_7360 MINT3_X_2880_Y_7360 1.319
R_VINT3_3858 MINT4_X_2880_Y_7680 MINT3_X_2880_Y_7680 1.319
R_VINT3_3859 MINT4_X_2880_Y_8000 MINT3_X_2880_Y_8000 1.319
R_VINT3_3860 MINT4_X_2880_Y_8320 MINT3_X_2880_Y_8320 1.319
R_VINT3_3861 MINT4_X_2880_Y_8640 MINT3_X_2880_Y_8640 1.319
R_VINT3_3862 MINT4_X_2880_Y_8960 MINT3_X_2880_Y_8960 1.319
R_VINT3_3863 MINT4_X_2880_Y_9280 MINT3_X_2880_Y_9280 1.319
R_VINT3_3864 MINT4_X_2880_Y_9600 MINT3_X_2880_Y_9600 1.319
R_VINT3_3865 MINT4_X_2880_Y_9920 MINT3_X_2880_Y_9920 1.319
R_VINT3_3866 MINT4_X_3200_Y_0 MINT3_X_3200_Y_0 1.319
R_VINT3_3867 MINT4_X_3200_Y_320 MINT3_X_3200_Y_320 1.319
R_VINT3_3868 MINT4_X_3200_Y_640 MINT3_X_3200_Y_640 1.319
R_VINT3_3869 MINT4_X_3200_Y_960 MINT3_X_3200_Y_960 1.319
R_VINT3_3870 MINT4_X_3200_Y_1280 MINT3_X_3200_Y_1280 1.319
R_VINT3_3871 MINT4_X_3200_Y_1600 MINT3_X_3200_Y_1600 1.319
R_VINT3_3872 MINT4_X_3200_Y_1920 MINT3_X_3200_Y_1920 1.319
R_VINT3_3873 MINT4_X_3200_Y_2240 MINT3_X_3200_Y_2240 1.319
R_VINT3_3874 MINT4_X_3200_Y_2560 MINT3_X_3200_Y_2560 1.319
R_VINT3_3875 MINT4_X_3200_Y_2880 MINT3_X_3200_Y_2880 1.319
R_VINT3_3876 MINT4_X_3200_Y_3200 MINT3_X_3200_Y_3200 1.319
R_VINT3_3877 MINT4_X_3200_Y_3520 MINT3_X_3200_Y_3520 1.319
R_VINT3_3878 MINT4_X_3200_Y_3840 MINT3_X_3200_Y_3840 1.319
R_VINT3_3879 MINT4_X_3200_Y_4160 MINT3_X_3200_Y_4160 1.319
R_VINT3_3880 MINT4_X_3200_Y_4480 MINT3_X_3200_Y_4480 1.319
R_VINT3_3881 MINT4_X_3200_Y_4800 MINT3_X_3200_Y_4800 1.319
R_VINT3_3882 MINT4_X_3200_Y_5120 MINT3_X_3200_Y_5120 1.319
R_VINT3_3883 MINT4_X_3200_Y_5440 MINT3_X_3200_Y_5440 1.319
R_VINT3_3884 MINT4_X_3200_Y_5760 MINT3_X_3200_Y_5760 1.319
R_VINT3_3885 MINT4_X_3200_Y_6080 MINT3_X_3200_Y_6080 1.319
R_VINT3_3886 MINT4_X_3200_Y_6400 MINT3_X_3200_Y_6400 1.319
R_VINT3_3887 MINT4_X_3200_Y_6720 MINT3_X_3200_Y_6720 1.319
R_VINT3_3888 MINT4_X_3200_Y_7040 MINT3_X_3200_Y_7040 1.319
R_VINT3_3889 MINT4_X_3200_Y_7360 MINT3_X_3200_Y_7360 1.319
R_VINT3_3890 MINT4_X_3200_Y_7680 MINT3_X_3200_Y_7680 1.319
R_VINT3_3891 MINT4_X_3200_Y_8000 MINT3_X_3200_Y_8000 1.319
R_VINT3_3892 MINT4_X_3200_Y_8320 MINT3_X_3200_Y_8320 1.319
R_VINT3_3893 MINT4_X_3200_Y_8640 MINT3_X_3200_Y_8640 1.319
R_VINT3_3894 MINT4_X_3200_Y_8960 MINT3_X_3200_Y_8960 1.319
R_VINT3_3895 MINT4_X_3200_Y_9280 MINT3_X_3200_Y_9280 1.319
R_VINT3_3896 MINT4_X_3200_Y_9600 MINT3_X_3200_Y_9600 1.319
R_VINT3_3897 MINT4_X_3200_Y_9920 MINT3_X_3200_Y_9920 1.319
R_VINT3_3898 MINT4_X_3520_Y_0 MINT3_X_3520_Y_0 1.319
R_VINT3_3899 MINT4_X_3520_Y_320 MINT3_X_3520_Y_320 1.319
R_VINT3_3900 MINT4_X_3520_Y_640 MINT3_X_3520_Y_640 1.319
R_VINT3_3901 MINT4_X_3520_Y_960 MINT3_X_3520_Y_960 1.319
R_VINT3_3902 MINT4_X_3520_Y_1280 MINT3_X_3520_Y_1280 1.319
R_VINT3_3903 MINT4_X_3520_Y_1600 MINT3_X_3520_Y_1600 1.319
R_VINT3_3904 MINT4_X_3520_Y_1920 MINT3_X_3520_Y_1920 1.319
R_VINT3_3905 MINT4_X_3520_Y_2240 MINT3_X_3520_Y_2240 1.319
R_VINT3_3906 MINT4_X_3520_Y_2560 MINT3_X_3520_Y_2560 1.319
R_VINT3_3907 MINT4_X_3520_Y_2880 MINT3_X_3520_Y_2880 1.319
R_VINT3_3908 MINT4_X_3520_Y_3200 MINT3_X_3520_Y_3200 1.319
R_VINT3_3909 MINT4_X_3520_Y_3520 MINT3_X_3520_Y_3520 1.319
R_VINT3_3910 MINT4_X_3520_Y_3840 MINT3_X_3520_Y_3840 1.319
R_VINT3_3911 MINT4_X_3520_Y_4160 MINT3_X_3520_Y_4160 1.319
R_VINT3_3912 MINT4_X_3520_Y_4480 MINT3_X_3520_Y_4480 1.319
R_VINT3_3913 MINT4_X_3520_Y_4800 MINT3_X_3520_Y_4800 1.319
R_VINT3_3914 MINT4_X_3520_Y_5120 MINT3_X_3520_Y_5120 1.319
R_VINT3_3915 MINT4_X_3520_Y_5440 MINT3_X_3520_Y_5440 1.319
R_VINT3_3916 MINT4_X_3520_Y_5760 MINT3_X_3520_Y_5760 1.319
R_VINT3_3917 MINT4_X_3520_Y_6080 MINT3_X_3520_Y_6080 1.319
R_VINT3_3918 MINT4_X_3520_Y_6400 MINT3_X_3520_Y_6400 1.319
R_VINT3_3919 MINT4_X_3520_Y_6720 MINT3_X_3520_Y_6720 1.319
R_VINT3_3920 MINT4_X_3520_Y_7040 MINT3_X_3520_Y_7040 1.319
R_VINT3_3921 MINT4_X_3520_Y_7360 MINT3_X_3520_Y_7360 1.319
R_VINT3_3922 MINT4_X_3520_Y_7680 MINT3_X_3520_Y_7680 1.319
R_VINT3_3923 MINT4_X_3520_Y_8000 MINT3_X_3520_Y_8000 1.319
R_VINT3_3924 MINT4_X_3520_Y_8320 MINT3_X_3520_Y_8320 1.319
R_VINT3_3925 MINT4_X_3520_Y_8640 MINT3_X_3520_Y_8640 1.319
R_VINT3_3926 MINT4_X_3520_Y_8960 MINT3_X_3520_Y_8960 1.319
R_VINT3_3927 MINT4_X_3520_Y_9280 MINT3_X_3520_Y_9280 1.319
R_VINT3_3928 MINT4_X_3520_Y_9600 MINT3_X_3520_Y_9600 1.319
R_VINT3_3929 MINT4_X_3520_Y_9920 MINT3_X_3520_Y_9920 1.319
R_VINT3_3930 MINT4_X_3840_Y_0 MINT3_X_3840_Y_0 1.319
R_VINT3_3931 MINT4_X_3840_Y_320 MINT3_X_3840_Y_320 1.319
R_VINT3_3932 MINT4_X_3840_Y_640 MINT3_X_3840_Y_640 1.319
R_VINT3_3933 MINT4_X_3840_Y_960 MINT3_X_3840_Y_960 1.319
R_VINT3_3934 MINT4_X_3840_Y_1280 MINT3_X_3840_Y_1280 1.319
R_VINT3_3935 MINT4_X_3840_Y_1600 MINT3_X_3840_Y_1600 1.319
R_VINT3_3936 MINT4_X_3840_Y_1920 MINT3_X_3840_Y_1920 1.319
R_VINT3_3937 MINT4_X_3840_Y_2240 MINT3_X_3840_Y_2240 1.319
R_VINT3_3938 MINT4_X_3840_Y_2560 MINT3_X_3840_Y_2560 1.319
R_VINT3_3939 MINT4_X_3840_Y_2880 MINT3_X_3840_Y_2880 1.319
R_VINT3_3940 MINT4_X_3840_Y_3200 MINT3_X_3840_Y_3200 1.319
R_VINT3_3941 MINT4_X_3840_Y_3520 MINT3_X_3840_Y_3520 1.319
R_VINT3_3942 MINT4_X_3840_Y_3840 MINT3_X_3840_Y_3840 1.319
R_VINT3_3943 MINT4_X_3840_Y_4160 MINT3_X_3840_Y_4160 1.319
R_VINT3_3944 MINT4_X_3840_Y_4480 MINT3_X_3840_Y_4480 1.319
R_VINT3_3945 MINT4_X_3840_Y_4800 MINT3_X_3840_Y_4800 1.319
R_VINT3_3946 MINT4_X_3840_Y_5120 MINT3_X_3840_Y_5120 1.319
R_VINT3_3947 MINT4_X_3840_Y_5440 MINT3_X_3840_Y_5440 1.319
R_VINT3_3948 MINT4_X_3840_Y_5760 MINT3_X_3840_Y_5760 1.319
R_VINT3_3949 MINT4_X_3840_Y_6080 MINT3_X_3840_Y_6080 1.319
R_VINT3_3950 MINT4_X_3840_Y_6400 MINT3_X_3840_Y_6400 1.319
R_VINT3_3951 MINT4_X_3840_Y_6720 MINT3_X_3840_Y_6720 1.319
R_VINT3_3952 MINT4_X_3840_Y_7040 MINT3_X_3840_Y_7040 1.319
R_VINT3_3953 MINT4_X_3840_Y_7360 MINT3_X_3840_Y_7360 1.319
R_VINT3_3954 MINT4_X_3840_Y_7680 MINT3_X_3840_Y_7680 1.319
R_VINT3_3955 MINT4_X_3840_Y_8000 MINT3_X_3840_Y_8000 1.319
R_VINT3_3956 MINT4_X_3840_Y_8320 MINT3_X_3840_Y_8320 1.319
R_VINT3_3957 MINT4_X_3840_Y_8640 MINT3_X_3840_Y_8640 1.319
R_VINT3_3958 MINT4_X_3840_Y_8960 MINT3_X_3840_Y_8960 1.319
R_VINT3_3959 MINT4_X_3840_Y_9280 MINT3_X_3840_Y_9280 1.319
R_VINT3_3960 MINT4_X_3840_Y_9600 MINT3_X_3840_Y_9600 1.319
R_VINT3_3961 MINT4_X_3840_Y_9920 MINT3_X_3840_Y_9920 1.319
R_VINT3_3962 MINT4_X_4160_Y_0 MINT3_X_4160_Y_0 1.319
R_VINT3_3963 MINT4_X_4160_Y_320 MINT3_X_4160_Y_320 1.319
R_VINT3_3964 MINT4_X_4160_Y_640 MINT3_X_4160_Y_640 1.319
R_VINT3_3965 MINT4_X_4160_Y_960 MINT3_X_4160_Y_960 1.319
R_VINT3_3966 MINT4_X_4160_Y_1280 MINT3_X_4160_Y_1280 1.319
R_VINT3_3967 MINT4_X_4160_Y_1600 MINT3_X_4160_Y_1600 1.319
R_VINT3_3968 MINT4_X_4160_Y_1920 MINT3_X_4160_Y_1920 1.319
R_VINT3_3969 MINT4_X_4160_Y_2240 MINT3_X_4160_Y_2240 1.319
R_VINT3_3970 MINT4_X_4160_Y_2560 MINT3_X_4160_Y_2560 1.319
R_VINT3_3971 MINT4_X_4160_Y_2880 MINT3_X_4160_Y_2880 1.319
R_VINT3_3972 MINT4_X_4160_Y_3200 MINT3_X_4160_Y_3200 1.319
R_VINT3_3973 MINT4_X_4160_Y_3520 MINT3_X_4160_Y_3520 1.319
R_VINT3_3974 MINT4_X_4160_Y_3840 MINT3_X_4160_Y_3840 1.319
R_VINT3_3975 MINT4_X_4160_Y_4160 MINT3_X_4160_Y_4160 1.319
R_VINT3_3976 MINT4_X_4160_Y_4480 MINT3_X_4160_Y_4480 1.319
R_VINT3_3977 MINT4_X_4160_Y_4800 MINT3_X_4160_Y_4800 1.319
R_VINT3_3978 MINT4_X_4160_Y_5120 MINT3_X_4160_Y_5120 1.319
R_VINT3_3979 MINT4_X_4160_Y_5440 MINT3_X_4160_Y_5440 1.319
R_VINT3_3980 MINT4_X_4160_Y_5760 MINT3_X_4160_Y_5760 1.319
R_VINT3_3981 MINT4_X_4160_Y_6080 MINT3_X_4160_Y_6080 1.319
R_VINT3_3982 MINT4_X_4160_Y_6400 MINT3_X_4160_Y_6400 1.319
R_VINT3_3983 MINT4_X_4160_Y_6720 MINT3_X_4160_Y_6720 1.319
R_VINT3_3984 MINT4_X_4160_Y_7040 MINT3_X_4160_Y_7040 1.319
R_VINT3_3985 MINT4_X_4160_Y_7360 MINT3_X_4160_Y_7360 1.319
R_VINT3_3986 MINT4_X_4160_Y_7680 MINT3_X_4160_Y_7680 1.319
R_VINT3_3987 MINT4_X_4160_Y_8000 MINT3_X_4160_Y_8000 1.319
R_VINT3_3988 MINT4_X_4160_Y_8320 MINT3_X_4160_Y_8320 1.319
R_VINT3_3989 MINT4_X_4160_Y_8640 MINT3_X_4160_Y_8640 1.319
R_VINT3_3990 MINT4_X_4160_Y_8960 MINT3_X_4160_Y_8960 1.319
R_VINT3_3991 MINT4_X_4160_Y_9280 MINT3_X_4160_Y_9280 1.319
R_VINT3_3992 MINT4_X_4160_Y_9600 MINT3_X_4160_Y_9600 1.319
R_VINT3_3993 MINT4_X_4160_Y_9920 MINT3_X_4160_Y_9920 1.319
R_VINT3_3994 MINT4_X_4480_Y_0 MINT3_X_4480_Y_0 1.319
R_VINT3_3995 MINT4_X_4480_Y_320 MINT3_X_4480_Y_320 1.319
R_VINT3_3996 MINT4_X_4480_Y_640 MINT3_X_4480_Y_640 1.319
R_VINT3_3997 MINT4_X_4480_Y_960 MINT3_X_4480_Y_960 1.319
R_VINT3_3998 MINT4_X_4480_Y_1280 MINT3_X_4480_Y_1280 1.319
R_VINT3_3999 MINT4_X_4480_Y_1600 MINT3_X_4480_Y_1600 1.319
R_VINT3_4000 MINT4_X_4480_Y_1920 MINT3_X_4480_Y_1920 1.319
R_VINT3_4001 MINT4_X_4480_Y_2240 MINT3_X_4480_Y_2240 1.319
R_VINT3_4002 MINT4_X_4480_Y_2560 MINT3_X_4480_Y_2560 1.319
R_VINT3_4003 MINT4_X_4480_Y_2880 MINT3_X_4480_Y_2880 1.319
R_VINT3_4004 MINT4_X_4480_Y_3200 MINT3_X_4480_Y_3200 1.319
R_VINT3_4005 MINT4_X_4480_Y_3520 MINT3_X_4480_Y_3520 1.319
R_VINT3_4006 MINT4_X_4480_Y_3840 MINT3_X_4480_Y_3840 1.319
R_VINT3_4007 MINT4_X_4480_Y_4160 MINT3_X_4480_Y_4160 1.319
R_VINT3_4008 MINT4_X_4480_Y_4480 MINT3_X_4480_Y_4480 1.319
R_VINT3_4009 MINT4_X_4480_Y_4800 MINT3_X_4480_Y_4800 1.319
R_VINT3_4010 MINT4_X_4480_Y_5120 MINT3_X_4480_Y_5120 1.319
R_VINT3_4011 MINT4_X_4480_Y_5440 MINT3_X_4480_Y_5440 1.319
R_VINT3_4012 MINT4_X_4480_Y_5760 MINT3_X_4480_Y_5760 1.319
R_VINT3_4013 MINT4_X_4480_Y_6080 MINT3_X_4480_Y_6080 1.319
R_VINT3_4014 MINT4_X_4480_Y_6400 MINT3_X_4480_Y_6400 1.319
R_VINT3_4015 MINT4_X_4480_Y_6720 MINT3_X_4480_Y_6720 1.319
R_VINT3_4016 MINT4_X_4480_Y_7040 MINT3_X_4480_Y_7040 1.319
R_VINT3_4017 MINT4_X_4480_Y_7360 MINT3_X_4480_Y_7360 1.319
R_VINT3_4018 MINT4_X_4480_Y_7680 MINT3_X_4480_Y_7680 1.319
R_VINT3_4019 MINT4_X_4480_Y_8000 MINT3_X_4480_Y_8000 1.319
R_VINT3_4020 MINT4_X_4480_Y_8320 MINT3_X_4480_Y_8320 1.319
R_VINT3_4021 MINT4_X_4480_Y_8640 MINT3_X_4480_Y_8640 1.319
R_VINT3_4022 MINT4_X_4480_Y_8960 MINT3_X_4480_Y_8960 1.319
R_VINT3_4023 MINT4_X_4480_Y_9280 MINT3_X_4480_Y_9280 1.319
R_VINT3_4024 MINT4_X_4480_Y_9600 MINT3_X_4480_Y_9600 1.319
R_VINT3_4025 MINT4_X_4480_Y_9920 MINT3_X_4480_Y_9920 1.319
R_VINT3_4026 MINT4_X_4800_Y_0 MINT3_X_4800_Y_0 1.319
R_VINT3_4027 MINT4_X_4800_Y_320 MINT3_X_4800_Y_320 1.319
R_VINT3_4028 MINT4_X_4800_Y_640 MINT3_X_4800_Y_640 1.319
R_VINT3_4029 MINT4_X_4800_Y_960 MINT3_X_4800_Y_960 1.319
R_VINT3_4030 MINT4_X_4800_Y_1280 MINT3_X_4800_Y_1280 1.319
R_VINT3_4031 MINT4_X_4800_Y_1600 MINT3_X_4800_Y_1600 1.319
R_VINT3_4032 MINT4_X_4800_Y_1920 MINT3_X_4800_Y_1920 1.319
R_VINT3_4033 MINT4_X_4800_Y_2240 MINT3_X_4800_Y_2240 1.319
R_VINT3_4034 MINT4_X_4800_Y_2560 MINT3_X_4800_Y_2560 1.319
R_VINT3_4035 MINT4_X_4800_Y_2880 MINT3_X_4800_Y_2880 1.319
R_VINT3_4036 MINT4_X_4800_Y_3200 MINT3_X_4800_Y_3200 1.319
R_VINT3_4037 MINT4_X_4800_Y_3520 MINT3_X_4800_Y_3520 1.319
R_VINT3_4038 MINT4_X_4800_Y_3840 MINT3_X_4800_Y_3840 1.319
R_VINT3_4039 MINT4_X_4800_Y_4160 MINT3_X_4800_Y_4160 1.319
R_VINT3_4040 MINT4_X_4800_Y_4480 MINT3_X_4800_Y_4480 1.319
R_VINT3_4041 MINT4_X_4800_Y_4800 MINT3_X_4800_Y_4800 1.319
R_VINT3_4042 MINT4_X_4800_Y_5120 MINT3_X_4800_Y_5120 1.319
R_VINT3_4043 MINT4_X_4800_Y_5440 MINT3_X_4800_Y_5440 1.319
R_VINT3_4044 MINT4_X_4800_Y_5760 MINT3_X_4800_Y_5760 1.319
R_VINT3_4045 MINT4_X_4800_Y_6080 MINT3_X_4800_Y_6080 1.319
R_VINT3_4046 MINT4_X_4800_Y_6400 MINT3_X_4800_Y_6400 1.319
R_VINT3_4047 MINT4_X_4800_Y_6720 MINT3_X_4800_Y_6720 1.319
R_VINT3_4048 MINT4_X_4800_Y_7040 MINT3_X_4800_Y_7040 1.319
R_VINT3_4049 MINT4_X_4800_Y_7360 MINT3_X_4800_Y_7360 1.319
R_VINT3_4050 MINT4_X_4800_Y_7680 MINT3_X_4800_Y_7680 1.319
R_VINT3_4051 MINT4_X_4800_Y_8000 MINT3_X_4800_Y_8000 1.319
R_VINT3_4052 MINT4_X_4800_Y_8320 MINT3_X_4800_Y_8320 1.319
R_VINT3_4053 MINT4_X_4800_Y_8640 MINT3_X_4800_Y_8640 1.319
R_VINT3_4054 MINT4_X_4800_Y_8960 MINT3_X_4800_Y_8960 1.319
R_VINT3_4055 MINT4_X_4800_Y_9280 MINT3_X_4800_Y_9280 1.319
R_VINT3_4056 MINT4_X_4800_Y_9600 MINT3_X_4800_Y_9600 1.319
R_VINT3_4057 MINT4_X_4800_Y_9920 MINT3_X_4800_Y_9920 1.319
R_VINT3_4058 MINT4_X_5120_Y_0 MINT3_X_5120_Y_0 1.319
R_VINT3_4059 MINT4_X_5120_Y_320 MINT3_X_5120_Y_320 1.319
R_VINT3_4060 MINT4_X_5120_Y_640 MINT3_X_5120_Y_640 1.319
R_VINT3_4061 MINT4_X_5120_Y_960 MINT3_X_5120_Y_960 1.319
R_VINT3_4062 MINT4_X_5120_Y_1280 MINT3_X_5120_Y_1280 1.319
R_VINT3_4063 MINT4_X_5120_Y_1600 MINT3_X_5120_Y_1600 1.319
R_VINT3_4064 MINT4_X_5120_Y_1920 MINT3_X_5120_Y_1920 1.319
R_VINT3_4065 MINT4_X_5120_Y_2240 MINT3_X_5120_Y_2240 1.319
R_VINT3_4066 MINT4_X_5120_Y_2560 MINT3_X_5120_Y_2560 1.319
R_VINT3_4067 MINT4_X_5120_Y_2880 MINT3_X_5120_Y_2880 1.319
R_VINT3_4068 MINT4_X_5120_Y_3200 MINT3_X_5120_Y_3200 1.319
R_VINT3_4069 MINT4_X_5120_Y_3520 MINT3_X_5120_Y_3520 1.319
R_VINT3_4070 MINT4_X_5120_Y_3840 MINT3_X_5120_Y_3840 1.319
R_VINT3_4071 MINT4_X_5120_Y_4160 MINT3_X_5120_Y_4160 1.319
R_VINT3_4072 MINT4_X_5120_Y_4480 MINT3_X_5120_Y_4480 1.319
R_VINT3_4073 MINT4_X_5120_Y_4800 MINT3_X_5120_Y_4800 1.319
R_VINT3_4074 MINT4_X_5120_Y_5120 MINT3_X_5120_Y_5120 1.319
R_VINT3_4075 MINT4_X_5120_Y_5440 MINT3_X_5120_Y_5440 1.319
R_VINT3_4076 MINT4_X_5120_Y_5760 MINT3_X_5120_Y_5760 1.319
R_VINT3_4077 MINT4_X_5120_Y_6080 MINT3_X_5120_Y_6080 1.319
R_VINT3_4078 MINT4_X_5120_Y_6400 MINT3_X_5120_Y_6400 1.319
R_VINT3_4079 MINT4_X_5120_Y_6720 MINT3_X_5120_Y_6720 1.319
R_VINT3_4080 MINT4_X_5120_Y_7040 MINT3_X_5120_Y_7040 1.319
R_VINT3_4081 MINT4_X_5120_Y_7360 MINT3_X_5120_Y_7360 1.319
R_VINT3_4082 MINT4_X_5120_Y_7680 MINT3_X_5120_Y_7680 1.319
R_VINT3_4083 MINT4_X_5120_Y_8000 MINT3_X_5120_Y_8000 1.319
R_VINT3_4084 MINT4_X_5120_Y_8320 MINT3_X_5120_Y_8320 1.319
R_VINT3_4085 MINT4_X_5120_Y_8640 MINT3_X_5120_Y_8640 1.319
R_VINT3_4086 MINT4_X_5120_Y_8960 MINT3_X_5120_Y_8960 1.319
R_VINT3_4087 MINT4_X_5120_Y_9280 MINT3_X_5120_Y_9280 1.319
R_VINT3_4088 MINT4_X_5120_Y_9600 MINT3_X_5120_Y_9600 1.319
R_VINT3_4089 MINT4_X_5120_Y_9920 MINT3_X_5120_Y_9920 1.319
R_VINT3_4090 MINT4_X_5440_Y_0 MINT3_X_5440_Y_0 1.319
R_VINT3_4091 MINT4_X_5440_Y_320 MINT3_X_5440_Y_320 1.319
R_VINT3_4092 MINT4_X_5440_Y_640 MINT3_X_5440_Y_640 1.319
R_VINT3_4093 MINT4_X_5440_Y_960 MINT3_X_5440_Y_960 1.319
R_VINT3_4094 MINT4_X_5440_Y_1280 MINT3_X_5440_Y_1280 1.319
R_VINT3_4095 MINT4_X_5440_Y_1600 MINT3_X_5440_Y_1600 1.319
R_VINT3_4096 MINT4_X_5440_Y_1920 MINT3_X_5440_Y_1920 1.319
R_VINT3_4097 MINT4_X_5440_Y_2240 MINT3_X_5440_Y_2240 1.319
R_VINT3_4098 MINT4_X_5440_Y_2560 MINT3_X_5440_Y_2560 1.319
R_VINT3_4099 MINT4_X_5440_Y_2880 MINT3_X_5440_Y_2880 1.319
R_VINT3_4100 MINT4_X_5440_Y_3200 MINT3_X_5440_Y_3200 1.319
R_VINT3_4101 MINT4_X_5440_Y_3520 MINT3_X_5440_Y_3520 1.319
R_VINT3_4102 MINT4_X_5440_Y_3840 MINT3_X_5440_Y_3840 1.319
R_VINT3_4103 MINT4_X_5440_Y_4160 MINT3_X_5440_Y_4160 1.319
R_VINT3_4104 MINT4_X_5440_Y_4480 MINT3_X_5440_Y_4480 1.319
R_VINT3_4105 MINT4_X_5440_Y_4800 MINT3_X_5440_Y_4800 1.319
R_VINT3_4106 MINT4_X_5440_Y_5120 MINT3_X_5440_Y_5120 1.319
R_VINT3_4107 MINT4_X_5440_Y_5440 MINT3_X_5440_Y_5440 1.319
R_VINT3_4108 MINT4_X_5440_Y_5760 MINT3_X_5440_Y_5760 1.319
R_VINT3_4109 MINT4_X_5440_Y_6080 MINT3_X_5440_Y_6080 1.319
R_VINT3_4110 MINT4_X_5440_Y_6400 MINT3_X_5440_Y_6400 1.319
R_VINT3_4111 MINT4_X_5440_Y_6720 MINT3_X_5440_Y_6720 1.319
R_VINT3_4112 MINT4_X_5440_Y_7040 MINT3_X_5440_Y_7040 1.319
R_VINT3_4113 MINT4_X_5440_Y_7360 MINT3_X_5440_Y_7360 1.319
R_VINT3_4114 MINT4_X_5440_Y_7680 MINT3_X_5440_Y_7680 1.319
R_VINT3_4115 MINT4_X_5440_Y_8000 MINT3_X_5440_Y_8000 1.319
R_VINT3_4116 MINT4_X_5440_Y_8320 MINT3_X_5440_Y_8320 1.319
R_VINT3_4117 MINT4_X_5440_Y_8640 MINT3_X_5440_Y_8640 1.319
R_VINT3_4118 MINT4_X_5440_Y_8960 MINT3_X_5440_Y_8960 1.319
R_VINT3_4119 MINT4_X_5440_Y_9280 MINT3_X_5440_Y_9280 1.319
R_VINT3_4120 MINT4_X_5440_Y_9600 MINT3_X_5440_Y_9600 1.319
R_VINT3_4121 MINT4_X_5440_Y_9920 MINT3_X_5440_Y_9920 1.319
R_VINT3_4122 MINT4_X_5760_Y_0 MINT3_X_5760_Y_0 1.319
R_VINT3_4123 MINT4_X_5760_Y_320 MINT3_X_5760_Y_320 1.319
R_VINT3_4124 MINT4_X_5760_Y_640 MINT3_X_5760_Y_640 1.319
R_VINT3_4125 MINT4_X_5760_Y_960 MINT3_X_5760_Y_960 1.319
R_VINT3_4126 MINT4_X_5760_Y_1280 MINT3_X_5760_Y_1280 1.319
R_VINT3_4127 MINT4_X_5760_Y_1600 MINT3_X_5760_Y_1600 1.319
R_VINT3_4128 MINT4_X_5760_Y_1920 MINT3_X_5760_Y_1920 1.319
R_VINT3_4129 MINT4_X_5760_Y_2240 MINT3_X_5760_Y_2240 1.319
R_VINT3_4130 MINT4_X_5760_Y_2560 MINT3_X_5760_Y_2560 1.319
R_VINT3_4131 MINT4_X_5760_Y_2880 MINT3_X_5760_Y_2880 1.319
R_VINT3_4132 MINT4_X_5760_Y_3200 MINT3_X_5760_Y_3200 1.319
R_VINT3_4133 MINT4_X_5760_Y_3520 MINT3_X_5760_Y_3520 1.319
R_VINT3_4134 MINT4_X_5760_Y_3840 MINT3_X_5760_Y_3840 1.319
R_VINT3_4135 MINT4_X_5760_Y_4160 MINT3_X_5760_Y_4160 1.319
R_VINT3_4136 MINT4_X_5760_Y_4480 MINT3_X_5760_Y_4480 1.319
R_VINT3_4137 MINT4_X_5760_Y_4800 MINT3_X_5760_Y_4800 1.319
R_VINT3_4138 MINT4_X_5760_Y_5120 MINT3_X_5760_Y_5120 1.319
R_VINT3_4139 MINT4_X_5760_Y_5440 MINT3_X_5760_Y_5440 1.319
R_VINT3_4140 MINT4_X_5760_Y_5760 MINT3_X_5760_Y_5760 1.319
R_VINT3_4141 MINT4_X_5760_Y_6080 MINT3_X_5760_Y_6080 1.319
R_VINT3_4142 MINT4_X_5760_Y_6400 MINT3_X_5760_Y_6400 1.319
R_VINT3_4143 MINT4_X_5760_Y_6720 MINT3_X_5760_Y_6720 1.319
R_VINT3_4144 MINT4_X_5760_Y_7040 MINT3_X_5760_Y_7040 1.319
R_VINT3_4145 MINT4_X_5760_Y_7360 MINT3_X_5760_Y_7360 1.319
R_VINT3_4146 MINT4_X_5760_Y_7680 MINT3_X_5760_Y_7680 1.319
R_VINT3_4147 MINT4_X_5760_Y_8000 MINT3_X_5760_Y_8000 1.319
R_VINT3_4148 MINT4_X_5760_Y_8320 MINT3_X_5760_Y_8320 1.319
R_VINT3_4149 MINT4_X_5760_Y_8640 MINT3_X_5760_Y_8640 1.319
R_VINT3_4150 MINT4_X_5760_Y_8960 MINT3_X_5760_Y_8960 1.319
R_VINT3_4151 MINT4_X_5760_Y_9280 MINT3_X_5760_Y_9280 1.319
R_VINT3_4152 MINT4_X_5760_Y_9600 MINT3_X_5760_Y_9600 1.319
R_VINT3_4153 MINT4_X_5760_Y_9920 MINT3_X_5760_Y_9920 1.319
R_VINT3_4154 MINT4_X_6080_Y_0 MINT3_X_6080_Y_0 1.319
R_VINT3_4155 MINT4_X_6080_Y_320 MINT3_X_6080_Y_320 1.319
R_VINT3_4156 MINT4_X_6080_Y_640 MINT3_X_6080_Y_640 1.319
R_VINT3_4157 MINT4_X_6080_Y_960 MINT3_X_6080_Y_960 1.319
R_VINT3_4158 MINT4_X_6080_Y_1280 MINT3_X_6080_Y_1280 1.319
R_VINT3_4159 MINT4_X_6080_Y_1600 MINT3_X_6080_Y_1600 1.319
R_VINT3_4160 MINT4_X_6080_Y_1920 MINT3_X_6080_Y_1920 1.319
R_VINT3_4161 MINT4_X_6080_Y_2240 MINT3_X_6080_Y_2240 1.319
R_VINT3_4162 MINT4_X_6080_Y_2560 MINT3_X_6080_Y_2560 1.319
R_VINT3_4163 MINT4_X_6080_Y_2880 MINT3_X_6080_Y_2880 1.319
R_VINT3_4164 MINT4_X_6080_Y_3200 MINT3_X_6080_Y_3200 1.319
R_VINT3_4165 MINT4_X_6080_Y_3520 MINT3_X_6080_Y_3520 1.319
R_VINT3_4166 MINT4_X_6080_Y_3840 MINT3_X_6080_Y_3840 1.319
R_VINT3_4167 MINT4_X_6080_Y_4160 MINT3_X_6080_Y_4160 1.319
R_VINT3_4168 MINT4_X_6080_Y_4480 MINT3_X_6080_Y_4480 1.319
R_VINT3_4169 MINT4_X_6080_Y_4800 MINT3_X_6080_Y_4800 1.319
R_VINT3_4170 MINT4_X_6080_Y_5120 MINT3_X_6080_Y_5120 1.319
R_VINT3_4171 MINT4_X_6080_Y_5440 MINT3_X_6080_Y_5440 1.319
R_VINT3_4172 MINT4_X_6080_Y_5760 MINT3_X_6080_Y_5760 1.319
R_VINT3_4173 MINT4_X_6080_Y_6080 MINT3_X_6080_Y_6080 1.319
R_VINT3_4174 MINT4_X_6080_Y_6400 MINT3_X_6080_Y_6400 1.319
R_VINT3_4175 MINT4_X_6080_Y_6720 MINT3_X_6080_Y_6720 1.319
R_VINT3_4176 MINT4_X_6080_Y_7040 MINT3_X_6080_Y_7040 1.319
R_VINT3_4177 MINT4_X_6080_Y_7360 MINT3_X_6080_Y_7360 1.319
R_VINT3_4178 MINT4_X_6080_Y_7680 MINT3_X_6080_Y_7680 1.319
R_VINT3_4179 MINT4_X_6080_Y_8000 MINT3_X_6080_Y_8000 1.319
R_VINT3_4180 MINT4_X_6080_Y_8320 MINT3_X_6080_Y_8320 1.319
R_VINT3_4181 MINT4_X_6080_Y_8640 MINT3_X_6080_Y_8640 1.319
R_VINT3_4182 MINT4_X_6080_Y_8960 MINT3_X_6080_Y_8960 1.319
R_VINT3_4183 MINT4_X_6080_Y_9280 MINT3_X_6080_Y_9280 1.319
R_VINT3_4184 MINT4_X_6080_Y_9600 MINT3_X_6080_Y_9600 1.319
R_VINT3_4185 MINT4_X_6080_Y_9920 MINT3_X_6080_Y_9920 1.319
R_VINT3_4186 MINT4_X_6400_Y_0 MINT3_X_6400_Y_0 1.319
R_VINT3_4187 MINT4_X_6400_Y_320 MINT3_X_6400_Y_320 1.319
R_VINT3_4188 MINT4_X_6400_Y_640 MINT3_X_6400_Y_640 1.319
R_VINT3_4189 MINT4_X_6400_Y_960 MINT3_X_6400_Y_960 1.319
R_VINT3_4190 MINT4_X_6400_Y_1280 MINT3_X_6400_Y_1280 1.319
R_VINT3_4191 MINT4_X_6400_Y_1600 MINT3_X_6400_Y_1600 1.319
R_VINT3_4192 MINT4_X_6400_Y_1920 MINT3_X_6400_Y_1920 1.319
R_VINT3_4193 MINT4_X_6400_Y_2240 MINT3_X_6400_Y_2240 1.319
R_VINT3_4194 MINT4_X_6400_Y_2560 MINT3_X_6400_Y_2560 1.319
R_VINT3_4195 MINT4_X_6400_Y_2880 MINT3_X_6400_Y_2880 1.319
R_VINT3_4196 MINT4_X_6400_Y_3200 MINT3_X_6400_Y_3200 1.319
R_VINT3_4197 MINT4_X_6400_Y_3520 MINT3_X_6400_Y_3520 1.319
R_VINT3_4198 MINT4_X_6400_Y_3840 MINT3_X_6400_Y_3840 1.319
R_VINT3_4199 MINT4_X_6400_Y_4160 MINT3_X_6400_Y_4160 1.319
R_VINT3_4200 MINT4_X_6400_Y_4480 MINT3_X_6400_Y_4480 1.319
R_VINT3_4201 MINT4_X_6400_Y_4800 MINT3_X_6400_Y_4800 1.319
R_VINT3_4202 MINT4_X_6400_Y_5120 MINT3_X_6400_Y_5120 1.319
R_VINT3_4203 MINT4_X_6400_Y_5440 MINT3_X_6400_Y_5440 1.319
R_VINT3_4204 MINT4_X_6400_Y_5760 MINT3_X_6400_Y_5760 1.319
R_VINT3_4205 MINT4_X_6400_Y_6080 MINT3_X_6400_Y_6080 1.319
R_VINT3_4206 MINT4_X_6400_Y_6400 MINT3_X_6400_Y_6400 1.319
R_VINT3_4207 MINT4_X_6400_Y_6720 MINT3_X_6400_Y_6720 1.319
R_VINT3_4208 MINT4_X_6400_Y_7040 MINT3_X_6400_Y_7040 1.319
R_VINT3_4209 MINT4_X_6400_Y_7360 MINT3_X_6400_Y_7360 1.319
R_VINT3_4210 MINT4_X_6400_Y_7680 MINT3_X_6400_Y_7680 1.319
R_VINT3_4211 MINT4_X_6400_Y_8000 MINT3_X_6400_Y_8000 1.319
R_VINT3_4212 MINT4_X_6400_Y_8320 MINT3_X_6400_Y_8320 1.319
R_VINT3_4213 MINT4_X_6400_Y_8640 MINT3_X_6400_Y_8640 1.319
R_VINT3_4214 MINT4_X_6400_Y_8960 MINT3_X_6400_Y_8960 1.319
R_VINT3_4215 MINT4_X_6400_Y_9280 MINT3_X_6400_Y_9280 1.319
R_VINT3_4216 MINT4_X_6400_Y_9600 MINT3_X_6400_Y_9600 1.319
R_VINT3_4217 MINT4_X_6400_Y_9920 MINT3_X_6400_Y_9920 1.319
R_VINT3_4218 MINT4_X_6720_Y_0 MINT3_X_6720_Y_0 1.319
R_VINT3_4219 MINT4_X_6720_Y_320 MINT3_X_6720_Y_320 1.319
R_VINT3_4220 MINT4_X_6720_Y_640 MINT3_X_6720_Y_640 1.319
R_VINT3_4221 MINT4_X_6720_Y_960 MINT3_X_6720_Y_960 1.319
R_VINT3_4222 MINT4_X_6720_Y_1280 MINT3_X_6720_Y_1280 1.319
R_VINT3_4223 MINT4_X_6720_Y_1600 MINT3_X_6720_Y_1600 1.319
R_VINT3_4224 MINT4_X_6720_Y_1920 MINT3_X_6720_Y_1920 1.319
R_VINT3_4225 MINT4_X_6720_Y_2240 MINT3_X_6720_Y_2240 1.319
R_VINT3_4226 MINT4_X_6720_Y_2560 MINT3_X_6720_Y_2560 1.319
R_VINT3_4227 MINT4_X_6720_Y_2880 MINT3_X_6720_Y_2880 1.319
R_VINT3_4228 MINT4_X_6720_Y_3200 MINT3_X_6720_Y_3200 1.319
R_VINT3_4229 MINT4_X_6720_Y_3520 MINT3_X_6720_Y_3520 1.319
R_VINT3_4230 MINT4_X_6720_Y_3840 MINT3_X_6720_Y_3840 1.319
R_VINT3_4231 MINT4_X_6720_Y_4160 MINT3_X_6720_Y_4160 1.319
R_VINT3_4232 MINT4_X_6720_Y_4480 MINT3_X_6720_Y_4480 1.319
R_VINT3_4233 MINT4_X_6720_Y_4800 MINT3_X_6720_Y_4800 1.319
R_VINT3_4234 MINT4_X_6720_Y_5120 MINT3_X_6720_Y_5120 1.319
R_VINT3_4235 MINT4_X_6720_Y_5440 MINT3_X_6720_Y_5440 1.319
R_VINT3_4236 MINT4_X_6720_Y_5760 MINT3_X_6720_Y_5760 1.319
R_VINT3_4237 MINT4_X_6720_Y_6080 MINT3_X_6720_Y_6080 1.319
R_VINT3_4238 MINT4_X_6720_Y_6400 MINT3_X_6720_Y_6400 1.319
R_VINT3_4239 MINT4_X_6720_Y_6720 MINT3_X_6720_Y_6720 1.319
R_VINT3_4240 MINT4_X_6720_Y_7040 MINT3_X_6720_Y_7040 1.319
R_VINT3_4241 MINT4_X_6720_Y_7360 MINT3_X_6720_Y_7360 1.319
R_VINT3_4242 MINT4_X_6720_Y_7680 MINT3_X_6720_Y_7680 1.319
R_VINT3_4243 MINT4_X_6720_Y_8000 MINT3_X_6720_Y_8000 1.319
R_VINT3_4244 MINT4_X_6720_Y_8320 MINT3_X_6720_Y_8320 1.319
R_VINT3_4245 MINT4_X_6720_Y_8640 MINT3_X_6720_Y_8640 1.319
R_VINT3_4246 MINT4_X_6720_Y_8960 MINT3_X_6720_Y_8960 1.319
R_VINT3_4247 MINT4_X_6720_Y_9280 MINT3_X_6720_Y_9280 1.319
R_VINT3_4248 MINT4_X_6720_Y_9600 MINT3_X_6720_Y_9600 1.319
R_VINT3_4249 MINT4_X_6720_Y_9920 MINT3_X_6720_Y_9920 1.319
R_VINT3_4250 MINT4_X_7040_Y_0 MINT3_X_7040_Y_0 1.319
R_VINT3_4251 MINT4_X_7040_Y_320 MINT3_X_7040_Y_320 1.319
R_VINT3_4252 MINT4_X_7040_Y_640 MINT3_X_7040_Y_640 1.319
R_VINT3_4253 MINT4_X_7040_Y_960 MINT3_X_7040_Y_960 1.319
R_VINT3_4254 MINT4_X_7040_Y_1280 MINT3_X_7040_Y_1280 1.319
R_VINT3_4255 MINT4_X_7040_Y_1600 MINT3_X_7040_Y_1600 1.319
R_VINT3_4256 MINT4_X_7040_Y_1920 MINT3_X_7040_Y_1920 1.319
R_VINT3_4257 MINT4_X_7040_Y_2240 MINT3_X_7040_Y_2240 1.319
R_VINT3_4258 MINT4_X_7040_Y_2560 MINT3_X_7040_Y_2560 1.319
R_VINT3_4259 MINT4_X_7040_Y_2880 MINT3_X_7040_Y_2880 1.319
R_VINT3_4260 MINT4_X_7040_Y_3200 MINT3_X_7040_Y_3200 1.319
R_VINT3_4261 MINT4_X_7040_Y_3520 MINT3_X_7040_Y_3520 1.319
R_VINT3_4262 MINT4_X_7040_Y_3840 MINT3_X_7040_Y_3840 1.319
R_VINT3_4263 MINT4_X_7040_Y_4160 MINT3_X_7040_Y_4160 1.319
R_VINT3_4264 MINT4_X_7040_Y_4480 MINT3_X_7040_Y_4480 1.319
R_VINT3_4265 MINT4_X_7040_Y_4800 MINT3_X_7040_Y_4800 1.319
R_VINT3_4266 MINT4_X_7040_Y_5120 MINT3_X_7040_Y_5120 1.319
R_VINT3_4267 MINT4_X_7040_Y_5440 MINT3_X_7040_Y_5440 1.319
R_VINT3_4268 MINT4_X_7040_Y_5760 MINT3_X_7040_Y_5760 1.319
R_VINT3_4269 MINT4_X_7040_Y_6080 MINT3_X_7040_Y_6080 1.319
R_VINT3_4270 MINT4_X_7040_Y_6400 MINT3_X_7040_Y_6400 1.319
R_VINT3_4271 MINT4_X_7040_Y_6720 MINT3_X_7040_Y_6720 1.319
R_VINT3_4272 MINT4_X_7040_Y_7040 MINT3_X_7040_Y_7040 1.319
R_VINT3_4273 MINT4_X_7040_Y_7360 MINT3_X_7040_Y_7360 1.319
R_VINT3_4274 MINT4_X_7040_Y_7680 MINT3_X_7040_Y_7680 1.319
R_VINT3_4275 MINT4_X_7040_Y_8000 MINT3_X_7040_Y_8000 1.319
R_VINT3_4276 MINT4_X_7040_Y_8320 MINT3_X_7040_Y_8320 1.319
R_VINT3_4277 MINT4_X_7040_Y_8640 MINT3_X_7040_Y_8640 1.319
R_VINT3_4278 MINT4_X_7040_Y_8960 MINT3_X_7040_Y_8960 1.319
R_VINT3_4279 MINT4_X_7040_Y_9280 MINT3_X_7040_Y_9280 1.319
R_VINT3_4280 MINT4_X_7040_Y_9600 MINT3_X_7040_Y_9600 1.319
R_VINT3_4281 MINT4_X_7040_Y_9920 MINT3_X_7040_Y_9920 1.319
R_VINT3_4282 MINT4_X_7360_Y_0 MINT3_X_7360_Y_0 1.319
R_VINT3_4283 MINT4_X_7360_Y_320 MINT3_X_7360_Y_320 1.319
R_VINT3_4284 MINT4_X_7360_Y_640 MINT3_X_7360_Y_640 1.319
R_VINT3_4285 MINT4_X_7360_Y_960 MINT3_X_7360_Y_960 1.319
R_VINT3_4286 MINT4_X_7360_Y_1280 MINT3_X_7360_Y_1280 1.319
R_VINT3_4287 MINT4_X_7360_Y_1600 MINT3_X_7360_Y_1600 1.319
R_VINT3_4288 MINT4_X_7360_Y_1920 MINT3_X_7360_Y_1920 1.319
R_VINT3_4289 MINT4_X_7360_Y_2240 MINT3_X_7360_Y_2240 1.319
R_VINT3_4290 MINT4_X_7360_Y_2560 MINT3_X_7360_Y_2560 1.319
R_VINT3_4291 MINT4_X_7360_Y_2880 MINT3_X_7360_Y_2880 1.319
R_VINT3_4292 MINT4_X_7360_Y_3200 MINT3_X_7360_Y_3200 1.319
R_VINT3_4293 MINT4_X_7360_Y_3520 MINT3_X_7360_Y_3520 1.319
R_VINT3_4294 MINT4_X_7360_Y_3840 MINT3_X_7360_Y_3840 1.319
R_VINT3_4295 MINT4_X_7360_Y_4160 MINT3_X_7360_Y_4160 1.319
R_VINT3_4296 MINT4_X_7360_Y_4480 MINT3_X_7360_Y_4480 1.319
R_VINT3_4297 MINT4_X_7360_Y_4800 MINT3_X_7360_Y_4800 1.319
R_VINT3_4298 MINT4_X_7360_Y_5120 MINT3_X_7360_Y_5120 1.319
R_VINT3_4299 MINT4_X_7360_Y_5440 MINT3_X_7360_Y_5440 1.319
R_VINT3_4300 MINT4_X_7360_Y_5760 MINT3_X_7360_Y_5760 1.319
R_VINT3_4301 MINT4_X_7360_Y_6080 MINT3_X_7360_Y_6080 1.319
R_VINT3_4302 MINT4_X_7360_Y_6400 MINT3_X_7360_Y_6400 1.319
R_VINT3_4303 MINT4_X_7360_Y_6720 MINT3_X_7360_Y_6720 1.319
R_VINT3_4304 MINT4_X_7360_Y_7040 MINT3_X_7360_Y_7040 1.319
R_VINT3_4305 MINT4_X_7360_Y_7360 MINT3_X_7360_Y_7360 1.319
R_VINT3_4306 MINT4_X_7360_Y_7680 MINT3_X_7360_Y_7680 1.319
R_VINT3_4307 MINT4_X_7360_Y_8000 MINT3_X_7360_Y_8000 1.319
R_VINT3_4308 MINT4_X_7360_Y_8320 MINT3_X_7360_Y_8320 1.319
R_VINT3_4309 MINT4_X_7360_Y_8640 MINT3_X_7360_Y_8640 1.319
R_VINT3_4310 MINT4_X_7360_Y_8960 MINT3_X_7360_Y_8960 1.319
R_VINT3_4311 MINT4_X_7360_Y_9280 MINT3_X_7360_Y_9280 1.319
R_VINT3_4312 MINT4_X_7360_Y_9600 MINT3_X_7360_Y_9600 1.319
R_VINT3_4313 MINT4_X_7360_Y_9920 MINT3_X_7360_Y_9920 1.319
R_VINT3_4314 MINT4_X_7680_Y_0 MINT3_X_7680_Y_0 1.319
R_VINT3_4315 MINT4_X_7680_Y_320 MINT3_X_7680_Y_320 1.319
R_VINT3_4316 MINT4_X_7680_Y_640 MINT3_X_7680_Y_640 1.319
R_VINT3_4317 MINT4_X_7680_Y_960 MINT3_X_7680_Y_960 1.319
R_VINT3_4318 MINT4_X_7680_Y_1280 MINT3_X_7680_Y_1280 1.319
R_VINT3_4319 MINT4_X_7680_Y_1600 MINT3_X_7680_Y_1600 1.319
R_VINT3_4320 MINT4_X_7680_Y_1920 MINT3_X_7680_Y_1920 1.319
R_VINT3_4321 MINT4_X_7680_Y_2240 MINT3_X_7680_Y_2240 1.319
R_VINT3_4322 MINT4_X_7680_Y_2560 MINT3_X_7680_Y_2560 1.319
R_VINT3_4323 MINT4_X_7680_Y_2880 MINT3_X_7680_Y_2880 1.319
R_VINT3_4324 MINT4_X_7680_Y_3200 MINT3_X_7680_Y_3200 1.319
R_VINT3_4325 MINT4_X_7680_Y_3520 MINT3_X_7680_Y_3520 1.319
R_VINT3_4326 MINT4_X_7680_Y_3840 MINT3_X_7680_Y_3840 1.319
R_VINT3_4327 MINT4_X_7680_Y_4160 MINT3_X_7680_Y_4160 1.319
R_VINT3_4328 MINT4_X_7680_Y_4480 MINT3_X_7680_Y_4480 1.319
R_VINT3_4329 MINT4_X_7680_Y_4800 MINT3_X_7680_Y_4800 1.319
R_VINT3_4330 MINT4_X_7680_Y_5120 MINT3_X_7680_Y_5120 1.319
R_VINT3_4331 MINT4_X_7680_Y_5440 MINT3_X_7680_Y_5440 1.319
R_VINT3_4332 MINT4_X_7680_Y_5760 MINT3_X_7680_Y_5760 1.319
R_VINT3_4333 MINT4_X_7680_Y_6080 MINT3_X_7680_Y_6080 1.319
R_VINT3_4334 MINT4_X_7680_Y_6400 MINT3_X_7680_Y_6400 1.319
R_VINT3_4335 MINT4_X_7680_Y_6720 MINT3_X_7680_Y_6720 1.319
R_VINT3_4336 MINT4_X_7680_Y_7040 MINT3_X_7680_Y_7040 1.319
R_VINT3_4337 MINT4_X_7680_Y_7360 MINT3_X_7680_Y_7360 1.319
R_VINT3_4338 MINT4_X_7680_Y_7680 MINT3_X_7680_Y_7680 1.319
R_VINT3_4339 MINT4_X_7680_Y_8000 MINT3_X_7680_Y_8000 1.319
R_VINT3_4340 MINT4_X_7680_Y_8320 MINT3_X_7680_Y_8320 1.319
R_VINT3_4341 MINT4_X_7680_Y_8640 MINT3_X_7680_Y_8640 1.319
R_VINT3_4342 MINT4_X_7680_Y_8960 MINT3_X_7680_Y_8960 1.319
R_VINT3_4343 MINT4_X_7680_Y_9280 MINT3_X_7680_Y_9280 1.319
R_VINT3_4344 MINT4_X_7680_Y_9600 MINT3_X_7680_Y_9600 1.319
R_VINT3_4345 MINT4_X_7680_Y_9920 MINT3_X_7680_Y_9920 1.319
R_VINT3_4346 MINT4_X_8000_Y_0 MINT3_X_8000_Y_0 1.319
R_VINT3_4347 MINT4_X_8000_Y_320 MINT3_X_8000_Y_320 1.319
R_VINT3_4348 MINT4_X_8000_Y_640 MINT3_X_8000_Y_640 1.319
R_VINT3_4349 MINT4_X_8000_Y_960 MINT3_X_8000_Y_960 1.319
R_VINT3_4350 MINT4_X_8000_Y_1280 MINT3_X_8000_Y_1280 1.319
R_VINT3_4351 MINT4_X_8000_Y_1600 MINT3_X_8000_Y_1600 1.319
R_VINT3_4352 MINT4_X_8000_Y_1920 MINT3_X_8000_Y_1920 1.319
R_VINT3_4353 MINT4_X_8000_Y_2240 MINT3_X_8000_Y_2240 1.319
R_VINT3_4354 MINT4_X_8000_Y_2560 MINT3_X_8000_Y_2560 1.319
R_VINT3_4355 MINT4_X_8000_Y_2880 MINT3_X_8000_Y_2880 1.319
R_VINT3_4356 MINT4_X_8000_Y_3200 MINT3_X_8000_Y_3200 1.319
R_VINT3_4357 MINT4_X_8000_Y_3520 MINT3_X_8000_Y_3520 1.319
R_VINT3_4358 MINT4_X_8000_Y_3840 MINT3_X_8000_Y_3840 1.319
R_VINT3_4359 MINT4_X_8000_Y_4160 MINT3_X_8000_Y_4160 1.319
R_VINT3_4360 MINT4_X_8000_Y_4480 MINT3_X_8000_Y_4480 1.319
R_VINT3_4361 MINT4_X_8000_Y_4800 MINT3_X_8000_Y_4800 1.319
R_VINT3_4362 MINT4_X_8000_Y_5120 MINT3_X_8000_Y_5120 1.319
R_VINT3_4363 MINT4_X_8000_Y_5440 MINT3_X_8000_Y_5440 1.319
R_VINT3_4364 MINT4_X_8000_Y_5760 MINT3_X_8000_Y_5760 1.319
R_VINT3_4365 MINT4_X_8000_Y_6080 MINT3_X_8000_Y_6080 1.319
R_VINT3_4366 MINT4_X_8000_Y_6400 MINT3_X_8000_Y_6400 1.319
R_VINT3_4367 MINT4_X_8000_Y_6720 MINT3_X_8000_Y_6720 1.319
R_VINT3_4368 MINT4_X_8000_Y_7040 MINT3_X_8000_Y_7040 1.319
R_VINT3_4369 MINT4_X_8000_Y_7360 MINT3_X_8000_Y_7360 1.319
R_VINT3_4370 MINT4_X_8000_Y_7680 MINT3_X_8000_Y_7680 1.319
R_VINT3_4371 MINT4_X_8000_Y_8000 MINT3_X_8000_Y_8000 1.319
R_VINT3_4372 MINT4_X_8000_Y_8320 MINT3_X_8000_Y_8320 1.319
R_VINT3_4373 MINT4_X_8000_Y_8640 MINT3_X_8000_Y_8640 1.319
R_VINT3_4374 MINT4_X_8000_Y_8960 MINT3_X_8000_Y_8960 1.319
R_VINT3_4375 MINT4_X_8000_Y_9280 MINT3_X_8000_Y_9280 1.319
R_VINT3_4376 MINT4_X_8000_Y_9600 MINT3_X_8000_Y_9600 1.319
R_VINT3_4377 MINT4_X_8000_Y_9920 MINT3_X_8000_Y_9920 1.319
R_VINT3_4378 MINT4_X_8320_Y_0 MINT3_X_8320_Y_0 1.319
R_VINT3_4379 MINT4_X_8320_Y_320 MINT3_X_8320_Y_320 1.319
R_VINT3_4380 MINT4_X_8320_Y_640 MINT3_X_8320_Y_640 1.319
R_VINT3_4381 MINT4_X_8320_Y_960 MINT3_X_8320_Y_960 1.319
R_VINT3_4382 MINT4_X_8320_Y_1280 MINT3_X_8320_Y_1280 1.319
R_VINT3_4383 MINT4_X_8320_Y_1600 MINT3_X_8320_Y_1600 1.319
R_VINT3_4384 MINT4_X_8320_Y_1920 MINT3_X_8320_Y_1920 1.319
R_VINT3_4385 MINT4_X_8320_Y_2240 MINT3_X_8320_Y_2240 1.319
R_VINT3_4386 MINT4_X_8320_Y_2560 MINT3_X_8320_Y_2560 1.319
R_VINT3_4387 MINT4_X_8320_Y_2880 MINT3_X_8320_Y_2880 1.319
R_VINT3_4388 MINT4_X_8320_Y_3200 MINT3_X_8320_Y_3200 1.319
R_VINT3_4389 MINT4_X_8320_Y_3520 MINT3_X_8320_Y_3520 1.319
R_VINT3_4390 MINT4_X_8320_Y_3840 MINT3_X_8320_Y_3840 1.319
R_VINT3_4391 MINT4_X_8320_Y_4160 MINT3_X_8320_Y_4160 1.319
R_VINT3_4392 MINT4_X_8320_Y_4480 MINT3_X_8320_Y_4480 1.319
R_VINT3_4393 MINT4_X_8320_Y_4800 MINT3_X_8320_Y_4800 1.319
R_VINT3_4394 MINT4_X_8320_Y_5120 MINT3_X_8320_Y_5120 1.319
R_VINT3_4395 MINT4_X_8320_Y_5440 MINT3_X_8320_Y_5440 1.319
R_VINT3_4396 MINT4_X_8320_Y_5760 MINT3_X_8320_Y_5760 1.319
R_VINT3_4397 MINT4_X_8320_Y_6080 MINT3_X_8320_Y_6080 1.319
R_VINT3_4398 MINT4_X_8320_Y_6400 MINT3_X_8320_Y_6400 1.319
R_VINT3_4399 MINT4_X_8320_Y_6720 MINT3_X_8320_Y_6720 1.319
R_VINT3_4400 MINT4_X_8320_Y_7040 MINT3_X_8320_Y_7040 1.319
R_VINT3_4401 MINT4_X_8320_Y_7360 MINT3_X_8320_Y_7360 1.319
R_VINT3_4402 MINT4_X_8320_Y_7680 MINT3_X_8320_Y_7680 1.319
R_VINT3_4403 MINT4_X_8320_Y_8000 MINT3_X_8320_Y_8000 1.319
R_VINT3_4404 MINT4_X_8320_Y_8320 MINT3_X_8320_Y_8320 1.319
R_VINT3_4405 MINT4_X_8320_Y_8640 MINT3_X_8320_Y_8640 1.319
R_VINT3_4406 MINT4_X_8320_Y_8960 MINT3_X_8320_Y_8960 1.319
R_VINT3_4407 MINT4_X_8320_Y_9280 MINT3_X_8320_Y_9280 1.319
R_VINT3_4408 MINT4_X_8320_Y_9600 MINT3_X_8320_Y_9600 1.319
R_VINT3_4409 MINT4_X_8320_Y_9920 MINT3_X_8320_Y_9920 1.319
R_VINT3_4410 MINT4_X_8640_Y_0 MINT3_X_8640_Y_0 1.319
R_VINT3_4411 MINT4_X_8640_Y_320 MINT3_X_8640_Y_320 1.319
R_VINT3_4412 MINT4_X_8640_Y_640 MINT3_X_8640_Y_640 1.319
R_VINT3_4413 MINT4_X_8640_Y_960 MINT3_X_8640_Y_960 1.319
R_VINT3_4414 MINT4_X_8640_Y_1280 MINT3_X_8640_Y_1280 1.319
R_VINT3_4415 MINT4_X_8640_Y_1600 MINT3_X_8640_Y_1600 1.319
R_VINT3_4416 MINT4_X_8640_Y_1920 MINT3_X_8640_Y_1920 1.319
R_VINT3_4417 MINT4_X_8640_Y_2240 MINT3_X_8640_Y_2240 1.319
R_VINT3_4418 MINT4_X_8640_Y_2560 MINT3_X_8640_Y_2560 1.319
R_VINT3_4419 MINT4_X_8640_Y_2880 MINT3_X_8640_Y_2880 1.319
R_VINT3_4420 MINT4_X_8640_Y_3200 MINT3_X_8640_Y_3200 1.319
R_VINT3_4421 MINT4_X_8640_Y_3520 MINT3_X_8640_Y_3520 1.319
R_VINT3_4422 MINT4_X_8640_Y_3840 MINT3_X_8640_Y_3840 1.319
R_VINT3_4423 MINT4_X_8640_Y_4160 MINT3_X_8640_Y_4160 1.319
R_VINT3_4424 MINT4_X_8640_Y_4480 MINT3_X_8640_Y_4480 1.319
R_VINT3_4425 MINT4_X_8640_Y_4800 MINT3_X_8640_Y_4800 1.319
R_VINT3_4426 MINT4_X_8640_Y_5120 MINT3_X_8640_Y_5120 1.319
R_VINT3_4427 MINT4_X_8640_Y_5440 MINT3_X_8640_Y_5440 1.319
R_VINT3_4428 MINT4_X_8640_Y_5760 MINT3_X_8640_Y_5760 1.319
R_VINT3_4429 MINT4_X_8640_Y_6080 MINT3_X_8640_Y_6080 1.319
R_VINT3_4430 MINT4_X_8640_Y_6400 MINT3_X_8640_Y_6400 1.319
R_VINT3_4431 MINT4_X_8640_Y_6720 MINT3_X_8640_Y_6720 1.319
R_VINT3_4432 MINT4_X_8640_Y_7040 MINT3_X_8640_Y_7040 1.319
R_VINT3_4433 MINT4_X_8640_Y_7360 MINT3_X_8640_Y_7360 1.319
R_VINT3_4434 MINT4_X_8640_Y_7680 MINT3_X_8640_Y_7680 1.319
R_VINT3_4435 MINT4_X_8640_Y_8000 MINT3_X_8640_Y_8000 1.319
R_VINT3_4436 MINT4_X_8640_Y_8320 MINT3_X_8640_Y_8320 1.319
R_VINT3_4437 MINT4_X_8640_Y_8640 MINT3_X_8640_Y_8640 1.319
R_VINT3_4438 MINT4_X_8640_Y_8960 MINT3_X_8640_Y_8960 1.319
R_VINT3_4439 MINT4_X_8640_Y_9280 MINT3_X_8640_Y_9280 1.319
R_VINT3_4440 MINT4_X_8640_Y_9600 MINT3_X_8640_Y_9600 1.319
R_VINT3_4441 MINT4_X_8640_Y_9920 MINT3_X_8640_Y_9920 1.319
R_VINT3_4442 MINT4_X_8960_Y_0 MINT3_X_8960_Y_0 1.319
R_VINT3_4443 MINT4_X_8960_Y_320 MINT3_X_8960_Y_320 1.319
R_VINT3_4444 MINT4_X_8960_Y_640 MINT3_X_8960_Y_640 1.319
R_VINT3_4445 MINT4_X_8960_Y_960 MINT3_X_8960_Y_960 1.319
R_VINT3_4446 MINT4_X_8960_Y_1280 MINT3_X_8960_Y_1280 1.319
R_VINT3_4447 MINT4_X_8960_Y_1600 MINT3_X_8960_Y_1600 1.319
R_VINT3_4448 MINT4_X_8960_Y_1920 MINT3_X_8960_Y_1920 1.319
R_VINT3_4449 MINT4_X_8960_Y_2240 MINT3_X_8960_Y_2240 1.319
R_VINT3_4450 MINT4_X_8960_Y_2560 MINT3_X_8960_Y_2560 1.319
R_VINT3_4451 MINT4_X_8960_Y_2880 MINT3_X_8960_Y_2880 1.319
R_VINT3_4452 MINT4_X_8960_Y_3200 MINT3_X_8960_Y_3200 1.319
R_VINT3_4453 MINT4_X_8960_Y_3520 MINT3_X_8960_Y_3520 1.319
R_VINT3_4454 MINT4_X_8960_Y_3840 MINT3_X_8960_Y_3840 1.319
R_VINT3_4455 MINT4_X_8960_Y_4160 MINT3_X_8960_Y_4160 1.319
R_VINT3_4456 MINT4_X_8960_Y_4480 MINT3_X_8960_Y_4480 1.319
R_VINT3_4457 MINT4_X_8960_Y_4800 MINT3_X_8960_Y_4800 1.319
R_VINT3_4458 MINT4_X_8960_Y_5120 MINT3_X_8960_Y_5120 1.319
R_VINT3_4459 MINT4_X_8960_Y_5440 MINT3_X_8960_Y_5440 1.319
R_VINT3_4460 MINT4_X_8960_Y_5760 MINT3_X_8960_Y_5760 1.319
R_VINT3_4461 MINT4_X_8960_Y_6080 MINT3_X_8960_Y_6080 1.319
R_VINT3_4462 MINT4_X_8960_Y_6400 MINT3_X_8960_Y_6400 1.319
R_VINT3_4463 MINT4_X_8960_Y_6720 MINT3_X_8960_Y_6720 1.319
R_VINT3_4464 MINT4_X_8960_Y_7040 MINT3_X_8960_Y_7040 1.319
R_VINT3_4465 MINT4_X_8960_Y_7360 MINT3_X_8960_Y_7360 1.319
R_VINT3_4466 MINT4_X_8960_Y_7680 MINT3_X_8960_Y_7680 1.319
R_VINT3_4467 MINT4_X_8960_Y_8000 MINT3_X_8960_Y_8000 1.319
R_VINT3_4468 MINT4_X_8960_Y_8320 MINT3_X_8960_Y_8320 1.319
R_VINT3_4469 MINT4_X_8960_Y_8640 MINT3_X_8960_Y_8640 1.319
R_VINT3_4470 MINT4_X_8960_Y_8960 MINT3_X_8960_Y_8960 1.319
R_VINT3_4471 MINT4_X_8960_Y_9280 MINT3_X_8960_Y_9280 1.319
R_VINT3_4472 MINT4_X_8960_Y_9600 MINT3_X_8960_Y_9600 1.319
R_VINT3_4473 MINT4_X_8960_Y_9920 MINT3_X_8960_Y_9920 1.319
R_VINT3_4474 MINT4_X_9280_Y_0 MINT3_X_9280_Y_0 1.319
R_VINT3_4475 MINT4_X_9280_Y_320 MINT3_X_9280_Y_320 1.319
R_VINT3_4476 MINT4_X_9280_Y_640 MINT3_X_9280_Y_640 1.319
R_VINT3_4477 MINT4_X_9280_Y_960 MINT3_X_9280_Y_960 1.319
R_VINT3_4478 MINT4_X_9280_Y_1280 MINT3_X_9280_Y_1280 1.319
R_VINT3_4479 MINT4_X_9280_Y_1600 MINT3_X_9280_Y_1600 1.319
R_VINT3_4480 MINT4_X_9280_Y_1920 MINT3_X_9280_Y_1920 1.319
R_VINT3_4481 MINT4_X_9280_Y_2240 MINT3_X_9280_Y_2240 1.319
R_VINT3_4482 MINT4_X_9280_Y_2560 MINT3_X_9280_Y_2560 1.319
R_VINT3_4483 MINT4_X_9280_Y_2880 MINT3_X_9280_Y_2880 1.319
R_VINT3_4484 MINT4_X_9280_Y_3200 MINT3_X_9280_Y_3200 1.319
R_VINT3_4485 MINT4_X_9280_Y_3520 MINT3_X_9280_Y_3520 1.319
R_VINT3_4486 MINT4_X_9280_Y_3840 MINT3_X_9280_Y_3840 1.319
R_VINT3_4487 MINT4_X_9280_Y_4160 MINT3_X_9280_Y_4160 1.319
R_VINT3_4488 MINT4_X_9280_Y_4480 MINT3_X_9280_Y_4480 1.319
R_VINT3_4489 MINT4_X_9280_Y_4800 MINT3_X_9280_Y_4800 1.319
R_VINT3_4490 MINT4_X_9280_Y_5120 MINT3_X_9280_Y_5120 1.319
R_VINT3_4491 MINT4_X_9280_Y_5440 MINT3_X_9280_Y_5440 1.319
R_VINT3_4492 MINT4_X_9280_Y_5760 MINT3_X_9280_Y_5760 1.319
R_VINT3_4493 MINT4_X_9280_Y_6080 MINT3_X_9280_Y_6080 1.319
R_VINT3_4494 MINT4_X_9280_Y_6400 MINT3_X_9280_Y_6400 1.319
R_VINT3_4495 MINT4_X_9280_Y_6720 MINT3_X_9280_Y_6720 1.319
R_VINT3_4496 MINT4_X_9280_Y_7040 MINT3_X_9280_Y_7040 1.319
R_VINT3_4497 MINT4_X_9280_Y_7360 MINT3_X_9280_Y_7360 1.319
R_VINT3_4498 MINT4_X_9280_Y_7680 MINT3_X_9280_Y_7680 1.319
R_VINT3_4499 MINT4_X_9280_Y_8000 MINT3_X_9280_Y_8000 1.319
R_VINT3_4500 MINT4_X_9280_Y_8320 MINT3_X_9280_Y_8320 1.319
R_VINT3_4501 MINT4_X_9280_Y_8640 MINT3_X_9280_Y_8640 1.319
R_VINT3_4502 MINT4_X_9280_Y_8960 MINT3_X_9280_Y_8960 1.319
R_VINT3_4503 MINT4_X_9280_Y_9280 MINT3_X_9280_Y_9280 1.319
R_VINT3_4504 MINT4_X_9280_Y_9600 MINT3_X_9280_Y_9600 1.319
R_VINT3_4505 MINT4_X_9280_Y_9920 MINT3_X_9280_Y_9920 1.319
R_VINT3_4506 MINT4_X_9600_Y_0 MINT3_X_9600_Y_0 1.319
R_VINT3_4507 MINT4_X_9600_Y_320 MINT3_X_9600_Y_320 1.319
R_VINT3_4508 MINT4_X_9600_Y_640 MINT3_X_9600_Y_640 1.319
R_VINT3_4509 MINT4_X_9600_Y_960 MINT3_X_9600_Y_960 1.319
R_VINT3_4510 MINT4_X_9600_Y_1280 MINT3_X_9600_Y_1280 1.319
R_VINT3_4511 MINT4_X_9600_Y_1600 MINT3_X_9600_Y_1600 1.319
R_VINT3_4512 MINT4_X_9600_Y_1920 MINT3_X_9600_Y_1920 1.319
R_VINT3_4513 MINT4_X_9600_Y_2240 MINT3_X_9600_Y_2240 1.319
R_VINT3_4514 MINT4_X_9600_Y_2560 MINT3_X_9600_Y_2560 1.319
R_VINT3_4515 MINT4_X_9600_Y_2880 MINT3_X_9600_Y_2880 1.319
R_VINT3_4516 MINT4_X_9600_Y_3200 MINT3_X_9600_Y_3200 1.319
R_VINT3_4517 MINT4_X_9600_Y_3520 MINT3_X_9600_Y_3520 1.319
R_VINT3_4518 MINT4_X_9600_Y_3840 MINT3_X_9600_Y_3840 1.319
R_VINT3_4519 MINT4_X_9600_Y_4160 MINT3_X_9600_Y_4160 1.319
R_VINT3_4520 MINT4_X_9600_Y_4480 MINT3_X_9600_Y_4480 1.319
R_VINT3_4521 MINT4_X_9600_Y_4800 MINT3_X_9600_Y_4800 1.319
R_VINT3_4522 MINT4_X_9600_Y_5120 MINT3_X_9600_Y_5120 1.319
R_VINT3_4523 MINT4_X_9600_Y_5440 MINT3_X_9600_Y_5440 1.319
R_VINT3_4524 MINT4_X_9600_Y_5760 MINT3_X_9600_Y_5760 1.319
R_VINT3_4525 MINT4_X_9600_Y_6080 MINT3_X_9600_Y_6080 1.319
R_VINT3_4526 MINT4_X_9600_Y_6400 MINT3_X_9600_Y_6400 1.319
R_VINT3_4527 MINT4_X_9600_Y_6720 MINT3_X_9600_Y_6720 1.319
R_VINT3_4528 MINT4_X_9600_Y_7040 MINT3_X_9600_Y_7040 1.319
R_VINT3_4529 MINT4_X_9600_Y_7360 MINT3_X_9600_Y_7360 1.319
R_VINT3_4530 MINT4_X_9600_Y_7680 MINT3_X_9600_Y_7680 1.319
R_VINT3_4531 MINT4_X_9600_Y_8000 MINT3_X_9600_Y_8000 1.319
R_VINT3_4532 MINT4_X_9600_Y_8320 MINT3_X_9600_Y_8320 1.319
R_VINT3_4533 MINT4_X_9600_Y_8640 MINT3_X_9600_Y_8640 1.319
R_VINT3_4534 MINT4_X_9600_Y_8960 MINT3_X_9600_Y_8960 1.319
R_VINT3_4535 MINT4_X_9600_Y_9280 MINT3_X_9600_Y_9280 1.319
R_VINT3_4536 MINT4_X_9600_Y_9600 MINT3_X_9600_Y_9600 1.319
R_VINT3_4537 MINT4_X_9600_Y_9920 MINT3_X_9600_Y_9920 1.319
R_VINT3_4538 MINT4_X_9920_Y_0 MINT3_X_9920_Y_0 1.319
R_VINT3_4539 MINT4_X_9920_Y_320 MINT3_X_9920_Y_320 1.319
R_VINT3_4540 MINT4_X_9920_Y_640 MINT3_X_9920_Y_640 1.319
R_VINT3_4541 MINT4_X_9920_Y_960 MINT3_X_9920_Y_960 1.319
R_VINT3_4542 MINT4_X_9920_Y_1280 MINT3_X_9920_Y_1280 1.319
R_VINT3_4543 MINT4_X_9920_Y_1600 MINT3_X_9920_Y_1600 1.319
R_VINT3_4544 MINT4_X_9920_Y_1920 MINT3_X_9920_Y_1920 1.319
R_VINT3_4545 MINT4_X_9920_Y_2240 MINT3_X_9920_Y_2240 1.319
R_VINT3_4546 MINT4_X_9920_Y_2560 MINT3_X_9920_Y_2560 1.319
R_VINT3_4547 MINT4_X_9920_Y_2880 MINT3_X_9920_Y_2880 1.319
R_VINT3_4548 MINT4_X_9920_Y_3200 MINT3_X_9920_Y_3200 1.319
R_VINT3_4549 MINT4_X_9920_Y_3520 MINT3_X_9920_Y_3520 1.319
R_VINT3_4550 MINT4_X_9920_Y_3840 MINT3_X_9920_Y_3840 1.319
R_VINT3_4551 MINT4_X_9920_Y_4160 MINT3_X_9920_Y_4160 1.319
R_VINT3_4552 MINT4_X_9920_Y_4480 MINT3_X_9920_Y_4480 1.319
R_VINT3_4553 MINT4_X_9920_Y_4800 MINT3_X_9920_Y_4800 1.319
R_VINT3_4554 MINT4_X_9920_Y_5120 MINT3_X_9920_Y_5120 1.319
R_VINT3_4555 MINT4_X_9920_Y_5440 MINT3_X_9920_Y_5440 1.319
R_VINT3_4556 MINT4_X_9920_Y_5760 MINT3_X_9920_Y_5760 1.319
R_VINT3_4557 MINT4_X_9920_Y_6080 MINT3_X_9920_Y_6080 1.319
R_VINT3_4558 MINT4_X_9920_Y_6400 MINT3_X_9920_Y_6400 1.319
R_VINT3_4559 MINT4_X_9920_Y_6720 MINT3_X_9920_Y_6720 1.319
R_VINT3_4560 MINT4_X_9920_Y_7040 MINT3_X_9920_Y_7040 1.319
R_VINT3_4561 MINT4_X_9920_Y_7360 MINT3_X_9920_Y_7360 1.319
R_VINT3_4562 MINT4_X_9920_Y_7680 MINT3_X_9920_Y_7680 1.319
R_VINT3_4563 MINT4_X_9920_Y_8000 MINT3_X_9920_Y_8000 1.319
R_VINT3_4564 MINT4_X_9920_Y_8320 MINT3_X_9920_Y_8320 1.319
R_VINT3_4565 MINT4_X_9920_Y_8640 MINT3_X_9920_Y_8640 1.319
R_VINT3_4566 MINT4_X_9920_Y_8960 MINT3_X_9920_Y_8960 1.319
R_VINT3_4567 MINT4_X_9920_Y_9280 MINT3_X_9920_Y_9280 1.319
R_VINT3_4568 MINT4_X_9920_Y_9600 MINT3_X_9920_Y_9600 1.319
R_VINT3_4569 MINT4_X_9920_Y_9920 MINT3_X_9920_Y_9920 1.319
R_VINT2_4570 MINT3_X_0_Y_0 MINT2_X_0_Y_0 1.319
R_VINT2_4571 MINT3_X_0_Y_320 MINT2_X_0_Y_320 1.319
R_VINT2_4572 MINT3_X_0_Y_640 MINT2_X_0_Y_640 1.319
R_VINT2_4573 MINT3_X_0_Y_960 MINT2_X_0_Y_960 1.319
R_VINT2_4574 MINT3_X_0_Y_1280 MINT2_X_0_Y_1280 1.319
R_VINT2_4575 MINT3_X_0_Y_1600 MINT2_X_0_Y_1600 1.319
R_VINT2_4576 MINT3_X_0_Y_1920 MINT2_X_0_Y_1920 1.319
R_VINT2_4577 MINT3_X_0_Y_2240 MINT2_X_0_Y_2240 1.319
R_VINT2_4578 MINT3_X_0_Y_2560 MINT2_X_0_Y_2560 1.319
R_VINT2_4579 MINT3_X_0_Y_2880 MINT2_X_0_Y_2880 1.319
R_VINT2_4580 MINT3_X_0_Y_3200 MINT2_X_0_Y_3200 1.319
R_VINT2_4581 MINT3_X_0_Y_3520 MINT2_X_0_Y_3520 1.319
R_VINT2_4582 MINT3_X_0_Y_3840 MINT2_X_0_Y_3840 1.319
R_VINT2_4583 MINT3_X_0_Y_4160 MINT2_X_0_Y_4160 1.319
R_VINT2_4584 MINT3_X_0_Y_4480 MINT2_X_0_Y_4480 1.319
R_VINT2_4585 MINT3_X_0_Y_4800 MINT2_X_0_Y_4800 1.319
R_VINT2_4586 MINT3_X_0_Y_5120 MINT2_X_0_Y_5120 1.319
R_VINT2_4587 MINT3_X_0_Y_5440 MINT2_X_0_Y_5440 1.319
R_VINT2_4588 MINT3_X_0_Y_5760 MINT2_X_0_Y_5760 1.319
R_VINT2_4589 MINT3_X_0_Y_6080 MINT2_X_0_Y_6080 1.319
R_VINT2_4590 MINT3_X_0_Y_6400 MINT2_X_0_Y_6400 1.319
R_VINT2_4591 MINT3_X_0_Y_6720 MINT2_X_0_Y_6720 1.319
R_VINT2_4592 MINT3_X_0_Y_7040 MINT2_X_0_Y_7040 1.319
R_VINT2_4593 MINT3_X_0_Y_7360 MINT2_X_0_Y_7360 1.319
R_VINT2_4594 MINT3_X_0_Y_7680 MINT2_X_0_Y_7680 1.319
R_VINT2_4595 MINT3_X_0_Y_8000 MINT2_X_0_Y_8000 1.319
R_VINT2_4596 MINT3_X_0_Y_8320 MINT2_X_0_Y_8320 1.319
R_VINT2_4597 MINT3_X_0_Y_8640 MINT2_X_0_Y_8640 1.319
R_VINT2_4598 MINT3_X_0_Y_8960 MINT2_X_0_Y_8960 1.319
R_VINT2_4599 MINT3_X_0_Y_9280 MINT2_X_0_Y_9280 1.319
R_VINT2_4600 MINT3_X_0_Y_9600 MINT2_X_0_Y_9600 1.319
R_VINT2_4601 MINT3_X_0_Y_9920 MINT2_X_0_Y_9920 1.319
R_VINT2_4602 MINT3_X_320_Y_0 MINT2_X_320_Y_0 1.319
R_VINT2_4603 MINT3_X_320_Y_320 MINT2_X_320_Y_320 1.319
R_VINT2_4604 MINT3_X_320_Y_640 MINT2_X_320_Y_640 1.319
R_VINT2_4605 MINT3_X_320_Y_960 MINT2_X_320_Y_960 1.319
R_VINT2_4606 MINT3_X_320_Y_1280 MINT2_X_320_Y_1280 1.319
R_VINT2_4607 MINT3_X_320_Y_1600 MINT2_X_320_Y_1600 1.319
R_VINT2_4608 MINT3_X_320_Y_1920 MINT2_X_320_Y_1920 1.319
R_VINT2_4609 MINT3_X_320_Y_2240 MINT2_X_320_Y_2240 1.319
R_VINT2_4610 MINT3_X_320_Y_2560 MINT2_X_320_Y_2560 1.319
R_VINT2_4611 MINT3_X_320_Y_2880 MINT2_X_320_Y_2880 1.319
R_VINT2_4612 MINT3_X_320_Y_3200 MINT2_X_320_Y_3200 1.319
R_VINT2_4613 MINT3_X_320_Y_3520 MINT2_X_320_Y_3520 1.319
R_VINT2_4614 MINT3_X_320_Y_3840 MINT2_X_320_Y_3840 1.319
R_VINT2_4615 MINT3_X_320_Y_4160 MINT2_X_320_Y_4160 1.319
R_VINT2_4616 MINT3_X_320_Y_4480 MINT2_X_320_Y_4480 1.319
R_VINT2_4617 MINT3_X_320_Y_4800 MINT2_X_320_Y_4800 1.319
R_VINT2_4618 MINT3_X_320_Y_5120 MINT2_X_320_Y_5120 1.319
R_VINT2_4619 MINT3_X_320_Y_5440 MINT2_X_320_Y_5440 1.319
R_VINT2_4620 MINT3_X_320_Y_5760 MINT2_X_320_Y_5760 1.319
R_VINT2_4621 MINT3_X_320_Y_6080 MINT2_X_320_Y_6080 1.319
R_VINT2_4622 MINT3_X_320_Y_6400 MINT2_X_320_Y_6400 1.319
R_VINT2_4623 MINT3_X_320_Y_6720 MINT2_X_320_Y_6720 1.319
R_VINT2_4624 MINT3_X_320_Y_7040 MINT2_X_320_Y_7040 1.319
R_VINT2_4625 MINT3_X_320_Y_7360 MINT2_X_320_Y_7360 1.319
R_VINT2_4626 MINT3_X_320_Y_7680 MINT2_X_320_Y_7680 1.319
R_VINT2_4627 MINT3_X_320_Y_8000 MINT2_X_320_Y_8000 1.319
R_VINT2_4628 MINT3_X_320_Y_8320 MINT2_X_320_Y_8320 1.319
R_VINT2_4629 MINT3_X_320_Y_8640 MINT2_X_320_Y_8640 1.319
R_VINT2_4630 MINT3_X_320_Y_8960 MINT2_X_320_Y_8960 1.319
R_VINT2_4631 MINT3_X_320_Y_9280 MINT2_X_320_Y_9280 1.319
R_VINT2_4632 MINT3_X_320_Y_9600 MINT2_X_320_Y_9600 1.319
R_VINT2_4633 MINT3_X_320_Y_9920 MINT2_X_320_Y_9920 1.319
R_VINT2_4634 MINT3_X_640_Y_0 MINT2_X_640_Y_0 1.319
R_VINT2_4635 MINT3_X_640_Y_320 MINT2_X_640_Y_320 1.319
R_VINT2_4636 MINT3_X_640_Y_640 MINT2_X_640_Y_640 1.319
R_VINT2_4637 MINT3_X_640_Y_960 MINT2_X_640_Y_960 1.319
R_VINT2_4638 MINT3_X_640_Y_1280 MINT2_X_640_Y_1280 1.319
R_VINT2_4639 MINT3_X_640_Y_1600 MINT2_X_640_Y_1600 1.319
R_VINT2_4640 MINT3_X_640_Y_1920 MINT2_X_640_Y_1920 1.319
R_VINT2_4641 MINT3_X_640_Y_2240 MINT2_X_640_Y_2240 1.319
R_VINT2_4642 MINT3_X_640_Y_2560 MINT2_X_640_Y_2560 1.319
R_VINT2_4643 MINT3_X_640_Y_2880 MINT2_X_640_Y_2880 1.319
R_VINT2_4644 MINT3_X_640_Y_3200 MINT2_X_640_Y_3200 1.319
R_VINT2_4645 MINT3_X_640_Y_3520 MINT2_X_640_Y_3520 1.319
R_VINT2_4646 MINT3_X_640_Y_3840 MINT2_X_640_Y_3840 1.319
R_VINT2_4647 MINT3_X_640_Y_4160 MINT2_X_640_Y_4160 1.319
R_VINT2_4648 MINT3_X_640_Y_4480 MINT2_X_640_Y_4480 1.319
R_VINT2_4649 MINT3_X_640_Y_4800 MINT2_X_640_Y_4800 1.319
R_VINT2_4650 MINT3_X_640_Y_5120 MINT2_X_640_Y_5120 1.319
R_VINT2_4651 MINT3_X_640_Y_5440 MINT2_X_640_Y_5440 1.319
R_VINT2_4652 MINT3_X_640_Y_5760 MINT2_X_640_Y_5760 1.319
R_VINT2_4653 MINT3_X_640_Y_6080 MINT2_X_640_Y_6080 1.319
R_VINT2_4654 MINT3_X_640_Y_6400 MINT2_X_640_Y_6400 1.319
R_VINT2_4655 MINT3_X_640_Y_6720 MINT2_X_640_Y_6720 1.319
R_VINT2_4656 MINT3_X_640_Y_7040 MINT2_X_640_Y_7040 1.319
R_VINT2_4657 MINT3_X_640_Y_7360 MINT2_X_640_Y_7360 1.319
R_VINT2_4658 MINT3_X_640_Y_7680 MINT2_X_640_Y_7680 1.319
R_VINT2_4659 MINT3_X_640_Y_8000 MINT2_X_640_Y_8000 1.319
R_VINT2_4660 MINT3_X_640_Y_8320 MINT2_X_640_Y_8320 1.319
R_VINT2_4661 MINT3_X_640_Y_8640 MINT2_X_640_Y_8640 1.319
R_VINT2_4662 MINT3_X_640_Y_8960 MINT2_X_640_Y_8960 1.319
R_VINT2_4663 MINT3_X_640_Y_9280 MINT2_X_640_Y_9280 1.319
R_VINT2_4664 MINT3_X_640_Y_9600 MINT2_X_640_Y_9600 1.319
R_VINT2_4665 MINT3_X_640_Y_9920 MINT2_X_640_Y_9920 1.319
R_VINT2_4666 MINT3_X_960_Y_0 MINT2_X_960_Y_0 1.319
R_VINT2_4667 MINT3_X_960_Y_320 MINT2_X_960_Y_320 1.319
R_VINT2_4668 MINT3_X_960_Y_640 MINT2_X_960_Y_640 1.319
R_VINT2_4669 MINT3_X_960_Y_960 MINT2_X_960_Y_960 1.319
R_VINT2_4670 MINT3_X_960_Y_1280 MINT2_X_960_Y_1280 1.319
R_VINT2_4671 MINT3_X_960_Y_1600 MINT2_X_960_Y_1600 1.319
R_VINT2_4672 MINT3_X_960_Y_1920 MINT2_X_960_Y_1920 1.319
R_VINT2_4673 MINT3_X_960_Y_2240 MINT2_X_960_Y_2240 1.319
R_VINT2_4674 MINT3_X_960_Y_2560 MINT2_X_960_Y_2560 1.319
R_VINT2_4675 MINT3_X_960_Y_2880 MINT2_X_960_Y_2880 1.319
R_VINT2_4676 MINT3_X_960_Y_3200 MINT2_X_960_Y_3200 1.319
R_VINT2_4677 MINT3_X_960_Y_3520 MINT2_X_960_Y_3520 1.319
R_VINT2_4678 MINT3_X_960_Y_3840 MINT2_X_960_Y_3840 1.319
R_VINT2_4679 MINT3_X_960_Y_4160 MINT2_X_960_Y_4160 1.319
R_VINT2_4680 MINT3_X_960_Y_4480 MINT2_X_960_Y_4480 1.319
R_VINT2_4681 MINT3_X_960_Y_4800 MINT2_X_960_Y_4800 1.319
R_VINT2_4682 MINT3_X_960_Y_5120 MINT2_X_960_Y_5120 1.319
R_VINT2_4683 MINT3_X_960_Y_5440 MINT2_X_960_Y_5440 1.319
R_VINT2_4684 MINT3_X_960_Y_5760 MINT2_X_960_Y_5760 1.319
R_VINT2_4685 MINT3_X_960_Y_6080 MINT2_X_960_Y_6080 1.319
R_VINT2_4686 MINT3_X_960_Y_6400 MINT2_X_960_Y_6400 1.319
R_VINT2_4687 MINT3_X_960_Y_6720 MINT2_X_960_Y_6720 1.319
R_VINT2_4688 MINT3_X_960_Y_7040 MINT2_X_960_Y_7040 1.319
R_VINT2_4689 MINT3_X_960_Y_7360 MINT2_X_960_Y_7360 1.319
R_VINT2_4690 MINT3_X_960_Y_7680 MINT2_X_960_Y_7680 1.319
R_VINT2_4691 MINT3_X_960_Y_8000 MINT2_X_960_Y_8000 1.319
R_VINT2_4692 MINT3_X_960_Y_8320 MINT2_X_960_Y_8320 1.319
R_VINT2_4693 MINT3_X_960_Y_8640 MINT2_X_960_Y_8640 1.319
R_VINT2_4694 MINT3_X_960_Y_8960 MINT2_X_960_Y_8960 1.319
R_VINT2_4695 MINT3_X_960_Y_9280 MINT2_X_960_Y_9280 1.319
R_VINT2_4696 MINT3_X_960_Y_9600 MINT2_X_960_Y_9600 1.319
R_VINT2_4697 MINT3_X_960_Y_9920 MINT2_X_960_Y_9920 1.319
R_VINT2_4698 MINT3_X_1280_Y_0 MINT2_X_1280_Y_0 1.319
R_VINT2_4699 MINT3_X_1280_Y_320 MINT2_X_1280_Y_320 1.319
R_VINT2_4700 MINT3_X_1280_Y_640 MINT2_X_1280_Y_640 1.319
R_VINT2_4701 MINT3_X_1280_Y_960 MINT2_X_1280_Y_960 1.319
R_VINT2_4702 MINT3_X_1280_Y_1280 MINT2_X_1280_Y_1280 1.319
R_VINT2_4703 MINT3_X_1280_Y_1600 MINT2_X_1280_Y_1600 1.319
R_VINT2_4704 MINT3_X_1280_Y_1920 MINT2_X_1280_Y_1920 1.319
R_VINT2_4705 MINT3_X_1280_Y_2240 MINT2_X_1280_Y_2240 1.319
R_VINT2_4706 MINT3_X_1280_Y_2560 MINT2_X_1280_Y_2560 1.319
R_VINT2_4707 MINT3_X_1280_Y_2880 MINT2_X_1280_Y_2880 1.319
R_VINT2_4708 MINT3_X_1280_Y_3200 MINT2_X_1280_Y_3200 1.319
R_VINT2_4709 MINT3_X_1280_Y_3520 MINT2_X_1280_Y_3520 1.319
R_VINT2_4710 MINT3_X_1280_Y_3840 MINT2_X_1280_Y_3840 1.319
R_VINT2_4711 MINT3_X_1280_Y_4160 MINT2_X_1280_Y_4160 1.319
R_VINT2_4712 MINT3_X_1280_Y_4480 MINT2_X_1280_Y_4480 1.319
R_VINT2_4713 MINT3_X_1280_Y_4800 MINT2_X_1280_Y_4800 1.319
R_VINT2_4714 MINT3_X_1280_Y_5120 MINT2_X_1280_Y_5120 1.319
R_VINT2_4715 MINT3_X_1280_Y_5440 MINT2_X_1280_Y_5440 1.319
R_VINT2_4716 MINT3_X_1280_Y_5760 MINT2_X_1280_Y_5760 1.319
R_VINT2_4717 MINT3_X_1280_Y_6080 MINT2_X_1280_Y_6080 1.319
R_VINT2_4718 MINT3_X_1280_Y_6400 MINT2_X_1280_Y_6400 1.319
R_VINT2_4719 MINT3_X_1280_Y_6720 MINT2_X_1280_Y_6720 1.319
R_VINT2_4720 MINT3_X_1280_Y_7040 MINT2_X_1280_Y_7040 1.319
R_VINT2_4721 MINT3_X_1280_Y_7360 MINT2_X_1280_Y_7360 1.319
R_VINT2_4722 MINT3_X_1280_Y_7680 MINT2_X_1280_Y_7680 1.319
R_VINT2_4723 MINT3_X_1280_Y_8000 MINT2_X_1280_Y_8000 1.319
R_VINT2_4724 MINT3_X_1280_Y_8320 MINT2_X_1280_Y_8320 1.319
R_VINT2_4725 MINT3_X_1280_Y_8640 MINT2_X_1280_Y_8640 1.319
R_VINT2_4726 MINT3_X_1280_Y_8960 MINT2_X_1280_Y_8960 1.319
R_VINT2_4727 MINT3_X_1280_Y_9280 MINT2_X_1280_Y_9280 1.319
R_VINT2_4728 MINT3_X_1280_Y_9600 MINT2_X_1280_Y_9600 1.319
R_VINT2_4729 MINT3_X_1280_Y_9920 MINT2_X_1280_Y_9920 1.319
R_VINT2_4730 MINT3_X_1600_Y_0 MINT2_X_1600_Y_0 1.319
R_VINT2_4731 MINT3_X_1600_Y_320 MINT2_X_1600_Y_320 1.319
R_VINT2_4732 MINT3_X_1600_Y_640 MINT2_X_1600_Y_640 1.319
R_VINT2_4733 MINT3_X_1600_Y_960 MINT2_X_1600_Y_960 1.319
R_VINT2_4734 MINT3_X_1600_Y_1280 MINT2_X_1600_Y_1280 1.319
R_VINT2_4735 MINT3_X_1600_Y_1600 MINT2_X_1600_Y_1600 1.319
R_VINT2_4736 MINT3_X_1600_Y_1920 MINT2_X_1600_Y_1920 1.319
R_VINT2_4737 MINT3_X_1600_Y_2240 MINT2_X_1600_Y_2240 1.319
R_VINT2_4738 MINT3_X_1600_Y_2560 MINT2_X_1600_Y_2560 1.319
R_VINT2_4739 MINT3_X_1600_Y_2880 MINT2_X_1600_Y_2880 1.319
R_VINT2_4740 MINT3_X_1600_Y_3200 MINT2_X_1600_Y_3200 1.319
R_VINT2_4741 MINT3_X_1600_Y_3520 MINT2_X_1600_Y_3520 1.319
R_VINT2_4742 MINT3_X_1600_Y_3840 MINT2_X_1600_Y_3840 1.319
R_VINT2_4743 MINT3_X_1600_Y_4160 MINT2_X_1600_Y_4160 1.319
R_VINT2_4744 MINT3_X_1600_Y_4480 MINT2_X_1600_Y_4480 1.319
R_VINT2_4745 MINT3_X_1600_Y_4800 MINT2_X_1600_Y_4800 1.319
R_VINT2_4746 MINT3_X_1600_Y_5120 MINT2_X_1600_Y_5120 1.319
R_VINT2_4747 MINT3_X_1600_Y_5440 MINT2_X_1600_Y_5440 1.319
R_VINT2_4748 MINT3_X_1600_Y_5760 MINT2_X_1600_Y_5760 1.319
R_VINT2_4749 MINT3_X_1600_Y_6080 MINT2_X_1600_Y_6080 1.319
R_VINT2_4750 MINT3_X_1600_Y_6400 MINT2_X_1600_Y_6400 1.319
R_VINT2_4751 MINT3_X_1600_Y_6720 MINT2_X_1600_Y_6720 1.319
R_VINT2_4752 MINT3_X_1600_Y_7040 MINT2_X_1600_Y_7040 1.319
R_VINT2_4753 MINT3_X_1600_Y_7360 MINT2_X_1600_Y_7360 1.319
R_VINT2_4754 MINT3_X_1600_Y_7680 MINT2_X_1600_Y_7680 1.319
R_VINT2_4755 MINT3_X_1600_Y_8000 MINT2_X_1600_Y_8000 1.319
R_VINT2_4756 MINT3_X_1600_Y_8320 MINT2_X_1600_Y_8320 1.319
R_VINT2_4757 MINT3_X_1600_Y_8640 MINT2_X_1600_Y_8640 1.319
R_VINT2_4758 MINT3_X_1600_Y_8960 MINT2_X_1600_Y_8960 1.319
R_VINT2_4759 MINT3_X_1600_Y_9280 MINT2_X_1600_Y_9280 1.319
R_VINT2_4760 MINT3_X_1600_Y_9600 MINT2_X_1600_Y_9600 1.319
R_VINT2_4761 MINT3_X_1600_Y_9920 MINT2_X_1600_Y_9920 1.319
R_VINT2_4762 MINT3_X_1920_Y_0 MINT2_X_1920_Y_0 1.319
R_VINT2_4763 MINT3_X_1920_Y_320 MINT2_X_1920_Y_320 1.319
R_VINT2_4764 MINT3_X_1920_Y_640 MINT2_X_1920_Y_640 1.319
R_VINT2_4765 MINT3_X_1920_Y_960 MINT2_X_1920_Y_960 1.319
R_VINT2_4766 MINT3_X_1920_Y_1280 MINT2_X_1920_Y_1280 1.319
R_VINT2_4767 MINT3_X_1920_Y_1600 MINT2_X_1920_Y_1600 1.319
R_VINT2_4768 MINT3_X_1920_Y_1920 MINT2_X_1920_Y_1920 1.319
R_VINT2_4769 MINT3_X_1920_Y_2240 MINT2_X_1920_Y_2240 1.319
R_VINT2_4770 MINT3_X_1920_Y_2560 MINT2_X_1920_Y_2560 1.319
R_VINT2_4771 MINT3_X_1920_Y_2880 MINT2_X_1920_Y_2880 1.319
R_VINT2_4772 MINT3_X_1920_Y_3200 MINT2_X_1920_Y_3200 1.319
R_VINT2_4773 MINT3_X_1920_Y_3520 MINT2_X_1920_Y_3520 1.319
R_VINT2_4774 MINT3_X_1920_Y_3840 MINT2_X_1920_Y_3840 1.319
R_VINT2_4775 MINT3_X_1920_Y_4160 MINT2_X_1920_Y_4160 1.319
R_VINT2_4776 MINT3_X_1920_Y_4480 MINT2_X_1920_Y_4480 1.319
R_VINT2_4777 MINT3_X_1920_Y_4800 MINT2_X_1920_Y_4800 1.319
R_VINT2_4778 MINT3_X_1920_Y_5120 MINT2_X_1920_Y_5120 1.319
R_VINT2_4779 MINT3_X_1920_Y_5440 MINT2_X_1920_Y_5440 1.319
R_VINT2_4780 MINT3_X_1920_Y_5760 MINT2_X_1920_Y_5760 1.319
R_VINT2_4781 MINT3_X_1920_Y_6080 MINT2_X_1920_Y_6080 1.319
R_VINT2_4782 MINT3_X_1920_Y_6400 MINT2_X_1920_Y_6400 1.319
R_VINT2_4783 MINT3_X_1920_Y_6720 MINT2_X_1920_Y_6720 1.319
R_VINT2_4784 MINT3_X_1920_Y_7040 MINT2_X_1920_Y_7040 1.319
R_VINT2_4785 MINT3_X_1920_Y_7360 MINT2_X_1920_Y_7360 1.319
R_VINT2_4786 MINT3_X_1920_Y_7680 MINT2_X_1920_Y_7680 1.319
R_VINT2_4787 MINT3_X_1920_Y_8000 MINT2_X_1920_Y_8000 1.319
R_VINT2_4788 MINT3_X_1920_Y_8320 MINT2_X_1920_Y_8320 1.319
R_VINT2_4789 MINT3_X_1920_Y_8640 MINT2_X_1920_Y_8640 1.319
R_VINT2_4790 MINT3_X_1920_Y_8960 MINT2_X_1920_Y_8960 1.319
R_VINT2_4791 MINT3_X_1920_Y_9280 MINT2_X_1920_Y_9280 1.319
R_VINT2_4792 MINT3_X_1920_Y_9600 MINT2_X_1920_Y_9600 1.319
R_VINT2_4793 MINT3_X_1920_Y_9920 MINT2_X_1920_Y_9920 1.319
R_VINT2_4794 MINT3_X_2240_Y_0 MINT2_X_2240_Y_0 1.319
R_VINT2_4795 MINT3_X_2240_Y_320 MINT2_X_2240_Y_320 1.319
R_VINT2_4796 MINT3_X_2240_Y_640 MINT2_X_2240_Y_640 1.319
R_VINT2_4797 MINT3_X_2240_Y_960 MINT2_X_2240_Y_960 1.319
R_VINT2_4798 MINT3_X_2240_Y_1280 MINT2_X_2240_Y_1280 1.319
R_VINT2_4799 MINT3_X_2240_Y_1600 MINT2_X_2240_Y_1600 1.319
R_VINT2_4800 MINT3_X_2240_Y_1920 MINT2_X_2240_Y_1920 1.319
R_VINT2_4801 MINT3_X_2240_Y_2240 MINT2_X_2240_Y_2240 1.319
R_VINT2_4802 MINT3_X_2240_Y_2560 MINT2_X_2240_Y_2560 1.319
R_VINT2_4803 MINT3_X_2240_Y_2880 MINT2_X_2240_Y_2880 1.319
R_VINT2_4804 MINT3_X_2240_Y_3200 MINT2_X_2240_Y_3200 1.319
R_VINT2_4805 MINT3_X_2240_Y_3520 MINT2_X_2240_Y_3520 1.319
R_VINT2_4806 MINT3_X_2240_Y_3840 MINT2_X_2240_Y_3840 1.319
R_VINT2_4807 MINT3_X_2240_Y_4160 MINT2_X_2240_Y_4160 1.319
R_VINT2_4808 MINT3_X_2240_Y_4480 MINT2_X_2240_Y_4480 1.319
R_VINT2_4809 MINT3_X_2240_Y_4800 MINT2_X_2240_Y_4800 1.319
R_VINT2_4810 MINT3_X_2240_Y_5120 MINT2_X_2240_Y_5120 1.319
R_VINT2_4811 MINT3_X_2240_Y_5440 MINT2_X_2240_Y_5440 1.319
R_VINT2_4812 MINT3_X_2240_Y_5760 MINT2_X_2240_Y_5760 1.319
R_VINT2_4813 MINT3_X_2240_Y_6080 MINT2_X_2240_Y_6080 1.319
R_VINT2_4814 MINT3_X_2240_Y_6400 MINT2_X_2240_Y_6400 1.319
R_VINT2_4815 MINT3_X_2240_Y_6720 MINT2_X_2240_Y_6720 1.319
R_VINT2_4816 MINT3_X_2240_Y_7040 MINT2_X_2240_Y_7040 1.319
R_VINT2_4817 MINT3_X_2240_Y_7360 MINT2_X_2240_Y_7360 1.319
R_VINT2_4818 MINT3_X_2240_Y_7680 MINT2_X_2240_Y_7680 1.319
R_VINT2_4819 MINT3_X_2240_Y_8000 MINT2_X_2240_Y_8000 1.319
R_VINT2_4820 MINT3_X_2240_Y_8320 MINT2_X_2240_Y_8320 1.319
R_VINT2_4821 MINT3_X_2240_Y_8640 MINT2_X_2240_Y_8640 1.319
R_VINT2_4822 MINT3_X_2240_Y_8960 MINT2_X_2240_Y_8960 1.319
R_VINT2_4823 MINT3_X_2240_Y_9280 MINT2_X_2240_Y_9280 1.319
R_VINT2_4824 MINT3_X_2240_Y_9600 MINT2_X_2240_Y_9600 1.319
R_VINT2_4825 MINT3_X_2240_Y_9920 MINT2_X_2240_Y_9920 1.319
R_VINT2_4826 MINT3_X_2560_Y_0 MINT2_X_2560_Y_0 1.319
R_VINT2_4827 MINT3_X_2560_Y_320 MINT2_X_2560_Y_320 1.319
R_VINT2_4828 MINT3_X_2560_Y_640 MINT2_X_2560_Y_640 1.319
R_VINT2_4829 MINT3_X_2560_Y_960 MINT2_X_2560_Y_960 1.319
R_VINT2_4830 MINT3_X_2560_Y_1280 MINT2_X_2560_Y_1280 1.319
R_VINT2_4831 MINT3_X_2560_Y_1600 MINT2_X_2560_Y_1600 1.319
R_VINT2_4832 MINT3_X_2560_Y_1920 MINT2_X_2560_Y_1920 1.319
R_VINT2_4833 MINT3_X_2560_Y_2240 MINT2_X_2560_Y_2240 1.319
R_VINT2_4834 MINT3_X_2560_Y_2560 MINT2_X_2560_Y_2560 1.319
R_VINT2_4835 MINT3_X_2560_Y_2880 MINT2_X_2560_Y_2880 1.319
R_VINT2_4836 MINT3_X_2560_Y_3200 MINT2_X_2560_Y_3200 1.319
R_VINT2_4837 MINT3_X_2560_Y_3520 MINT2_X_2560_Y_3520 1.319
R_VINT2_4838 MINT3_X_2560_Y_3840 MINT2_X_2560_Y_3840 1.319
R_VINT2_4839 MINT3_X_2560_Y_4160 MINT2_X_2560_Y_4160 1.319
R_VINT2_4840 MINT3_X_2560_Y_4480 MINT2_X_2560_Y_4480 1.319
R_VINT2_4841 MINT3_X_2560_Y_4800 MINT2_X_2560_Y_4800 1.319
R_VINT2_4842 MINT3_X_2560_Y_5120 MINT2_X_2560_Y_5120 1.319
R_VINT2_4843 MINT3_X_2560_Y_5440 MINT2_X_2560_Y_5440 1.319
R_VINT2_4844 MINT3_X_2560_Y_5760 MINT2_X_2560_Y_5760 1.319
R_VINT2_4845 MINT3_X_2560_Y_6080 MINT2_X_2560_Y_6080 1.319
R_VINT2_4846 MINT3_X_2560_Y_6400 MINT2_X_2560_Y_6400 1.319
R_VINT2_4847 MINT3_X_2560_Y_6720 MINT2_X_2560_Y_6720 1.319
R_VINT2_4848 MINT3_X_2560_Y_7040 MINT2_X_2560_Y_7040 1.319
R_VINT2_4849 MINT3_X_2560_Y_7360 MINT2_X_2560_Y_7360 1.319
R_VINT2_4850 MINT3_X_2560_Y_7680 MINT2_X_2560_Y_7680 1.319
R_VINT2_4851 MINT3_X_2560_Y_8000 MINT2_X_2560_Y_8000 1.319
R_VINT2_4852 MINT3_X_2560_Y_8320 MINT2_X_2560_Y_8320 1.319
R_VINT2_4853 MINT3_X_2560_Y_8640 MINT2_X_2560_Y_8640 1.319
R_VINT2_4854 MINT3_X_2560_Y_8960 MINT2_X_2560_Y_8960 1.319
R_VINT2_4855 MINT3_X_2560_Y_9280 MINT2_X_2560_Y_9280 1.319
R_VINT2_4856 MINT3_X_2560_Y_9600 MINT2_X_2560_Y_9600 1.319
R_VINT2_4857 MINT3_X_2560_Y_9920 MINT2_X_2560_Y_9920 1.319
R_VINT2_4858 MINT3_X_2880_Y_0 MINT2_X_2880_Y_0 1.319
R_VINT2_4859 MINT3_X_2880_Y_320 MINT2_X_2880_Y_320 1.319
R_VINT2_4860 MINT3_X_2880_Y_640 MINT2_X_2880_Y_640 1.319
R_VINT2_4861 MINT3_X_2880_Y_960 MINT2_X_2880_Y_960 1.319
R_VINT2_4862 MINT3_X_2880_Y_1280 MINT2_X_2880_Y_1280 1.319
R_VINT2_4863 MINT3_X_2880_Y_1600 MINT2_X_2880_Y_1600 1.319
R_VINT2_4864 MINT3_X_2880_Y_1920 MINT2_X_2880_Y_1920 1.319
R_VINT2_4865 MINT3_X_2880_Y_2240 MINT2_X_2880_Y_2240 1.319
R_VINT2_4866 MINT3_X_2880_Y_2560 MINT2_X_2880_Y_2560 1.319
R_VINT2_4867 MINT3_X_2880_Y_2880 MINT2_X_2880_Y_2880 1.319
R_VINT2_4868 MINT3_X_2880_Y_3200 MINT2_X_2880_Y_3200 1.319
R_VINT2_4869 MINT3_X_2880_Y_3520 MINT2_X_2880_Y_3520 1.319
R_VINT2_4870 MINT3_X_2880_Y_3840 MINT2_X_2880_Y_3840 1.319
R_VINT2_4871 MINT3_X_2880_Y_4160 MINT2_X_2880_Y_4160 1.319
R_VINT2_4872 MINT3_X_2880_Y_4480 MINT2_X_2880_Y_4480 1.319
R_VINT2_4873 MINT3_X_2880_Y_4800 MINT2_X_2880_Y_4800 1.319
R_VINT2_4874 MINT3_X_2880_Y_5120 MINT2_X_2880_Y_5120 1.319
R_VINT2_4875 MINT3_X_2880_Y_5440 MINT2_X_2880_Y_5440 1.319
R_VINT2_4876 MINT3_X_2880_Y_5760 MINT2_X_2880_Y_5760 1.319
R_VINT2_4877 MINT3_X_2880_Y_6080 MINT2_X_2880_Y_6080 1.319
R_VINT2_4878 MINT3_X_2880_Y_6400 MINT2_X_2880_Y_6400 1.319
R_VINT2_4879 MINT3_X_2880_Y_6720 MINT2_X_2880_Y_6720 1.319
R_VINT2_4880 MINT3_X_2880_Y_7040 MINT2_X_2880_Y_7040 1.319
R_VINT2_4881 MINT3_X_2880_Y_7360 MINT2_X_2880_Y_7360 1.319
R_VINT2_4882 MINT3_X_2880_Y_7680 MINT2_X_2880_Y_7680 1.319
R_VINT2_4883 MINT3_X_2880_Y_8000 MINT2_X_2880_Y_8000 1.319
R_VINT2_4884 MINT3_X_2880_Y_8320 MINT2_X_2880_Y_8320 1.319
R_VINT2_4885 MINT3_X_2880_Y_8640 MINT2_X_2880_Y_8640 1.319
R_VINT2_4886 MINT3_X_2880_Y_8960 MINT2_X_2880_Y_8960 1.319
R_VINT2_4887 MINT3_X_2880_Y_9280 MINT2_X_2880_Y_9280 1.319
R_VINT2_4888 MINT3_X_2880_Y_9600 MINT2_X_2880_Y_9600 1.319
R_VINT2_4889 MINT3_X_2880_Y_9920 MINT2_X_2880_Y_9920 1.319
R_VINT2_4890 MINT3_X_3200_Y_0 MINT2_X_3200_Y_0 1.319
R_VINT2_4891 MINT3_X_3200_Y_320 MINT2_X_3200_Y_320 1.319
R_VINT2_4892 MINT3_X_3200_Y_640 MINT2_X_3200_Y_640 1.319
R_VINT2_4893 MINT3_X_3200_Y_960 MINT2_X_3200_Y_960 1.319
R_VINT2_4894 MINT3_X_3200_Y_1280 MINT2_X_3200_Y_1280 1.319
R_VINT2_4895 MINT3_X_3200_Y_1600 MINT2_X_3200_Y_1600 1.319
R_VINT2_4896 MINT3_X_3200_Y_1920 MINT2_X_3200_Y_1920 1.319
R_VINT2_4897 MINT3_X_3200_Y_2240 MINT2_X_3200_Y_2240 1.319
R_VINT2_4898 MINT3_X_3200_Y_2560 MINT2_X_3200_Y_2560 1.319
R_VINT2_4899 MINT3_X_3200_Y_2880 MINT2_X_3200_Y_2880 1.319
R_VINT2_4900 MINT3_X_3200_Y_3200 MINT2_X_3200_Y_3200 1.319
R_VINT2_4901 MINT3_X_3200_Y_3520 MINT2_X_3200_Y_3520 1.319
R_VINT2_4902 MINT3_X_3200_Y_3840 MINT2_X_3200_Y_3840 1.319
R_VINT2_4903 MINT3_X_3200_Y_4160 MINT2_X_3200_Y_4160 1.319
R_VINT2_4904 MINT3_X_3200_Y_4480 MINT2_X_3200_Y_4480 1.319
R_VINT2_4905 MINT3_X_3200_Y_4800 MINT2_X_3200_Y_4800 1.319
R_VINT2_4906 MINT3_X_3200_Y_5120 MINT2_X_3200_Y_5120 1.319
R_VINT2_4907 MINT3_X_3200_Y_5440 MINT2_X_3200_Y_5440 1.319
R_VINT2_4908 MINT3_X_3200_Y_5760 MINT2_X_3200_Y_5760 1.319
R_VINT2_4909 MINT3_X_3200_Y_6080 MINT2_X_3200_Y_6080 1.319
R_VINT2_4910 MINT3_X_3200_Y_6400 MINT2_X_3200_Y_6400 1.319
R_VINT2_4911 MINT3_X_3200_Y_6720 MINT2_X_3200_Y_6720 1.319
R_VINT2_4912 MINT3_X_3200_Y_7040 MINT2_X_3200_Y_7040 1.319
R_VINT2_4913 MINT3_X_3200_Y_7360 MINT2_X_3200_Y_7360 1.319
R_VINT2_4914 MINT3_X_3200_Y_7680 MINT2_X_3200_Y_7680 1.319
R_VINT2_4915 MINT3_X_3200_Y_8000 MINT2_X_3200_Y_8000 1.319
R_VINT2_4916 MINT3_X_3200_Y_8320 MINT2_X_3200_Y_8320 1.319
R_VINT2_4917 MINT3_X_3200_Y_8640 MINT2_X_3200_Y_8640 1.319
R_VINT2_4918 MINT3_X_3200_Y_8960 MINT2_X_3200_Y_8960 1.319
R_VINT2_4919 MINT3_X_3200_Y_9280 MINT2_X_3200_Y_9280 1.319
R_VINT2_4920 MINT3_X_3200_Y_9600 MINT2_X_3200_Y_9600 1.319
R_VINT2_4921 MINT3_X_3200_Y_9920 MINT2_X_3200_Y_9920 1.319
R_VINT2_4922 MINT3_X_3520_Y_0 MINT2_X_3520_Y_0 1.319
R_VINT2_4923 MINT3_X_3520_Y_320 MINT2_X_3520_Y_320 1.319
R_VINT2_4924 MINT3_X_3520_Y_640 MINT2_X_3520_Y_640 1.319
R_VINT2_4925 MINT3_X_3520_Y_960 MINT2_X_3520_Y_960 1.319
R_VINT2_4926 MINT3_X_3520_Y_1280 MINT2_X_3520_Y_1280 1.319
R_VINT2_4927 MINT3_X_3520_Y_1600 MINT2_X_3520_Y_1600 1.319
R_VINT2_4928 MINT3_X_3520_Y_1920 MINT2_X_3520_Y_1920 1.319
R_VINT2_4929 MINT3_X_3520_Y_2240 MINT2_X_3520_Y_2240 1.319
R_VINT2_4930 MINT3_X_3520_Y_2560 MINT2_X_3520_Y_2560 1.319
R_VINT2_4931 MINT3_X_3520_Y_2880 MINT2_X_3520_Y_2880 1.319
R_VINT2_4932 MINT3_X_3520_Y_3200 MINT2_X_3520_Y_3200 1.319
R_VINT2_4933 MINT3_X_3520_Y_3520 MINT2_X_3520_Y_3520 1.319
R_VINT2_4934 MINT3_X_3520_Y_3840 MINT2_X_3520_Y_3840 1.319
R_VINT2_4935 MINT3_X_3520_Y_4160 MINT2_X_3520_Y_4160 1.319
R_VINT2_4936 MINT3_X_3520_Y_4480 MINT2_X_3520_Y_4480 1.319
R_VINT2_4937 MINT3_X_3520_Y_4800 MINT2_X_3520_Y_4800 1.319
R_VINT2_4938 MINT3_X_3520_Y_5120 MINT2_X_3520_Y_5120 1.319
R_VINT2_4939 MINT3_X_3520_Y_5440 MINT2_X_3520_Y_5440 1.319
R_VINT2_4940 MINT3_X_3520_Y_5760 MINT2_X_3520_Y_5760 1.319
R_VINT2_4941 MINT3_X_3520_Y_6080 MINT2_X_3520_Y_6080 1.319
R_VINT2_4942 MINT3_X_3520_Y_6400 MINT2_X_3520_Y_6400 1.319
R_VINT2_4943 MINT3_X_3520_Y_6720 MINT2_X_3520_Y_6720 1.319
R_VINT2_4944 MINT3_X_3520_Y_7040 MINT2_X_3520_Y_7040 1.319
R_VINT2_4945 MINT3_X_3520_Y_7360 MINT2_X_3520_Y_7360 1.319
R_VINT2_4946 MINT3_X_3520_Y_7680 MINT2_X_3520_Y_7680 1.319
R_VINT2_4947 MINT3_X_3520_Y_8000 MINT2_X_3520_Y_8000 1.319
R_VINT2_4948 MINT3_X_3520_Y_8320 MINT2_X_3520_Y_8320 1.319
R_VINT2_4949 MINT3_X_3520_Y_8640 MINT2_X_3520_Y_8640 1.319
R_VINT2_4950 MINT3_X_3520_Y_8960 MINT2_X_3520_Y_8960 1.319
R_VINT2_4951 MINT3_X_3520_Y_9280 MINT2_X_3520_Y_9280 1.319
R_VINT2_4952 MINT3_X_3520_Y_9600 MINT2_X_3520_Y_9600 1.319
R_VINT2_4953 MINT3_X_3520_Y_9920 MINT2_X_3520_Y_9920 1.319
R_VINT2_4954 MINT3_X_3840_Y_0 MINT2_X_3840_Y_0 1.319
R_VINT2_4955 MINT3_X_3840_Y_320 MINT2_X_3840_Y_320 1.319
R_VINT2_4956 MINT3_X_3840_Y_640 MINT2_X_3840_Y_640 1.319
R_VINT2_4957 MINT3_X_3840_Y_960 MINT2_X_3840_Y_960 1.319
R_VINT2_4958 MINT3_X_3840_Y_1280 MINT2_X_3840_Y_1280 1.319
R_VINT2_4959 MINT3_X_3840_Y_1600 MINT2_X_3840_Y_1600 1.319
R_VINT2_4960 MINT3_X_3840_Y_1920 MINT2_X_3840_Y_1920 1.319
R_VINT2_4961 MINT3_X_3840_Y_2240 MINT2_X_3840_Y_2240 1.319
R_VINT2_4962 MINT3_X_3840_Y_2560 MINT2_X_3840_Y_2560 1.319
R_VINT2_4963 MINT3_X_3840_Y_2880 MINT2_X_3840_Y_2880 1.319
R_VINT2_4964 MINT3_X_3840_Y_3200 MINT2_X_3840_Y_3200 1.319
R_VINT2_4965 MINT3_X_3840_Y_3520 MINT2_X_3840_Y_3520 1.319
R_VINT2_4966 MINT3_X_3840_Y_3840 MINT2_X_3840_Y_3840 1.319
R_VINT2_4967 MINT3_X_3840_Y_4160 MINT2_X_3840_Y_4160 1.319
R_VINT2_4968 MINT3_X_3840_Y_4480 MINT2_X_3840_Y_4480 1.319
R_VINT2_4969 MINT3_X_3840_Y_4800 MINT2_X_3840_Y_4800 1.319
R_VINT2_4970 MINT3_X_3840_Y_5120 MINT2_X_3840_Y_5120 1.319
R_VINT2_4971 MINT3_X_3840_Y_5440 MINT2_X_3840_Y_5440 1.319
R_VINT2_4972 MINT3_X_3840_Y_5760 MINT2_X_3840_Y_5760 1.319
R_VINT2_4973 MINT3_X_3840_Y_6080 MINT2_X_3840_Y_6080 1.319
R_VINT2_4974 MINT3_X_3840_Y_6400 MINT2_X_3840_Y_6400 1.319
R_VINT2_4975 MINT3_X_3840_Y_6720 MINT2_X_3840_Y_6720 1.319
R_VINT2_4976 MINT3_X_3840_Y_7040 MINT2_X_3840_Y_7040 1.319
R_VINT2_4977 MINT3_X_3840_Y_7360 MINT2_X_3840_Y_7360 1.319
R_VINT2_4978 MINT3_X_3840_Y_7680 MINT2_X_3840_Y_7680 1.319
R_VINT2_4979 MINT3_X_3840_Y_8000 MINT2_X_3840_Y_8000 1.319
R_VINT2_4980 MINT3_X_3840_Y_8320 MINT2_X_3840_Y_8320 1.319
R_VINT2_4981 MINT3_X_3840_Y_8640 MINT2_X_3840_Y_8640 1.319
R_VINT2_4982 MINT3_X_3840_Y_8960 MINT2_X_3840_Y_8960 1.319
R_VINT2_4983 MINT3_X_3840_Y_9280 MINT2_X_3840_Y_9280 1.319
R_VINT2_4984 MINT3_X_3840_Y_9600 MINT2_X_3840_Y_9600 1.319
R_VINT2_4985 MINT3_X_3840_Y_9920 MINT2_X_3840_Y_9920 1.319
R_VINT2_4986 MINT3_X_4160_Y_0 MINT2_X_4160_Y_0 1.319
R_VINT2_4987 MINT3_X_4160_Y_320 MINT2_X_4160_Y_320 1.319
R_VINT2_4988 MINT3_X_4160_Y_640 MINT2_X_4160_Y_640 1.319
R_VINT2_4989 MINT3_X_4160_Y_960 MINT2_X_4160_Y_960 1.319
R_VINT2_4990 MINT3_X_4160_Y_1280 MINT2_X_4160_Y_1280 1.319
R_VINT2_4991 MINT3_X_4160_Y_1600 MINT2_X_4160_Y_1600 1.319
R_VINT2_4992 MINT3_X_4160_Y_1920 MINT2_X_4160_Y_1920 1.319
R_VINT2_4993 MINT3_X_4160_Y_2240 MINT2_X_4160_Y_2240 1.319
R_VINT2_4994 MINT3_X_4160_Y_2560 MINT2_X_4160_Y_2560 1.319
R_VINT2_4995 MINT3_X_4160_Y_2880 MINT2_X_4160_Y_2880 1.319
R_VINT2_4996 MINT3_X_4160_Y_3200 MINT2_X_4160_Y_3200 1.319
R_VINT2_4997 MINT3_X_4160_Y_3520 MINT2_X_4160_Y_3520 1.319
R_VINT2_4998 MINT3_X_4160_Y_3840 MINT2_X_4160_Y_3840 1.319
R_VINT2_4999 MINT3_X_4160_Y_4160 MINT2_X_4160_Y_4160 1.319
R_VINT2_5000 MINT3_X_4160_Y_4480 MINT2_X_4160_Y_4480 1.319
R_VINT2_5001 MINT3_X_4160_Y_4800 MINT2_X_4160_Y_4800 1.319
R_VINT2_5002 MINT3_X_4160_Y_5120 MINT2_X_4160_Y_5120 1.319
R_VINT2_5003 MINT3_X_4160_Y_5440 MINT2_X_4160_Y_5440 1.319
R_VINT2_5004 MINT3_X_4160_Y_5760 MINT2_X_4160_Y_5760 1.319
R_VINT2_5005 MINT3_X_4160_Y_6080 MINT2_X_4160_Y_6080 1.319
R_VINT2_5006 MINT3_X_4160_Y_6400 MINT2_X_4160_Y_6400 1.319
R_VINT2_5007 MINT3_X_4160_Y_6720 MINT2_X_4160_Y_6720 1.319
R_VINT2_5008 MINT3_X_4160_Y_7040 MINT2_X_4160_Y_7040 1.319
R_VINT2_5009 MINT3_X_4160_Y_7360 MINT2_X_4160_Y_7360 1.319
R_VINT2_5010 MINT3_X_4160_Y_7680 MINT2_X_4160_Y_7680 1.319
R_VINT2_5011 MINT3_X_4160_Y_8000 MINT2_X_4160_Y_8000 1.319
R_VINT2_5012 MINT3_X_4160_Y_8320 MINT2_X_4160_Y_8320 1.319
R_VINT2_5013 MINT3_X_4160_Y_8640 MINT2_X_4160_Y_8640 1.319
R_VINT2_5014 MINT3_X_4160_Y_8960 MINT2_X_4160_Y_8960 1.319
R_VINT2_5015 MINT3_X_4160_Y_9280 MINT2_X_4160_Y_9280 1.319
R_VINT2_5016 MINT3_X_4160_Y_9600 MINT2_X_4160_Y_9600 1.319
R_VINT2_5017 MINT3_X_4160_Y_9920 MINT2_X_4160_Y_9920 1.319
R_VINT2_5018 MINT3_X_4480_Y_0 MINT2_X_4480_Y_0 1.319
R_VINT2_5019 MINT3_X_4480_Y_320 MINT2_X_4480_Y_320 1.319
R_VINT2_5020 MINT3_X_4480_Y_640 MINT2_X_4480_Y_640 1.319
R_VINT2_5021 MINT3_X_4480_Y_960 MINT2_X_4480_Y_960 1.319
R_VINT2_5022 MINT3_X_4480_Y_1280 MINT2_X_4480_Y_1280 1.319
R_VINT2_5023 MINT3_X_4480_Y_1600 MINT2_X_4480_Y_1600 1.319
R_VINT2_5024 MINT3_X_4480_Y_1920 MINT2_X_4480_Y_1920 1.319
R_VINT2_5025 MINT3_X_4480_Y_2240 MINT2_X_4480_Y_2240 1.319
R_VINT2_5026 MINT3_X_4480_Y_2560 MINT2_X_4480_Y_2560 1.319
R_VINT2_5027 MINT3_X_4480_Y_2880 MINT2_X_4480_Y_2880 1.319
R_VINT2_5028 MINT3_X_4480_Y_3200 MINT2_X_4480_Y_3200 1.319
R_VINT2_5029 MINT3_X_4480_Y_3520 MINT2_X_4480_Y_3520 1.319
R_VINT2_5030 MINT3_X_4480_Y_3840 MINT2_X_4480_Y_3840 1.319
R_VINT2_5031 MINT3_X_4480_Y_4160 MINT2_X_4480_Y_4160 1.319
R_VINT2_5032 MINT3_X_4480_Y_4480 MINT2_X_4480_Y_4480 1.319
R_VINT2_5033 MINT3_X_4480_Y_4800 MINT2_X_4480_Y_4800 1.319
R_VINT2_5034 MINT3_X_4480_Y_5120 MINT2_X_4480_Y_5120 1.319
R_VINT2_5035 MINT3_X_4480_Y_5440 MINT2_X_4480_Y_5440 1.319
R_VINT2_5036 MINT3_X_4480_Y_5760 MINT2_X_4480_Y_5760 1.319
R_VINT2_5037 MINT3_X_4480_Y_6080 MINT2_X_4480_Y_6080 1.319
R_VINT2_5038 MINT3_X_4480_Y_6400 MINT2_X_4480_Y_6400 1.319
R_VINT2_5039 MINT3_X_4480_Y_6720 MINT2_X_4480_Y_6720 1.319
R_VINT2_5040 MINT3_X_4480_Y_7040 MINT2_X_4480_Y_7040 1.319
R_VINT2_5041 MINT3_X_4480_Y_7360 MINT2_X_4480_Y_7360 1.319
R_VINT2_5042 MINT3_X_4480_Y_7680 MINT2_X_4480_Y_7680 1.319
R_VINT2_5043 MINT3_X_4480_Y_8000 MINT2_X_4480_Y_8000 1.319
R_VINT2_5044 MINT3_X_4480_Y_8320 MINT2_X_4480_Y_8320 1.319
R_VINT2_5045 MINT3_X_4480_Y_8640 MINT2_X_4480_Y_8640 1.319
R_VINT2_5046 MINT3_X_4480_Y_8960 MINT2_X_4480_Y_8960 1.319
R_VINT2_5047 MINT3_X_4480_Y_9280 MINT2_X_4480_Y_9280 1.319
R_VINT2_5048 MINT3_X_4480_Y_9600 MINT2_X_4480_Y_9600 1.319
R_VINT2_5049 MINT3_X_4480_Y_9920 MINT2_X_4480_Y_9920 1.319
R_VINT2_5050 MINT3_X_4800_Y_0 MINT2_X_4800_Y_0 1.319
R_VINT2_5051 MINT3_X_4800_Y_320 MINT2_X_4800_Y_320 1.319
R_VINT2_5052 MINT3_X_4800_Y_640 MINT2_X_4800_Y_640 1.319
R_VINT2_5053 MINT3_X_4800_Y_960 MINT2_X_4800_Y_960 1.319
R_VINT2_5054 MINT3_X_4800_Y_1280 MINT2_X_4800_Y_1280 1.319
R_VINT2_5055 MINT3_X_4800_Y_1600 MINT2_X_4800_Y_1600 1.319
R_VINT2_5056 MINT3_X_4800_Y_1920 MINT2_X_4800_Y_1920 1.319
R_VINT2_5057 MINT3_X_4800_Y_2240 MINT2_X_4800_Y_2240 1.319
R_VINT2_5058 MINT3_X_4800_Y_2560 MINT2_X_4800_Y_2560 1.319
R_VINT2_5059 MINT3_X_4800_Y_2880 MINT2_X_4800_Y_2880 1.319
R_VINT2_5060 MINT3_X_4800_Y_3200 MINT2_X_4800_Y_3200 1.319
R_VINT2_5061 MINT3_X_4800_Y_3520 MINT2_X_4800_Y_3520 1.319
R_VINT2_5062 MINT3_X_4800_Y_3840 MINT2_X_4800_Y_3840 1.319
R_VINT2_5063 MINT3_X_4800_Y_4160 MINT2_X_4800_Y_4160 1.319
R_VINT2_5064 MINT3_X_4800_Y_4480 MINT2_X_4800_Y_4480 1.319
R_VINT2_5065 MINT3_X_4800_Y_4800 MINT2_X_4800_Y_4800 1.319
R_VINT2_5066 MINT3_X_4800_Y_5120 MINT2_X_4800_Y_5120 1.319
R_VINT2_5067 MINT3_X_4800_Y_5440 MINT2_X_4800_Y_5440 1.319
R_VINT2_5068 MINT3_X_4800_Y_5760 MINT2_X_4800_Y_5760 1.319
R_VINT2_5069 MINT3_X_4800_Y_6080 MINT2_X_4800_Y_6080 1.319
R_VINT2_5070 MINT3_X_4800_Y_6400 MINT2_X_4800_Y_6400 1.319
R_VINT2_5071 MINT3_X_4800_Y_6720 MINT2_X_4800_Y_6720 1.319
R_VINT2_5072 MINT3_X_4800_Y_7040 MINT2_X_4800_Y_7040 1.319
R_VINT2_5073 MINT3_X_4800_Y_7360 MINT2_X_4800_Y_7360 1.319
R_VINT2_5074 MINT3_X_4800_Y_7680 MINT2_X_4800_Y_7680 1.319
R_VINT2_5075 MINT3_X_4800_Y_8000 MINT2_X_4800_Y_8000 1.319
R_VINT2_5076 MINT3_X_4800_Y_8320 MINT2_X_4800_Y_8320 1.319
R_VINT2_5077 MINT3_X_4800_Y_8640 MINT2_X_4800_Y_8640 1.319
R_VINT2_5078 MINT3_X_4800_Y_8960 MINT2_X_4800_Y_8960 1.319
R_VINT2_5079 MINT3_X_4800_Y_9280 MINT2_X_4800_Y_9280 1.319
R_VINT2_5080 MINT3_X_4800_Y_9600 MINT2_X_4800_Y_9600 1.319
R_VINT2_5081 MINT3_X_4800_Y_9920 MINT2_X_4800_Y_9920 1.319
R_VINT2_5082 MINT3_X_5120_Y_0 MINT2_X_5120_Y_0 1.319
R_VINT2_5083 MINT3_X_5120_Y_320 MINT2_X_5120_Y_320 1.319
R_VINT2_5084 MINT3_X_5120_Y_640 MINT2_X_5120_Y_640 1.319
R_VINT2_5085 MINT3_X_5120_Y_960 MINT2_X_5120_Y_960 1.319
R_VINT2_5086 MINT3_X_5120_Y_1280 MINT2_X_5120_Y_1280 1.319
R_VINT2_5087 MINT3_X_5120_Y_1600 MINT2_X_5120_Y_1600 1.319
R_VINT2_5088 MINT3_X_5120_Y_1920 MINT2_X_5120_Y_1920 1.319
R_VINT2_5089 MINT3_X_5120_Y_2240 MINT2_X_5120_Y_2240 1.319
R_VINT2_5090 MINT3_X_5120_Y_2560 MINT2_X_5120_Y_2560 1.319
R_VINT2_5091 MINT3_X_5120_Y_2880 MINT2_X_5120_Y_2880 1.319
R_VINT2_5092 MINT3_X_5120_Y_3200 MINT2_X_5120_Y_3200 1.319
R_VINT2_5093 MINT3_X_5120_Y_3520 MINT2_X_5120_Y_3520 1.319
R_VINT2_5094 MINT3_X_5120_Y_3840 MINT2_X_5120_Y_3840 1.319
R_VINT2_5095 MINT3_X_5120_Y_4160 MINT2_X_5120_Y_4160 1.319
R_VINT2_5096 MINT3_X_5120_Y_4480 MINT2_X_5120_Y_4480 1.319
R_VINT2_5097 MINT3_X_5120_Y_4800 MINT2_X_5120_Y_4800 1.319
R_VINT2_5098 MINT3_X_5120_Y_5120 MINT2_X_5120_Y_5120 1.319
R_VINT2_5099 MINT3_X_5120_Y_5440 MINT2_X_5120_Y_5440 1.319
R_VINT2_5100 MINT3_X_5120_Y_5760 MINT2_X_5120_Y_5760 1.319
R_VINT2_5101 MINT3_X_5120_Y_6080 MINT2_X_5120_Y_6080 1.319
R_VINT2_5102 MINT3_X_5120_Y_6400 MINT2_X_5120_Y_6400 1.319
R_VINT2_5103 MINT3_X_5120_Y_6720 MINT2_X_5120_Y_6720 1.319
R_VINT2_5104 MINT3_X_5120_Y_7040 MINT2_X_5120_Y_7040 1.319
R_VINT2_5105 MINT3_X_5120_Y_7360 MINT2_X_5120_Y_7360 1.319
R_VINT2_5106 MINT3_X_5120_Y_7680 MINT2_X_5120_Y_7680 1.319
R_VINT2_5107 MINT3_X_5120_Y_8000 MINT2_X_5120_Y_8000 1.319
R_VINT2_5108 MINT3_X_5120_Y_8320 MINT2_X_5120_Y_8320 1.319
R_VINT2_5109 MINT3_X_5120_Y_8640 MINT2_X_5120_Y_8640 1.319
R_VINT2_5110 MINT3_X_5120_Y_8960 MINT2_X_5120_Y_8960 1.319
R_VINT2_5111 MINT3_X_5120_Y_9280 MINT2_X_5120_Y_9280 1.319
R_VINT2_5112 MINT3_X_5120_Y_9600 MINT2_X_5120_Y_9600 1.319
R_VINT2_5113 MINT3_X_5120_Y_9920 MINT2_X_5120_Y_9920 1.319
R_VINT2_5114 MINT3_X_5440_Y_0 MINT2_X_5440_Y_0 1.319
R_VINT2_5115 MINT3_X_5440_Y_320 MINT2_X_5440_Y_320 1.319
R_VINT2_5116 MINT3_X_5440_Y_640 MINT2_X_5440_Y_640 1.319
R_VINT2_5117 MINT3_X_5440_Y_960 MINT2_X_5440_Y_960 1.319
R_VINT2_5118 MINT3_X_5440_Y_1280 MINT2_X_5440_Y_1280 1.319
R_VINT2_5119 MINT3_X_5440_Y_1600 MINT2_X_5440_Y_1600 1.319
R_VINT2_5120 MINT3_X_5440_Y_1920 MINT2_X_5440_Y_1920 1.319
R_VINT2_5121 MINT3_X_5440_Y_2240 MINT2_X_5440_Y_2240 1.319
R_VINT2_5122 MINT3_X_5440_Y_2560 MINT2_X_5440_Y_2560 1.319
R_VINT2_5123 MINT3_X_5440_Y_2880 MINT2_X_5440_Y_2880 1.319
R_VINT2_5124 MINT3_X_5440_Y_3200 MINT2_X_5440_Y_3200 1.319
R_VINT2_5125 MINT3_X_5440_Y_3520 MINT2_X_5440_Y_3520 1.319
R_VINT2_5126 MINT3_X_5440_Y_3840 MINT2_X_5440_Y_3840 1.319
R_VINT2_5127 MINT3_X_5440_Y_4160 MINT2_X_5440_Y_4160 1.319
R_VINT2_5128 MINT3_X_5440_Y_4480 MINT2_X_5440_Y_4480 1.319
R_VINT2_5129 MINT3_X_5440_Y_4800 MINT2_X_5440_Y_4800 1.319
R_VINT2_5130 MINT3_X_5440_Y_5120 MINT2_X_5440_Y_5120 1.319
R_VINT2_5131 MINT3_X_5440_Y_5440 MINT2_X_5440_Y_5440 1.319
R_VINT2_5132 MINT3_X_5440_Y_5760 MINT2_X_5440_Y_5760 1.319
R_VINT2_5133 MINT3_X_5440_Y_6080 MINT2_X_5440_Y_6080 1.319
R_VINT2_5134 MINT3_X_5440_Y_6400 MINT2_X_5440_Y_6400 1.319
R_VINT2_5135 MINT3_X_5440_Y_6720 MINT2_X_5440_Y_6720 1.319
R_VINT2_5136 MINT3_X_5440_Y_7040 MINT2_X_5440_Y_7040 1.319
R_VINT2_5137 MINT3_X_5440_Y_7360 MINT2_X_5440_Y_7360 1.319
R_VINT2_5138 MINT3_X_5440_Y_7680 MINT2_X_5440_Y_7680 1.319
R_VINT2_5139 MINT3_X_5440_Y_8000 MINT2_X_5440_Y_8000 1.319
R_VINT2_5140 MINT3_X_5440_Y_8320 MINT2_X_5440_Y_8320 1.319
R_VINT2_5141 MINT3_X_5440_Y_8640 MINT2_X_5440_Y_8640 1.319
R_VINT2_5142 MINT3_X_5440_Y_8960 MINT2_X_5440_Y_8960 1.319
R_VINT2_5143 MINT3_X_5440_Y_9280 MINT2_X_5440_Y_9280 1.319
R_VINT2_5144 MINT3_X_5440_Y_9600 MINT2_X_5440_Y_9600 1.319
R_VINT2_5145 MINT3_X_5440_Y_9920 MINT2_X_5440_Y_9920 1.319
R_VINT2_5146 MINT3_X_5760_Y_0 MINT2_X_5760_Y_0 1.319
R_VINT2_5147 MINT3_X_5760_Y_320 MINT2_X_5760_Y_320 1.319
R_VINT2_5148 MINT3_X_5760_Y_640 MINT2_X_5760_Y_640 1.319
R_VINT2_5149 MINT3_X_5760_Y_960 MINT2_X_5760_Y_960 1.319
R_VINT2_5150 MINT3_X_5760_Y_1280 MINT2_X_5760_Y_1280 1.319
R_VINT2_5151 MINT3_X_5760_Y_1600 MINT2_X_5760_Y_1600 1.319
R_VINT2_5152 MINT3_X_5760_Y_1920 MINT2_X_5760_Y_1920 1.319
R_VINT2_5153 MINT3_X_5760_Y_2240 MINT2_X_5760_Y_2240 1.319
R_VINT2_5154 MINT3_X_5760_Y_2560 MINT2_X_5760_Y_2560 1.319
R_VINT2_5155 MINT3_X_5760_Y_2880 MINT2_X_5760_Y_2880 1.319
R_VINT2_5156 MINT3_X_5760_Y_3200 MINT2_X_5760_Y_3200 1.319
R_VINT2_5157 MINT3_X_5760_Y_3520 MINT2_X_5760_Y_3520 1.319
R_VINT2_5158 MINT3_X_5760_Y_3840 MINT2_X_5760_Y_3840 1.319
R_VINT2_5159 MINT3_X_5760_Y_4160 MINT2_X_5760_Y_4160 1.319
R_VINT2_5160 MINT3_X_5760_Y_4480 MINT2_X_5760_Y_4480 1.319
R_VINT2_5161 MINT3_X_5760_Y_4800 MINT2_X_5760_Y_4800 1.319
R_VINT2_5162 MINT3_X_5760_Y_5120 MINT2_X_5760_Y_5120 1.319
R_VINT2_5163 MINT3_X_5760_Y_5440 MINT2_X_5760_Y_5440 1.319
R_VINT2_5164 MINT3_X_5760_Y_5760 MINT2_X_5760_Y_5760 1.319
R_VINT2_5165 MINT3_X_5760_Y_6080 MINT2_X_5760_Y_6080 1.319
R_VINT2_5166 MINT3_X_5760_Y_6400 MINT2_X_5760_Y_6400 1.319
R_VINT2_5167 MINT3_X_5760_Y_6720 MINT2_X_5760_Y_6720 1.319
R_VINT2_5168 MINT3_X_5760_Y_7040 MINT2_X_5760_Y_7040 1.319
R_VINT2_5169 MINT3_X_5760_Y_7360 MINT2_X_5760_Y_7360 1.319
R_VINT2_5170 MINT3_X_5760_Y_7680 MINT2_X_5760_Y_7680 1.319
R_VINT2_5171 MINT3_X_5760_Y_8000 MINT2_X_5760_Y_8000 1.319
R_VINT2_5172 MINT3_X_5760_Y_8320 MINT2_X_5760_Y_8320 1.319
R_VINT2_5173 MINT3_X_5760_Y_8640 MINT2_X_5760_Y_8640 1.319
R_VINT2_5174 MINT3_X_5760_Y_8960 MINT2_X_5760_Y_8960 1.319
R_VINT2_5175 MINT3_X_5760_Y_9280 MINT2_X_5760_Y_9280 1.319
R_VINT2_5176 MINT3_X_5760_Y_9600 MINT2_X_5760_Y_9600 1.319
R_VINT2_5177 MINT3_X_5760_Y_9920 MINT2_X_5760_Y_9920 1.319
R_VINT2_5178 MINT3_X_6080_Y_0 MINT2_X_6080_Y_0 1.319
R_VINT2_5179 MINT3_X_6080_Y_320 MINT2_X_6080_Y_320 1.319
R_VINT2_5180 MINT3_X_6080_Y_640 MINT2_X_6080_Y_640 1.319
R_VINT2_5181 MINT3_X_6080_Y_960 MINT2_X_6080_Y_960 1.319
R_VINT2_5182 MINT3_X_6080_Y_1280 MINT2_X_6080_Y_1280 1.319
R_VINT2_5183 MINT3_X_6080_Y_1600 MINT2_X_6080_Y_1600 1.319
R_VINT2_5184 MINT3_X_6080_Y_1920 MINT2_X_6080_Y_1920 1.319
R_VINT2_5185 MINT3_X_6080_Y_2240 MINT2_X_6080_Y_2240 1.319
R_VINT2_5186 MINT3_X_6080_Y_2560 MINT2_X_6080_Y_2560 1.319
R_VINT2_5187 MINT3_X_6080_Y_2880 MINT2_X_6080_Y_2880 1.319
R_VINT2_5188 MINT3_X_6080_Y_3200 MINT2_X_6080_Y_3200 1.319
R_VINT2_5189 MINT3_X_6080_Y_3520 MINT2_X_6080_Y_3520 1.319
R_VINT2_5190 MINT3_X_6080_Y_3840 MINT2_X_6080_Y_3840 1.319
R_VINT2_5191 MINT3_X_6080_Y_4160 MINT2_X_6080_Y_4160 1.319
R_VINT2_5192 MINT3_X_6080_Y_4480 MINT2_X_6080_Y_4480 1.319
R_VINT2_5193 MINT3_X_6080_Y_4800 MINT2_X_6080_Y_4800 1.319
R_VINT2_5194 MINT3_X_6080_Y_5120 MINT2_X_6080_Y_5120 1.319
R_VINT2_5195 MINT3_X_6080_Y_5440 MINT2_X_6080_Y_5440 1.319
R_VINT2_5196 MINT3_X_6080_Y_5760 MINT2_X_6080_Y_5760 1.319
R_VINT2_5197 MINT3_X_6080_Y_6080 MINT2_X_6080_Y_6080 1.319
R_VINT2_5198 MINT3_X_6080_Y_6400 MINT2_X_6080_Y_6400 1.319
R_VINT2_5199 MINT3_X_6080_Y_6720 MINT2_X_6080_Y_6720 1.319
R_VINT2_5200 MINT3_X_6080_Y_7040 MINT2_X_6080_Y_7040 1.319
R_VINT2_5201 MINT3_X_6080_Y_7360 MINT2_X_6080_Y_7360 1.319
R_VINT2_5202 MINT3_X_6080_Y_7680 MINT2_X_6080_Y_7680 1.319
R_VINT2_5203 MINT3_X_6080_Y_8000 MINT2_X_6080_Y_8000 1.319
R_VINT2_5204 MINT3_X_6080_Y_8320 MINT2_X_6080_Y_8320 1.319
R_VINT2_5205 MINT3_X_6080_Y_8640 MINT2_X_6080_Y_8640 1.319
R_VINT2_5206 MINT3_X_6080_Y_8960 MINT2_X_6080_Y_8960 1.319
R_VINT2_5207 MINT3_X_6080_Y_9280 MINT2_X_6080_Y_9280 1.319
R_VINT2_5208 MINT3_X_6080_Y_9600 MINT2_X_6080_Y_9600 1.319
R_VINT2_5209 MINT3_X_6080_Y_9920 MINT2_X_6080_Y_9920 1.319
R_VINT2_5210 MINT3_X_6400_Y_0 MINT2_X_6400_Y_0 1.319
R_VINT2_5211 MINT3_X_6400_Y_320 MINT2_X_6400_Y_320 1.319
R_VINT2_5212 MINT3_X_6400_Y_640 MINT2_X_6400_Y_640 1.319
R_VINT2_5213 MINT3_X_6400_Y_960 MINT2_X_6400_Y_960 1.319
R_VINT2_5214 MINT3_X_6400_Y_1280 MINT2_X_6400_Y_1280 1.319
R_VINT2_5215 MINT3_X_6400_Y_1600 MINT2_X_6400_Y_1600 1.319
R_VINT2_5216 MINT3_X_6400_Y_1920 MINT2_X_6400_Y_1920 1.319
R_VINT2_5217 MINT3_X_6400_Y_2240 MINT2_X_6400_Y_2240 1.319
R_VINT2_5218 MINT3_X_6400_Y_2560 MINT2_X_6400_Y_2560 1.319
R_VINT2_5219 MINT3_X_6400_Y_2880 MINT2_X_6400_Y_2880 1.319
R_VINT2_5220 MINT3_X_6400_Y_3200 MINT2_X_6400_Y_3200 1.319
R_VINT2_5221 MINT3_X_6400_Y_3520 MINT2_X_6400_Y_3520 1.319
R_VINT2_5222 MINT3_X_6400_Y_3840 MINT2_X_6400_Y_3840 1.319
R_VINT2_5223 MINT3_X_6400_Y_4160 MINT2_X_6400_Y_4160 1.319
R_VINT2_5224 MINT3_X_6400_Y_4480 MINT2_X_6400_Y_4480 1.319
R_VINT2_5225 MINT3_X_6400_Y_4800 MINT2_X_6400_Y_4800 1.319
R_VINT2_5226 MINT3_X_6400_Y_5120 MINT2_X_6400_Y_5120 1.319
R_VINT2_5227 MINT3_X_6400_Y_5440 MINT2_X_6400_Y_5440 1.319
R_VINT2_5228 MINT3_X_6400_Y_5760 MINT2_X_6400_Y_5760 1.319
R_VINT2_5229 MINT3_X_6400_Y_6080 MINT2_X_6400_Y_6080 1.319
R_VINT2_5230 MINT3_X_6400_Y_6400 MINT2_X_6400_Y_6400 1.319
R_VINT2_5231 MINT3_X_6400_Y_6720 MINT2_X_6400_Y_6720 1.319
R_VINT2_5232 MINT3_X_6400_Y_7040 MINT2_X_6400_Y_7040 1.319
R_VINT2_5233 MINT3_X_6400_Y_7360 MINT2_X_6400_Y_7360 1.319
R_VINT2_5234 MINT3_X_6400_Y_7680 MINT2_X_6400_Y_7680 1.319
R_VINT2_5235 MINT3_X_6400_Y_8000 MINT2_X_6400_Y_8000 1.319
R_VINT2_5236 MINT3_X_6400_Y_8320 MINT2_X_6400_Y_8320 1.319
R_VINT2_5237 MINT3_X_6400_Y_8640 MINT2_X_6400_Y_8640 1.319
R_VINT2_5238 MINT3_X_6400_Y_8960 MINT2_X_6400_Y_8960 1.319
R_VINT2_5239 MINT3_X_6400_Y_9280 MINT2_X_6400_Y_9280 1.319
R_VINT2_5240 MINT3_X_6400_Y_9600 MINT2_X_6400_Y_9600 1.319
R_VINT2_5241 MINT3_X_6400_Y_9920 MINT2_X_6400_Y_9920 1.319
R_VINT2_5242 MINT3_X_6720_Y_0 MINT2_X_6720_Y_0 1.319
R_VINT2_5243 MINT3_X_6720_Y_320 MINT2_X_6720_Y_320 1.319
R_VINT2_5244 MINT3_X_6720_Y_640 MINT2_X_6720_Y_640 1.319
R_VINT2_5245 MINT3_X_6720_Y_960 MINT2_X_6720_Y_960 1.319
R_VINT2_5246 MINT3_X_6720_Y_1280 MINT2_X_6720_Y_1280 1.319
R_VINT2_5247 MINT3_X_6720_Y_1600 MINT2_X_6720_Y_1600 1.319
R_VINT2_5248 MINT3_X_6720_Y_1920 MINT2_X_6720_Y_1920 1.319
R_VINT2_5249 MINT3_X_6720_Y_2240 MINT2_X_6720_Y_2240 1.319
R_VINT2_5250 MINT3_X_6720_Y_2560 MINT2_X_6720_Y_2560 1.319
R_VINT2_5251 MINT3_X_6720_Y_2880 MINT2_X_6720_Y_2880 1.319
R_VINT2_5252 MINT3_X_6720_Y_3200 MINT2_X_6720_Y_3200 1.319
R_VINT2_5253 MINT3_X_6720_Y_3520 MINT2_X_6720_Y_3520 1.319
R_VINT2_5254 MINT3_X_6720_Y_3840 MINT2_X_6720_Y_3840 1.319
R_VINT2_5255 MINT3_X_6720_Y_4160 MINT2_X_6720_Y_4160 1.319
R_VINT2_5256 MINT3_X_6720_Y_4480 MINT2_X_6720_Y_4480 1.319
R_VINT2_5257 MINT3_X_6720_Y_4800 MINT2_X_6720_Y_4800 1.319
R_VINT2_5258 MINT3_X_6720_Y_5120 MINT2_X_6720_Y_5120 1.319
R_VINT2_5259 MINT3_X_6720_Y_5440 MINT2_X_6720_Y_5440 1.319
R_VINT2_5260 MINT3_X_6720_Y_5760 MINT2_X_6720_Y_5760 1.319
R_VINT2_5261 MINT3_X_6720_Y_6080 MINT2_X_6720_Y_6080 1.319
R_VINT2_5262 MINT3_X_6720_Y_6400 MINT2_X_6720_Y_6400 1.319
R_VINT2_5263 MINT3_X_6720_Y_6720 MINT2_X_6720_Y_6720 1.319
R_VINT2_5264 MINT3_X_6720_Y_7040 MINT2_X_6720_Y_7040 1.319
R_VINT2_5265 MINT3_X_6720_Y_7360 MINT2_X_6720_Y_7360 1.319
R_VINT2_5266 MINT3_X_6720_Y_7680 MINT2_X_6720_Y_7680 1.319
R_VINT2_5267 MINT3_X_6720_Y_8000 MINT2_X_6720_Y_8000 1.319
R_VINT2_5268 MINT3_X_6720_Y_8320 MINT2_X_6720_Y_8320 1.319
R_VINT2_5269 MINT3_X_6720_Y_8640 MINT2_X_6720_Y_8640 1.319
R_VINT2_5270 MINT3_X_6720_Y_8960 MINT2_X_6720_Y_8960 1.319
R_VINT2_5271 MINT3_X_6720_Y_9280 MINT2_X_6720_Y_9280 1.319
R_VINT2_5272 MINT3_X_6720_Y_9600 MINT2_X_6720_Y_9600 1.319
R_VINT2_5273 MINT3_X_6720_Y_9920 MINT2_X_6720_Y_9920 1.319
R_VINT2_5274 MINT3_X_7040_Y_0 MINT2_X_7040_Y_0 1.319
R_VINT2_5275 MINT3_X_7040_Y_320 MINT2_X_7040_Y_320 1.319
R_VINT2_5276 MINT3_X_7040_Y_640 MINT2_X_7040_Y_640 1.319
R_VINT2_5277 MINT3_X_7040_Y_960 MINT2_X_7040_Y_960 1.319
R_VINT2_5278 MINT3_X_7040_Y_1280 MINT2_X_7040_Y_1280 1.319
R_VINT2_5279 MINT3_X_7040_Y_1600 MINT2_X_7040_Y_1600 1.319
R_VINT2_5280 MINT3_X_7040_Y_1920 MINT2_X_7040_Y_1920 1.319
R_VINT2_5281 MINT3_X_7040_Y_2240 MINT2_X_7040_Y_2240 1.319
R_VINT2_5282 MINT3_X_7040_Y_2560 MINT2_X_7040_Y_2560 1.319
R_VINT2_5283 MINT3_X_7040_Y_2880 MINT2_X_7040_Y_2880 1.319
R_VINT2_5284 MINT3_X_7040_Y_3200 MINT2_X_7040_Y_3200 1.319
R_VINT2_5285 MINT3_X_7040_Y_3520 MINT2_X_7040_Y_3520 1.319
R_VINT2_5286 MINT3_X_7040_Y_3840 MINT2_X_7040_Y_3840 1.319
R_VINT2_5287 MINT3_X_7040_Y_4160 MINT2_X_7040_Y_4160 1.319
R_VINT2_5288 MINT3_X_7040_Y_4480 MINT2_X_7040_Y_4480 1.319
R_VINT2_5289 MINT3_X_7040_Y_4800 MINT2_X_7040_Y_4800 1.319
R_VINT2_5290 MINT3_X_7040_Y_5120 MINT2_X_7040_Y_5120 1.319
R_VINT2_5291 MINT3_X_7040_Y_5440 MINT2_X_7040_Y_5440 1.319
R_VINT2_5292 MINT3_X_7040_Y_5760 MINT2_X_7040_Y_5760 1.319
R_VINT2_5293 MINT3_X_7040_Y_6080 MINT2_X_7040_Y_6080 1.319
R_VINT2_5294 MINT3_X_7040_Y_6400 MINT2_X_7040_Y_6400 1.319
R_VINT2_5295 MINT3_X_7040_Y_6720 MINT2_X_7040_Y_6720 1.319
R_VINT2_5296 MINT3_X_7040_Y_7040 MINT2_X_7040_Y_7040 1.319
R_VINT2_5297 MINT3_X_7040_Y_7360 MINT2_X_7040_Y_7360 1.319
R_VINT2_5298 MINT3_X_7040_Y_7680 MINT2_X_7040_Y_7680 1.319
R_VINT2_5299 MINT3_X_7040_Y_8000 MINT2_X_7040_Y_8000 1.319
R_VINT2_5300 MINT3_X_7040_Y_8320 MINT2_X_7040_Y_8320 1.319
R_VINT2_5301 MINT3_X_7040_Y_8640 MINT2_X_7040_Y_8640 1.319
R_VINT2_5302 MINT3_X_7040_Y_8960 MINT2_X_7040_Y_8960 1.319
R_VINT2_5303 MINT3_X_7040_Y_9280 MINT2_X_7040_Y_9280 1.319
R_VINT2_5304 MINT3_X_7040_Y_9600 MINT2_X_7040_Y_9600 1.319
R_VINT2_5305 MINT3_X_7040_Y_9920 MINT2_X_7040_Y_9920 1.319
R_VINT2_5306 MINT3_X_7360_Y_0 MINT2_X_7360_Y_0 1.319
R_VINT2_5307 MINT3_X_7360_Y_320 MINT2_X_7360_Y_320 1.319
R_VINT2_5308 MINT3_X_7360_Y_640 MINT2_X_7360_Y_640 1.319
R_VINT2_5309 MINT3_X_7360_Y_960 MINT2_X_7360_Y_960 1.319
R_VINT2_5310 MINT3_X_7360_Y_1280 MINT2_X_7360_Y_1280 1.319
R_VINT2_5311 MINT3_X_7360_Y_1600 MINT2_X_7360_Y_1600 1.319
R_VINT2_5312 MINT3_X_7360_Y_1920 MINT2_X_7360_Y_1920 1.319
R_VINT2_5313 MINT3_X_7360_Y_2240 MINT2_X_7360_Y_2240 1.319
R_VINT2_5314 MINT3_X_7360_Y_2560 MINT2_X_7360_Y_2560 1.319
R_VINT2_5315 MINT3_X_7360_Y_2880 MINT2_X_7360_Y_2880 1.319
R_VINT2_5316 MINT3_X_7360_Y_3200 MINT2_X_7360_Y_3200 1.319
R_VINT2_5317 MINT3_X_7360_Y_3520 MINT2_X_7360_Y_3520 1.319
R_VINT2_5318 MINT3_X_7360_Y_3840 MINT2_X_7360_Y_3840 1.319
R_VINT2_5319 MINT3_X_7360_Y_4160 MINT2_X_7360_Y_4160 1.319
R_VINT2_5320 MINT3_X_7360_Y_4480 MINT2_X_7360_Y_4480 1.319
R_VINT2_5321 MINT3_X_7360_Y_4800 MINT2_X_7360_Y_4800 1.319
R_VINT2_5322 MINT3_X_7360_Y_5120 MINT2_X_7360_Y_5120 1.319
R_VINT2_5323 MINT3_X_7360_Y_5440 MINT2_X_7360_Y_5440 1.319
R_VINT2_5324 MINT3_X_7360_Y_5760 MINT2_X_7360_Y_5760 1.319
R_VINT2_5325 MINT3_X_7360_Y_6080 MINT2_X_7360_Y_6080 1.319
R_VINT2_5326 MINT3_X_7360_Y_6400 MINT2_X_7360_Y_6400 1.319
R_VINT2_5327 MINT3_X_7360_Y_6720 MINT2_X_7360_Y_6720 1.319
R_VINT2_5328 MINT3_X_7360_Y_7040 MINT2_X_7360_Y_7040 1.319
R_VINT2_5329 MINT3_X_7360_Y_7360 MINT2_X_7360_Y_7360 1.319
R_VINT2_5330 MINT3_X_7360_Y_7680 MINT2_X_7360_Y_7680 1.319
R_VINT2_5331 MINT3_X_7360_Y_8000 MINT2_X_7360_Y_8000 1.319
R_VINT2_5332 MINT3_X_7360_Y_8320 MINT2_X_7360_Y_8320 1.319
R_VINT2_5333 MINT3_X_7360_Y_8640 MINT2_X_7360_Y_8640 1.319
R_VINT2_5334 MINT3_X_7360_Y_8960 MINT2_X_7360_Y_8960 1.319
R_VINT2_5335 MINT3_X_7360_Y_9280 MINT2_X_7360_Y_9280 1.319
R_VINT2_5336 MINT3_X_7360_Y_9600 MINT2_X_7360_Y_9600 1.319
R_VINT2_5337 MINT3_X_7360_Y_9920 MINT2_X_7360_Y_9920 1.319
R_VINT2_5338 MINT3_X_7680_Y_0 MINT2_X_7680_Y_0 1.319
R_VINT2_5339 MINT3_X_7680_Y_320 MINT2_X_7680_Y_320 1.319
R_VINT2_5340 MINT3_X_7680_Y_640 MINT2_X_7680_Y_640 1.319
R_VINT2_5341 MINT3_X_7680_Y_960 MINT2_X_7680_Y_960 1.319
R_VINT2_5342 MINT3_X_7680_Y_1280 MINT2_X_7680_Y_1280 1.319
R_VINT2_5343 MINT3_X_7680_Y_1600 MINT2_X_7680_Y_1600 1.319
R_VINT2_5344 MINT3_X_7680_Y_1920 MINT2_X_7680_Y_1920 1.319
R_VINT2_5345 MINT3_X_7680_Y_2240 MINT2_X_7680_Y_2240 1.319
R_VINT2_5346 MINT3_X_7680_Y_2560 MINT2_X_7680_Y_2560 1.319
R_VINT2_5347 MINT3_X_7680_Y_2880 MINT2_X_7680_Y_2880 1.319
R_VINT2_5348 MINT3_X_7680_Y_3200 MINT2_X_7680_Y_3200 1.319
R_VINT2_5349 MINT3_X_7680_Y_3520 MINT2_X_7680_Y_3520 1.319
R_VINT2_5350 MINT3_X_7680_Y_3840 MINT2_X_7680_Y_3840 1.319
R_VINT2_5351 MINT3_X_7680_Y_4160 MINT2_X_7680_Y_4160 1.319
R_VINT2_5352 MINT3_X_7680_Y_4480 MINT2_X_7680_Y_4480 1.319
R_VINT2_5353 MINT3_X_7680_Y_4800 MINT2_X_7680_Y_4800 1.319
R_VINT2_5354 MINT3_X_7680_Y_5120 MINT2_X_7680_Y_5120 1.319
R_VINT2_5355 MINT3_X_7680_Y_5440 MINT2_X_7680_Y_5440 1.319
R_VINT2_5356 MINT3_X_7680_Y_5760 MINT2_X_7680_Y_5760 1.319
R_VINT2_5357 MINT3_X_7680_Y_6080 MINT2_X_7680_Y_6080 1.319
R_VINT2_5358 MINT3_X_7680_Y_6400 MINT2_X_7680_Y_6400 1.319
R_VINT2_5359 MINT3_X_7680_Y_6720 MINT2_X_7680_Y_6720 1.319
R_VINT2_5360 MINT3_X_7680_Y_7040 MINT2_X_7680_Y_7040 1.319
R_VINT2_5361 MINT3_X_7680_Y_7360 MINT2_X_7680_Y_7360 1.319
R_VINT2_5362 MINT3_X_7680_Y_7680 MINT2_X_7680_Y_7680 1.319
R_VINT2_5363 MINT3_X_7680_Y_8000 MINT2_X_7680_Y_8000 1.319
R_VINT2_5364 MINT3_X_7680_Y_8320 MINT2_X_7680_Y_8320 1.319
R_VINT2_5365 MINT3_X_7680_Y_8640 MINT2_X_7680_Y_8640 1.319
R_VINT2_5366 MINT3_X_7680_Y_8960 MINT2_X_7680_Y_8960 1.319
R_VINT2_5367 MINT3_X_7680_Y_9280 MINT2_X_7680_Y_9280 1.319
R_VINT2_5368 MINT3_X_7680_Y_9600 MINT2_X_7680_Y_9600 1.319
R_VINT2_5369 MINT3_X_7680_Y_9920 MINT2_X_7680_Y_9920 1.319
R_VINT2_5370 MINT3_X_8000_Y_0 MINT2_X_8000_Y_0 1.319
R_VINT2_5371 MINT3_X_8000_Y_320 MINT2_X_8000_Y_320 1.319
R_VINT2_5372 MINT3_X_8000_Y_640 MINT2_X_8000_Y_640 1.319
R_VINT2_5373 MINT3_X_8000_Y_960 MINT2_X_8000_Y_960 1.319
R_VINT2_5374 MINT3_X_8000_Y_1280 MINT2_X_8000_Y_1280 1.319
R_VINT2_5375 MINT3_X_8000_Y_1600 MINT2_X_8000_Y_1600 1.319
R_VINT2_5376 MINT3_X_8000_Y_1920 MINT2_X_8000_Y_1920 1.319
R_VINT2_5377 MINT3_X_8000_Y_2240 MINT2_X_8000_Y_2240 1.319
R_VINT2_5378 MINT3_X_8000_Y_2560 MINT2_X_8000_Y_2560 1.319
R_VINT2_5379 MINT3_X_8000_Y_2880 MINT2_X_8000_Y_2880 1.319
R_VINT2_5380 MINT3_X_8000_Y_3200 MINT2_X_8000_Y_3200 1.319
R_VINT2_5381 MINT3_X_8000_Y_3520 MINT2_X_8000_Y_3520 1.319
R_VINT2_5382 MINT3_X_8000_Y_3840 MINT2_X_8000_Y_3840 1.319
R_VINT2_5383 MINT3_X_8000_Y_4160 MINT2_X_8000_Y_4160 1.319
R_VINT2_5384 MINT3_X_8000_Y_4480 MINT2_X_8000_Y_4480 1.319
R_VINT2_5385 MINT3_X_8000_Y_4800 MINT2_X_8000_Y_4800 1.319
R_VINT2_5386 MINT3_X_8000_Y_5120 MINT2_X_8000_Y_5120 1.319
R_VINT2_5387 MINT3_X_8000_Y_5440 MINT2_X_8000_Y_5440 1.319
R_VINT2_5388 MINT3_X_8000_Y_5760 MINT2_X_8000_Y_5760 1.319
R_VINT2_5389 MINT3_X_8000_Y_6080 MINT2_X_8000_Y_6080 1.319
R_VINT2_5390 MINT3_X_8000_Y_6400 MINT2_X_8000_Y_6400 1.319
R_VINT2_5391 MINT3_X_8000_Y_6720 MINT2_X_8000_Y_6720 1.319
R_VINT2_5392 MINT3_X_8000_Y_7040 MINT2_X_8000_Y_7040 1.319
R_VINT2_5393 MINT3_X_8000_Y_7360 MINT2_X_8000_Y_7360 1.319
R_VINT2_5394 MINT3_X_8000_Y_7680 MINT2_X_8000_Y_7680 1.319
R_VINT2_5395 MINT3_X_8000_Y_8000 MINT2_X_8000_Y_8000 1.319
R_VINT2_5396 MINT3_X_8000_Y_8320 MINT2_X_8000_Y_8320 1.319
R_VINT2_5397 MINT3_X_8000_Y_8640 MINT2_X_8000_Y_8640 1.319
R_VINT2_5398 MINT3_X_8000_Y_8960 MINT2_X_8000_Y_8960 1.319
R_VINT2_5399 MINT3_X_8000_Y_9280 MINT2_X_8000_Y_9280 1.319
R_VINT2_5400 MINT3_X_8000_Y_9600 MINT2_X_8000_Y_9600 1.319
R_VINT2_5401 MINT3_X_8000_Y_9920 MINT2_X_8000_Y_9920 1.319
R_VINT2_5402 MINT3_X_8320_Y_0 MINT2_X_8320_Y_0 1.319
R_VINT2_5403 MINT3_X_8320_Y_320 MINT2_X_8320_Y_320 1.319
R_VINT2_5404 MINT3_X_8320_Y_640 MINT2_X_8320_Y_640 1.319
R_VINT2_5405 MINT3_X_8320_Y_960 MINT2_X_8320_Y_960 1.319
R_VINT2_5406 MINT3_X_8320_Y_1280 MINT2_X_8320_Y_1280 1.319
R_VINT2_5407 MINT3_X_8320_Y_1600 MINT2_X_8320_Y_1600 1.319
R_VINT2_5408 MINT3_X_8320_Y_1920 MINT2_X_8320_Y_1920 1.319
R_VINT2_5409 MINT3_X_8320_Y_2240 MINT2_X_8320_Y_2240 1.319
R_VINT2_5410 MINT3_X_8320_Y_2560 MINT2_X_8320_Y_2560 1.319
R_VINT2_5411 MINT3_X_8320_Y_2880 MINT2_X_8320_Y_2880 1.319
R_VINT2_5412 MINT3_X_8320_Y_3200 MINT2_X_8320_Y_3200 1.319
R_VINT2_5413 MINT3_X_8320_Y_3520 MINT2_X_8320_Y_3520 1.319
R_VINT2_5414 MINT3_X_8320_Y_3840 MINT2_X_8320_Y_3840 1.319
R_VINT2_5415 MINT3_X_8320_Y_4160 MINT2_X_8320_Y_4160 1.319
R_VINT2_5416 MINT3_X_8320_Y_4480 MINT2_X_8320_Y_4480 1.319
R_VINT2_5417 MINT3_X_8320_Y_4800 MINT2_X_8320_Y_4800 1.319
R_VINT2_5418 MINT3_X_8320_Y_5120 MINT2_X_8320_Y_5120 1.319
R_VINT2_5419 MINT3_X_8320_Y_5440 MINT2_X_8320_Y_5440 1.319
R_VINT2_5420 MINT3_X_8320_Y_5760 MINT2_X_8320_Y_5760 1.319
R_VINT2_5421 MINT3_X_8320_Y_6080 MINT2_X_8320_Y_6080 1.319
R_VINT2_5422 MINT3_X_8320_Y_6400 MINT2_X_8320_Y_6400 1.319
R_VINT2_5423 MINT3_X_8320_Y_6720 MINT2_X_8320_Y_6720 1.319
R_VINT2_5424 MINT3_X_8320_Y_7040 MINT2_X_8320_Y_7040 1.319
R_VINT2_5425 MINT3_X_8320_Y_7360 MINT2_X_8320_Y_7360 1.319
R_VINT2_5426 MINT3_X_8320_Y_7680 MINT2_X_8320_Y_7680 1.319
R_VINT2_5427 MINT3_X_8320_Y_8000 MINT2_X_8320_Y_8000 1.319
R_VINT2_5428 MINT3_X_8320_Y_8320 MINT2_X_8320_Y_8320 1.319
R_VINT2_5429 MINT3_X_8320_Y_8640 MINT2_X_8320_Y_8640 1.319
R_VINT2_5430 MINT3_X_8320_Y_8960 MINT2_X_8320_Y_8960 1.319
R_VINT2_5431 MINT3_X_8320_Y_9280 MINT2_X_8320_Y_9280 1.319
R_VINT2_5432 MINT3_X_8320_Y_9600 MINT2_X_8320_Y_9600 1.319
R_VINT2_5433 MINT3_X_8320_Y_9920 MINT2_X_8320_Y_9920 1.319
R_VINT2_5434 MINT3_X_8640_Y_0 MINT2_X_8640_Y_0 1.319
R_VINT2_5435 MINT3_X_8640_Y_320 MINT2_X_8640_Y_320 1.319
R_VINT2_5436 MINT3_X_8640_Y_640 MINT2_X_8640_Y_640 1.319
R_VINT2_5437 MINT3_X_8640_Y_960 MINT2_X_8640_Y_960 1.319
R_VINT2_5438 MINT3_X_8640_Y_1280 MINT2_X_8640_Y_1280 1.319
R_VINT2_5439 MINT3_X_8640_Y_1600 MINT2_X_8640_Y_1600 1.319
R_VINT2_5440 MINT3_X_8640_Y_1920 MINT2_X_8640_Y_1920 1.319
R_VINT2_5441 MINT3_X_8640_Y_2240 MINT2_X_8640_Y_2240 1.319
R_VINT2_5442 MINT3_X_8640_Y_2560 MINT2_X_8640_Y_2560 1.319
R_VINT2_5443 MINT3_X_8640_Y_2880 MINT2_X_8640_Y_2880 1.319
R_VINT2_5444 MINT3_X_8640_Y_3200 MINT2_X_8640_Y_3200 1.319
R_VINT2_5445 MINT3_X_8640_Y_3520 MINT2_X_8640_Y_3520 1.319
R_VINT2_5446 MINT3_X_8640_Y_3840 MINT2_X_8640_Y_3840 1.319
R_VINT2_5447 MINT3_X_8640_Y_4160 MINT2_X_8640_Y_4160 1.319
R_VINT2_5448 MINT3_X_8640_Y_4480 MINT2_X_8640_Y_4480 1.319
R_VINT2_5449 MINT3_X_8640_Y_4800 MINT2_X_8640_Y_4800 1.319
R_VINT2_5450 MINT3_X_8640_Y_5120 MINT2_X_8640_Y_5120 1.319
R_VINT2_5451 MINT3_X_8640_Y_5440 MINT2_X_8640_Y_5440 1.319
R_VINT2_5452 MINT3_X_8640_Y_5760 MINT2_X_8640_Y_5760 1.319
R_VINT2_5453 MINT3_X_8640_Y_6080 MINT2_X_8640_Y_6080 1.319
R_VINT2_5454 MINT3_X_8640_Y_6400 MINT2_X_8640_Y_6400 1.319
R_VINT2_5455 MINT3_X_8640_Y_6720 MINT2_X_8640_Y_6720 1.319
R_VINT2_5456 MINT3_X_8640_Y_7040 MINT2_X_8640_Y_7040 1.319
R_VINT2_5457 MINT3_X_8640_Y_7360 MINT2_X_8640_Y_7360 1.319
R_VINT2_5458 MINT3_X_8640_Y_7680 MINT2_X_8640_Y_7680 1.319
R_VINT2_5459 MINT3_X_8640_Y_8000 MINT2_X_8640_Y_8000 1.319
R_VINT2_5460 MINT3_X_8640_Y_8320 MINT2_X_8640_Y_8320 1.319
R_VINT2_5461 MINT3_X_8640_Y_8640 MINT2_X_8640_Y_8640 1.319
R_VINT2_5462 MINT3_X_8640_Y_8960 MINT2_X_8640_Y_8960 1.319
R_VINT2_5463 MINT3_X_8640_Y_9280 MINT2_X_8640_Y_9280 1.319
R_VINT2_5464 MINT3_X_8640_Y_9600 MINT2_X_8640_Y_9600 1.319
R_VINT2_5465 MINT3_X_8640_Y_9920 MINT2_X_8640_Y_9920 1.319
R_VINT2_5466 MINT3_X_8960_Y_0 MINT2_X_8960_Y_0 1.319
R_VINT2_5467 MINT3_X_8960_Y_320 MINT2_X_8960_Y_320 1.319
R_VINT2_5468 MINT3_X_8960_Y_640 MINT2_X_8960_Y_640 1.319
R_VINT2_5469 MINT3_X_8960_Y_960 MINT2_X_8960_Y_960 1.319
R_VINT2_5470 MINT3_X_8960_Y_1280 MINT2_X_8960_Y_1280 1.319
R_VINT2_5471 MINT3_X_8960_Y_1600 MINT2_X_8960_Y_1600 1.319
R_VINT2_5472 MINT3_X_8960_Y_1920 MINT2_X_8960_Y_1920 1.319
R_VINT2_5473 MINT3_X_8960_Y_2240 MINT2_X_8960_Y_2240 1.319
R_VINT2_5474 MINT3_X_8960_Y_2560 MINT2_X_8960_Y_2560 1.319
R_VINT2_5475 MINT3_X_8960_Y_2880 MINT2_X_8960_Y_2880 1.319
R_VINT2_5476 MINT3_X_8960_Y_3200 MINT2_X_8960_Y_3200 1.319
R_VINT2_5477 MINT3_X_8960_Y_3520 MINT2_X_8960_Y_3520 1.319
R_VINT2_5478 MINT3_X_8960_Y_3840 MINT2_X_8960_Y_3840 1.319
R_VINT2_5479 MINT3_X_8960_Y_4160 MINT2_X_8960_Y_4160 1.319
R_VINT2_5480 MINT3_X_8960_Y_4480 MINT2_X_8960_Y_4480 1.319
R_VINT2_5481 MINT3_X_8960_Y_4800 MINT2_X_8960_Y_4800 1.319
R_VINT2_5482 MINT3_X_8960_Y_5120 MINT2_X_8960_Y_5120 1.319
R_VINT2_5483 MINT3_X_8960_Y_5440 MINT2_X_8960_Y_5440 1.319
R_VINT2_5484 MINT3_X_8960_Y_5760 MINT2_X_8960_Y_5760 1.319
R_VINT2_5485 MINT3_X_8960_Y_6080 MINT2_X_8960_Y_6080 1.319
R_VINT2_5486 MINT3_X_8960_Y_6400 MINT2_X_8960_Y_6400 1.319
R_VINT2_5487 MINT3_X_8960_Y_6720 MINT2_X_8960_Y_6720 1.319
R_VINT2_5488 MINT3_X_8960_Y_7040 MINT2_X_8960_Y_7040 1.319
R_VINT2_5489 MINT3_X_8960_Y_7360 MINT2_X_8960_Y_7360 1.319
R_VINT2_5490 MINT3_X_8960_Y_7680 MINT2_X_8960_Y_7680 1.319
R_VINT2_5491 MINT3_X_8960_Y_8000 MINT2_X_8960_Y_8000 1.319
R_VINT2_5492 MINT3_X_8960_Y_8320 MINT2_X_8960_Y_8320 1.319
R_VINT2_5493 MINT3_X_8960_Y_8640 MINT2_X_8960_Y_8640 1.319
R_VINT2_5494 MINT3_X_8960_Y_8960 MINT2_X_8960_Y_8960 1.319
R_VINT2_5495 MINT3_X_8960_Y_9280 MINT2_X_8960_Y_9280 1.319
R_VINT2_5496 MINT3_X_8960_Y_9600 MINT2_X_8960_Y_9600 1.319
R_VINT2_5497 MINT3_X_8960_Y_9920 MINT2_X_8960_Y_9920 1.319
R_VINT2_5498 MINT3_X_9280_Y_0 MINT2_X_9280_Y_0 1.319
R_VINT2_5499 MINT3_X_9280_Y_320 MINT2_X_9280_Y_320 1.319
R_VINT2_5500 MINT3_X_9280_Y_640 MINT2_X_9280_Y_640 1.319
R_VINT2_5501 MINT3_X_9280_Y_960 MINT2_X_9280_Y_960 1.319
R_VINT2_5502 MINT3_X_9280_Y_1280 MINT2_X_9280_Y_1280 1.319
R_VINT2_5503 MINT3_X_9280_Y_1600 MINT2_X_9280_Y_1600 1.319
R_VINT2_5504 MINT3_X_9280_Y_1920 MINT2_X_9280_Y_1920 1.319
R_VINT2_5505 MINT3_X_9280_Y_2240 MINT2_X_9280_Y_2240 1.319
R_VINT2_5506 MINT3_X_9280_Y_2560 MINT2_X_9280_Y_2560 1.319
R_VINT2_5507 MINT3_X_9280_Y_2880 MINT2_X_9280_Y_2880 1.319
R_VINT2_5508 MINT3_X_9280_Y_3200 MINT2_X_9280_Y_3200 1.319
R_VINT2_5509 MINT3_X_9280_Y_3520 MINT2_X_9280_Y_3520 1.319
R_VINT2_5510 MINT3_X_9280_Y_3840 MINT2_X_9280_Y_3840 1.319
R_VINT2_5511 MINT3_X_9280_Y_4160 MINT2_X_9280_Y_4160 1.319
R_VINT2_5512 MINT3_X_9280_Y_4480 MINT2_X_9280_Y_4480 1.319
R_VINT2_5513 MINT3_X_9280_Y_4800 MINT2_X_9280_Y_4800 1.319
R_VINT2_5514 MINT3_X_9280_Y_5120 MINT2_X_9280_Y_5120 1.319
R_VINT2_5515 MINT3_X_9280_Y_5440 MINT2_X_9280_Y_5440 1.319
R_VINT2_5516 MINT3_X_9280_Y_5760 MINT2_X_9280_Y_5760 1.319
R_VINT2_5517 MINT3_X_9280_Y_6080 MINT2_X_9280_Y_6080 1.319
R_VINT2_5518 MINT3_X_9280_Y_6400 MINT2_X_9280_Y_6400 1.319
R_VINT2_5519 MINT3_X_9280_Y_6720 MINT2_X_9280_Y_6720 1.319
R_VINT2_5520 MINT3_X_9280_Y_7040 MINT2_X_9280_Y_7040 1.319
R_VINT2_5521 MINT3_X_9280_Y_7360 MINT2_X_9280_Y_7360 1.319
R_VINT2_5522 MINT3_X_9280_Y_7680 MINT2_X_9280_Y_7680 1.319
R_VINT2_5523 MINT3_X_9280_Y_8000 MINT2_X_9280_Y_8000 1.319
R_VINT2_5524 MINT3_X_9280_Y_8320 MINT2_X_9280_Y_8320 1.319
R_VINT2_5525 MINT3_X_9280_Y_8640 MINT2_X_9280_Y_8640 1.319
R_VINT2_5526 MINT3_X_9280_Y_8960 MINT2_X_9280_Y_8960 1.319
R_VINT2_5527 MINT3_X_9280_Y_9280 MINT2_X_9280_Y_9280 1.319
R_VINT2_5528 MINT3_X_9280_Y_9600 MINT2_X_9280_Y_9600 1.319
R_VINT2_5529 MINT3_X_9280_Y_9920 MINT2_X_9280_Y_9920 1.319
R_VINT2_5530 MINT3_X_9600_Y_0 MINT2_X_9600_Y_0 1.319
R_VINT2_5531 MINT3_X_9600_Y_320 MINT2_X_9600_Y_320 1.319
R_VINT2_5532 MINT3_X_9600_Y_640 MINT2_X_9600_Y_640 1.319
R_VINT2_5533 MINT3_X_9600_Y_960 MINT2_X_9600_Y_960 1.319
R_VINT2_5534 MINT3_X_9600_Y_1280 MINT2_X_9600_Y_1280 1.319
R_VINT2_5535 MINT3_X_9600_Y_1600 MINT2_X_9600_Y_1600 1.319
R_VINT2_5536 MINT3_X_9600_Y_1920 MINT2_X_9600_Y_1920 1.319
R_VINT2_5537 MINT3_X_9600_Y_2240 MINT2_X_9600_Y_2240 1.319
R_VINT2_5538 MINT3_X_9600_Y_2560 MINT2_X_9600_Y_2560 1.319
R_VINT2_5539 MINT3_X_9600_Y_2880 MINT2_X_9600_Y_2880 1.319
R_VINT2_5540 MINT3_X_9600_Y_3200 MINT2_X_9600_Y_3200 1.319
R_VINT2_5541 MINT3_X_9600_Y_3520 MINT2_X_9600_Y_3520 1.319
R_VINT2_5542 MINT3_X_9600_Y_3840 MINT2_X_9600_Y_3840 1.319
R_VINT2_5543 MINT3_X_9600_Y_4160 MINT2_X_9600_Y_4160 1.319
R_VINT2_5544 MINT3_X_9600_Y_4480 MINT2_X_9600_Y_4480 1.319
R_VINT2_5545 MINT3_X_9600_Y_4800 MINT2_X_9600_Y_4800 1.319
R_VINT2_5546 MINT3_X_9600_Y_5120 MINT2_X_9600_Y_5120 1.319
R_VINT2_5547 MINT3_X_9600_Y_5440 MINT2_X_9600_Y_5440 1.319
R_VINT2_5548 MINT3_X_9600_Y_5760 MINT2_X_9600_Y_5760 1.319
R_VINT2_5549 MINT3_X_9600_Y_6080 MINT2_X_9600_Y_6080 1.319
R_VINT2_5550 MINT3_X_9600_Y_6400 MINT2_X_9600_Y_6400 1.319
R_VINT2_5551 MINT3_X_9600_Y_6720 MINT2_X_9600_Y_6720 1.319
R_VINT2_5552 MINT3_X_9600_Y_7040 MINT2_X_9600_Y_7040 1.319
R_VINT2_5553 MINT3_X_9600_Y_7360 MINT2_X_9600_Y_7360 1.319
R_VINT2_5554 MINT3_X_9600_Y_7680 MINT2_X_9600_Y_7680 1.319
R_VINT2_5555 MINT3_X_9600_Y_8000 MINT2_X_9600_Y_8000 1.319
R_VINT2_5556 MINT3_X_9600_Y_8320 MINT2_X_9600_Y_8320 1.319
R_VINT2_5557 MINT3_X_9600_Y_8640 MINT2_X_9600_Y_8640 1.319
R_VINT2_5558 MINT3_X_9600_Y_8960 MINT2_X_9600_Y_8960 1.319
R_VINT2_5559 MINT3_X_9600_Y_9280 MINT2_X_9600_Y_9280 1.319
R_VINT2_5560 MINT3_X_9600_Y_9600 MINT2_X_9600_Y_9600 1.319
R_VINT2_5561 MINT3_X_9600_Y_9920 MINT2_X_9600_Y_9920 1.319
R_VINT2_5562 MINT3_X_9920_Y_0 MINT2_X_9920_Y_0 1.319
R_VINT2_5563 MINT3_X_9920_Y_320 MINT2_X_9920_Y_320 1.319
R_VINT2_5564 MINT3_X_9920_Y_640 MINT2_X_9920_Y_640 1.319
R_VINT2_5565 MINT3_X_9920_Y_960 MINT2_X_9920_Y_960 1.319
R_VINT2_5566 MINT3_X_9920_Y_1280 MINT2_X_9920_Y_1280 1.319
R_VINT2_5567 MINT3_X_9920_Y_1600 MINT2_X_9920_Y_1600 1.319
R_VINT2_5568 MINT3_X_9920_Y_1920 MINT2_X_9920_Y_1920 1.319
R_VINT2_5569 MINT3_X_9920_Y_2240 MINT2_X_9920_Y_2240 1.319
R_VINT2_5570 MINT3_X_9920_Y_2560 MINT2_X_9920_Y_2560 1.319
R_VINT2_5571 MINT3_X_9920_Y_2880 MINT2_X_9920_Y_2880 1.319
R_VINT2_5572 MINT3_X_9920_Y_3200 MINT2_X_9920_Y_3200 1.319
R_VINT2_5573 MINT3_X_9920_Y_3520 MINT2_X_9920_Y_3520 1.319
R_VINT2_5574 MINT3_X_9920_Y_3840 MINT2_X_9920_Y_3840 1.319
R_VINT2_5575 MINT3_X_9920_Y_4160 MINT2_X_9920_Y_4160 1.319
R_VINT2_5576 MINT3_X_9920_Y_4480 MINT2_X_9920_Y_4480 1.319
R_VINT2_5577 MINT3_X_9920_Y_4800 MINT2_X_9920_Y_4800 1.319
R_VINT2_5578 MINT3_X_9920_Y_5120 MINT2_X_9920_Y_5120 1.319
R_VINT2_5579 MINT3_X_9920_Y_5440 MINT2_X_9920_Y_5440 1.319
R_VINT2_5580 MINT3_X_9920_Y_5760 MINT2_X_9920_Y_5760 1.319
R_VINT2_5581 MINT3_X_9920_Y_6080 MINT2_X_9920_Y_6080 1.319
R_VINT2_5582 MINT3_X_9920_Y_6400 MINT2_X_9920_Y_6400 1.319
R_VINT2_5583 MINT3_X_9920_Y_6720 MINT2_X_9920_Y_6720 1.319
R_VINT2_5584 MINT3_X_9920_Y_7040 MINT2_X_9920_Y_7040 1.319
R_VINT2_5585 MINT3_X_9920_Y_7360 MINT2_X_9920_Y_7360 1.319
R_VINT2_5586 MINT3_X_9920_Y_7680 MINT2_X_9920_Y_7680 1.319
R_VINT2_5587 MINT3_X_9920_Y_8000 MINT2_X_9920_Y_8000 1.319
R_VINT2_5588 MINT3_X_9920_Y_8320 MINT2_X_9920_Y_8320 1.319
R_VINT2_5589 MINT3_X_9920_Y_8640 MINT2_X_9920_Y_8640 1.319
R_VINT2_5590 MINT3_X_9920_Y_8960 MINT2_X_9920_Y_8960 1.319
R_VINT2_5591 MINT3_X_9920_Y_9280 MINT2_X_9920_Y_9280 1.319
R_VINT2_5592 MINT3_X_9920_Y_9600 MINT2_X_9920_Y_9600 1.319
R_VINT2_5593 MINT3_X_9920_Y_9920 MINT2_X_9920_Y_9920 1.319
R_VINT1_5594 MINT2_X_0_Y_0 MINT1_X_0_Y_0 1.319
R_VINT1_5595 MINT2_X_0_Y_320 MINT1_X_0_Y_320 1.319
R_VINT1_5596 MINT2_X_0_Y_640 MINT1_X_0_Y_640 1.319
R_VINT1_5597 MINT2_X_0_Y_960 MINT1_X_0_Y_960 1.319
R_VINT1_5598 MINT2_X_0_Y_1280 MINT1_X_0_Y_1280 1.319
R_VINT1_5599 MINT2_X_0_Y_1600 MINT1_X_0_Y_1600 1.319
R_VINT1_5600 MINT2_X_0_Y_1920 MINT1_X_0_Y_1920 1.319
R_VINT1_5601 MINT2_X_0_Y_2240 MINT1_X_0_Y_2240 1.319
R_VINT1_5602 MINT2_X_0_Y_2560 MINT1_X_0_Y_2560 1.319
R_VINT1_5603 MINT2_X_0_Y_2880 MINT1_X_0_Y_2880 1.319
R_VINT1_5604 MINT2_X_0_Y_3200 MINT1_X_0_Y_3200 1.319
R_VINT1_5605 MINT2_X_0_Y_3520 MINT1_X_0_Y_3520 1.319
R_VINT1_5606 MINT2_X_0_Y_3840 MINT1_X_0_Y_3840 1.319
R_VINT1_5607 MINT2_X_0_Y_4160 MINT1_X_0_Y_4160 1.319
R_VINT1_5608 MINT2_X_0_Y_4480 MINT1_X_0_Y_4480 1.319
R_VINT1_5609 MINT2_X_0_Y_4800 MINT1_X_0_Y_4800 1.319
R_VINT1_5610 MINT2_X_0_Y_5120 MINT1_X_0_Y_5120 1.319
R_VINT1_5611 MINT2_X_0_Y_5440 MINT1_X_0_Y_5440 1.319
R_VINT1_5612 MINT2_X_0_Y_5760 MINT1_X_0_Y_5760 1.319
R_VINT1_5613 MINT2_X_0_Y_6080 MINT1_X_0_Y_6080 1.319
R_VINT1_5614 MINT2_X_0_Y_6400 MINT1_X_0_Y_6400 1.319
R_VINT1_5615 MINT2_X_0_Y_6720 MINT1_X_0_Y_6720 1.319
R_VINT1_5616 MINT2_X_0_Y_7040 MINT1_X_0_Y_7040 1.319
R_VINT1_5617 MINT2_X_0_Y_7360 MINT1_X_0_Y_7360 1.319
R_VINT1_5618 MINT2_X_0_Y_7680 MINT1_X_0_Y_7680 1.319
R_VINT1_5619 MINT2_X_0_Y_8000 MINT1_X_0_Y_8000 1.319
R_VINT1_5620 MINT2_X_0_Y_8320 MINT1_X_0_Y_8320 1.319
R_VINT1_5621 MINT2_X_0_Y_8640 MINT1_X_0_Y_8640 1.319
R_VINT1_5622 MINT2_X_0_Y_8960 MINT1_X_0_Y_8960 1.319
R_VINT1_5623 MINT2_X_0_Y_9280 MINT1_X_0_Y_9280 1.319
R_VINT1_5624 MINT2_X_0_Y_9600 MINT1_X_0_Y_9600 1.319
R_VINT1_5625 MINT2_X_0_Y_9920 MINT1_X_0_Y_9920 1.319
R_VINT1_5626 MINT2_X_320_Y_0 MINT1_X_320_Y_0 1.319
R_VINT1_5627 MINT2_X_320_Y_320 MINT1_X_320_Y_320 1.319
R_VINT1_5628 MINT2_X_320_Y_640 MINT1_X_320_Y_640 1.319
R_VINT1_5629 MINT2_X_320_Y_960 MINT1_X_320_Y_960 1.319
R_VINT1_5630 MINT2_X_320_Y_1280 MINT1_X_320_Y_1280 1.319
R_VINT1_5631 MINT2_X_320_Y_1600 MINT1_X_320_Y_1600 1.319
R_VINT1_5632 MINT2_X_320_Y_1920 MINT1_X_320_Y_1920 1.319
R_VINT1_5633 MINT2_X_320_Y_2240 MINT1_X_320_Y_2240 1.319
R_VINT1_5634 MINT2_X_320_Y_2560 MINT1_X_320_Y_2560 1.319
R_VINT1_5635 MINT2_X_320_Y_2880 MINT1_X_320_Y_2880 1.319
R_VINT1_5636 MINT2_X_320_Y_3200 MINT1_X_320_Y_3200 1.319
R_VINT1_5637 MINT2_X_320_Y_3520 MINT1_X_320_Y_3520 1.319
R_VINT1_5638 MINT2_X_320_Y_3840 MINT1_X_320_Y_3840 1.319
R_VINT1_5639 MINT2_X_320_Y_4160 MINT1_X_320_Y_4160 1.319
R_VINT1_5640 MINT2_X_320_Y_4480 MINT1_X_320_Y_4480 1.319
R_VINT1_5641 MINT2_X_320_Y_4800 MINT1_X_320_Y_4800 1.319
R_VINT1_5642 MINT2_X_320_Y_5120 MINT1_X_320_Y_5120 1.319
R_VINT1_5643 MINT2_X_320_Y_5440 MINT1_X_320_Y_5440 1.319
R_VINT1_5644 MINT2_X_320_Y_5760 MINT1_X_320_Y_5760 1.319
R_VINT1_5645 MINT2_X_320_Y_6080 MINT1_X_320_Y_6080 1.319
R_VINT1_5646 MINT2_X_320_Y_6400 MINT1_X_320_Y_6400 1.319
R_VINT1_5647 MINT2_X_320_Y_6720 MINT1_X_320_Y_6720 1.319
R_VINT1_5648 MINT2_X_320_Y_7040 MINT1_X_320_Y_7040 1.319
R_VINT1_5649 MINT2_X_320_Y_7360 MINT1_X_320_Y_7360 1.319
R_VINT1_5650 MINT2_X_320_Y_7680 MINT1_X_320_Y_7680 1.319
R_VINT1_5651 MINT2_X_320_Y_8000 MINT1_X_320_Y_8000 1.319
R_VINT1_5652 MINT2_X_320_Y_8320 MINT1_X_320_Y_8320 1.319
R_VINT1_5653 MINT2_X_320_Y_8640 MINT1_X_320_Y_8640 1.319
R_VINT1_5654 MINT2_X_320_Y_8960 MINT1_X_320_Y_8960 1.319
R_VINT1_5655 MINT2_X_320_Y_9280 MINT1_X_320_Y_9280 1.319
R_VINT1_5656 MINT2_X_320_Y_9600 MINT1_X_320_Y_9600 1.319
R_VINT1_5657 MINT2_X_320_Y_9920 MINT1_X_320_Y_9920 1.319
R_VINT1_5658 MINT2_X_640_Y_0 MINT1_X_640_Y_0 1.319
R_VINT1_5659 MINT2_X_640_Y_320 MINT1_X_640_Y_320 1.319
R_VINT1_5660 MINT2_X_640_Y_640 MINT1_X_640_Y_640 1.319
R_VINT1_5661 MINT2_X_640_Y_960 MINT1_X_640_Y_960 1.319
R_VINT1_5662 MINT2_X_640_Y_1280 MINT1_X_640_Y_1280 1.319
R_VINT1_5663 MINT2_X_640_Y_1600 MINT1_X_640_Y_1600 1.319
R_VINT1_5664 MINT2_X_640_Y_1920 MINT1_X_640_Y_1920 1.319
R_VINT1_5665 MINT2_X_640_Y_2240 MINT1_X_640_Y_2240 1.319
R_VINT1_5666 MINT2_X_640_Y_2560 MINT1_X_640_Y_2560 1.319
R_VINT1_5667 MINT2_X_640_Y_2880 MINT1_X_640_Y_2880 1.319
R_VINT1_5668 MINT2_X_640_Y_3200 MINT1_X_640_Y_3200 1.319
R_VINT1_5669 MINT2_X_640_Y_3520 MINT1_X_640_Y_3520 1.319
R_VINT1_5670 MINT2_X_640_Y_3840 MINT1_X_640_Y_3840 1.319
R_VINT1_5671 MINT2_X_640_Y_4160 MINT1_X_640_Y_4160 1.319
R_VINT1_5672 MINT2_X_640_Y_4480 MINT1_X_640_Y_4480 1.319
R_VINT1_5673 MINT2_X_640_Y_4800 MINT1_X_640_Y_4800 1.319
R_VINT1_5674 MINT2_X_640_Y_5120 MINT1_X_640_Y_5120 1.319
R_VINT1_5675 MINT2_X_640_Y_5440 MINT1_X_640_Y_5440 1.319
R_VINT1_5676 MINT2_X_640_Y_5760 MINT1_X_640_Y_5760 1.319
R_VINT1_5677 MINT2_X_640_Y_6080 MINT1_X_640_Y_6080 1.319
R_VINT1_5678 MINT2_X_640_Y_6400 MINT1_X_640_Y_6400 1.319
R_VINT1_5679 MINT2_X_640_Y_6720 MINT1_X_640_Y_6720 1.319
R_VINT1_5680 MINT2_X_640_Y_7040 MINT1_X_640_Y_7040 1.319
R_VINT1_5681 MINT2_X_640_Y_7360 MINT1_X_640_Y_7360 1.319
R_VINT1_5682 MINT2_X_640_Y_7680 MINT1_X_640_Y_7680 1.319
R_VINT1_5683 MINT2_X_640_Y_8000 MINT1_X_640_Y_8000 1.319
R_VINT1_5684 MINT2_X_640_Y_8320 MINT1_X_640_Y_8320 1.319
R_VINT1_5685 MINT2_X_640_Y_8640 MINT1_X_640_Y_8640 1.319
R_VINT1_5686 MINT2_X_640_Y_8960 MINT1_X_640_Y_8960 1.319
R_VINT1_5687 MINT2_X_640_Y_9280 MINT1_X_640_Y_9280 1.319
R_VINT1_5688 MINT2_X_640_Y_9600 MINT1_X_640_Y_9600 1.319
R_VINT1_5689 MINT2_X_640_Y_9920 MINT1_X_640_Y_9920 1.319
R_VINT1_5690 MINT2_X_960_Y_0 MINT1_X_960_Y_0 1.319
R_VINT1_5691 MINT2_X_960_Y_320 MINT1_X_960_Y_320 1.319
R_VINT1_5692 MINT2_X_960_Y_640 MINT1_X_960_Y_640 1.319
R_VINT1_5693 MINT2_X_960_Y_960 MINT1_X_960_Y_960 1.319
R_VINT1_5694 MINT2_X_960_Y_1280 MINT1_X_960_Y_1280 1.319
R_VINT1_5695 MINT2_X_960_Y_1600 MINT1_X_960_Y_1600 1.319
R_VINT1_5696 MINT2_X_960_Y_1920 MINT1_X_960_Y_1920 1.319
R_VINT1_5697 MINT2_X_960_Y_2240 MINT1_X_960_Y_2240 1.319
R_VINT1_5698 MINT2_X_960_Y_2560 MINT1_X_960_Y_2560 1.319
R_VINT1_5699 MINT2_X_960_Y_2880 MINT1_X_960_Y_2880 1.319
R_VINT1_5700 MINT2_X_960_Y_3200 MINT1_X_960_Y_3200 1.319
R_VINT1_5701 MINT2_X_960_Y_3520 MINT1_X_960_Y_3520 1.319
R_VINT1_5702 MINT2_X_960_Y_3840 MINT1_X_960_Y_3840 1.319
R_VINT1_5703 MINT2_X_960_Y_4160 MINT1_X_960_Y_4160 1.319
R_VINT1_5704 MINT2_X_960_Y_4480 MINT1_X_960_Y_4480 1.319
R_VINT1_5705 MINT2_X_960_Y_4800 MINT1_X_960_Y_4800 1.319
R_VINT1_5706 MINT2_X_960_Y_5120 MINT1_X_960_Y_5120 1.319
R_VINT1_5707 MINT2_X_960_Y_5440 MINT1_X_960_Y_5440 1.319
R_VINT1_5708 MINT2_X_960_Y_5760 MINT1_X_960_Y_5760 1.319
R_VINT1_5709 MINT2_X_960_Y_6080 MINT1_X_960_Y_6080 1.319
R_VINT1_5710 MINT2_X_960_Y_6400 MINT1_X_960_Y_6400 1.319
R_VINT1_5711 MINT2_X_960_Y_6720 MINT1_X_960_Y_6720 1.319
R_VINT1_5712 MINT2_X_960_Y_7040 MINT1_X_960_Y_7040 1.319
R_VINT1_5713 MINT2_X_960_Y_7360 MINT1_X_960_Y_7360 1.319
R_VINT1_5714 MINT2_X_960_Y_7680 MINT1_X_960_Y_7680 1.319
R_VINT1_5715 MINT2_X_960_Y_8000 MINT1_X_960_Y_8000 1.319
R_VINT1_5716 MINT2_X_960_Y_8320 MINT1_X_960_Y_8320 1.319
R_VINT1_5717 MINT2_X_960_Y_8640 MINT1_X_960_Y_8640 1.319
R_VINT1_5718 MINT2_X_960_Y_8960 MINT1_X_960_Y_8960 1.319
R_VINT1_5719 MINT2_X_960_Y_9280 MINT1_X_960_Y_9280 1.319
R_VINT1_5720 MINT2_X_960_Y_9600 MINT1_X_960_Y_9600 1.319
R_VINT1_5721 MINT2_X_960_Y_9920 MINT1_X_960_Y_9920 1.319
R_VINT1_5722 MINT2_X_1280_Y_0 MINT1_X_1280_Y_0 1.319
R_VINT1_5723 MINT2_X_1280_Y_320 MINT1_X_1280_Y_320 1.319
R_VINT1_5724 MINT2_X_1280_Y_640 MINT1_X_1280_Y_640 1.319
R_VINT1_5725 MINT2_X_1280_Y_960 MINT1_X_1280_Y_960 1.319
R_VINT1_5726 MINT2_X_1280_Y_1280 MINT1_X_1280_Y_1280 1.319
R_VINT1_5727 MINT2_X_1280_Y_1600 MINT1_X_1280_Y_1600 1.319
R_VINT1_5728 MINT2_X_1280_Y_1920 MINT1_X_1280_Y_1920 1.319
R_VINT1_5729 MINT2_X_1280_Y_2240 MINT1_X_1280_Y_2240 1.319
R_VINT1_5730 MINT2_X_1280_Y_2560 MINT1_X_1280_Y_2560 1.319
R_VINT1_5731 MINT2_X_1280_Y_2880 MINT1_X_1280_Y_2880 1.319
R_VINT1_5732 MINT2_X_1280_Y_3200 MINT1_X_1280_Y_3200 1.319
R_VINT1_5733 MINT2_X_1280_Y_3520 MINT1_X_1280_Y_3520 1.319
R_VINT1_5734 MINT2_X_1280_Y_3840 MINT1_X_1280_Y_3840 1.319
R_VINT1_5735 MINT2_X_1280_Y_4160 MINT1_X_1280_Y_4160 1.319
R_VINT1_5736 MINT2_X_1280_Y_4480 MINT1_X_1280_Y_4480 1.319
R_VINT1_5737 MINT2_X_1280_Y_4800 MINT1_X_1280_Y_4800 1.319
R_VINT1_5738 MINT2_X_1280_Y_5120 MINT1_X_1280_Y_5120 1.319
R_VINT1_5739 MINT2_X_1280_Y_5440 MINT1_X_1280_Y_5440 1.319
R_VINT1_5740 MINT2_X_1280_Y_5760 MINT1_X_1280_Y_5760 1.319
R_VINT1_5741 MINT2_X_1280_Y_6080 MINT1_X_1280_Y_6080 1.319
R_VINT1_5742 MINT2_X_1280_Y_6400 MINT1_X_1280_Y_6400 1.319
R_VINT1_5743 MINT2_X_1280_Y_6720 MINT1_X_1280_Y_6720 1.319
R_VINT1_5744 MINT2_X_1280_Y_7040 MINT1_X_1280_Y_7040 1.319
R_VINT1_5745 MINT2_X_1280_Y_7360 MINT1_X_1280_Y_7360 1.319
R_VINT1_5746 MINT2_X_1280_Y_7680 MINT1_X_1280_Y_7680 1.319
R_VINT1_5747 MINT2_X_1280_Y_8000 MINT1_X_1280_Y_8000 1.319
R_VINT1_5748 MINT2_X_1280_Y_8320 MINT1_X_1280_Y_8320 1.319
R_VINT1_5749 MINT2_X_1280_Y_8640 MINT1_X_1280_Y_8640 1.319
R_VINT1_5750 MINT2_X_1280_Y_8960 MINT1_X_1280_Y_8960 1.319
R_VINT1_5751 MINT2_X_1280_Y_9280 MINT1_X_1280_Y_9280 1.319
R_VINT1_5752 MINT2_X_1280_Y_9600 MINT1_X_1280_Y_9600 1.319
R_VINT1_5753 MINT2_X_1280_Y_9920 MINT1_X_1280_Y_9920 1.319
R_VINT1_5754 MINT2_X_1600_Y_0 MINT1_X_1600_Y_0 1.319
R_VINT1_5755 MINT2_X_1600_Y_320 MINT1_X_1600_Y_320 1.319
R_VINT1_5756 MINT2_X_1600_Y_640 MINT1_X_1600_Y_640 1.319
R_VINT1_5757 MINT2_X_1600_Y_960 MINT1_X_1600_Y_960 1.319
R_VINT1_5758 MINT2_X_1600_Y_1280 MINT1_X_1600_Y_1280 1.319
R_VINT1_5759 MINT2_X_1600_Y_1600 MINT1_X_1600_Y_1600 1.319
R_VINT1_5760 MINT2_X_1600_Y_1920 MINT1_X_1600_Y_1920 1.319
R_VINT1_5761 MINT2_X_1600_Y_2240 MINT1_X_1600_Y_2240 1.319
R_VINT1_5762 MINT2_X_1600_Y_2560 MINT1_X_1600_Y_2560 1.319
R_VINT1_5763 MINT2_X_1600_Y_2880 MINT1_X_1600_Y_2880 1.319
R_VINT1_5764 MINT2_X_1600_Y_3200 MINT1_X_1600_Y_3200 1.319
R_VINT1_5765 MINT2_X_1600_Y_3520 MINT1_X_1600_Y_3520 1.319
R_VINT1_5766 MINT2_X_1600_Y_3840 MINT1_X_1600_Y_3840 1.319
R_VINT1_5767 MINT2_X_1600_Y_4160 MINT1_X_1600_Y_4160 1.319
R_VINT1_5768 MINT2_X_1600_Y_4480 MINT1_X_1600_Y_4480 1.319
R_VINT1_5769 MINT2_X_1600_Y_4800 MINT1_X_1600_Y_4800 1.319
R_VINT1_5770 MINT2_X_1600_Y_5120 MINT1_X_1600_Y_5120 1.319
R_VINT1_5771 MINT2_X_1600_Y_5440 MINT1_X_1600_Y_5440 1.319
R_VINT1_5772 MINT2_X_1600_Y_5760 MINT1_X_1600_Y_5760 1.319
R_VINT1_5773 MINT2_X_1600_Y_6080 MINT1_X_1600_Y_6080 1.319
R_VINT1_5774 MINT2_X_1600_Y_6400 MINT1_X_1600_Y_6400 1.319
R_VINT1_5775 MINT2_X_1600_Y_6720 MINT1_X_1600_Y_6720 1.319
R_VINT1_5776 MINT2_X_1600_Y_7040 MINT1_X_1600_Y_7040 1.319
R_VINT1_5777 MINT2_X_1600_Y_7360 MINT1_X_1600_Y_7360 1.319
R_VINT1_5778 MINT2_X_1600_Y_7680 MINT1_X_1600_Y_7680 1.319
R_VINT1_5779 MINT2_X_1600_Y_8000 MINT1_X_1600_Y_8000 1.319
R_VINT1_5780 MINT2_X_1600_Y_8320 MINT1_X_1600_Y_8320 1.319
R_VINT1_5781 MINT2_X_1600_Y_8640 MINT1_X_1600_Y_8640 1.319
R_VINT1_5782 MINT2_X_1600_Y_8960 MINT1_X_1600_Y_8960 1.319
R_VINT1_5783 MINT2_X_1600_Y_9280 MINT1_X_1600_Y_9280 1.319
R_VINT1_5784 MINT2_X_1600_Y_9600 MINT1_X_1600_Y_9600 1.319
R_VINT1_5785 MINT2_X_1600_Y_9920 MINT1_X_1600_Y_9920 1.319
R_VINT1_5786 MINT2_X_1920_Y_0 MINT1_X_1920_Y_0 1.319
R_VINT1_5787 MINT2_X_1920_Y_320 MINT1_X_1920_Y_320 1.319
R_VINT1_5788 MINT2_X_1920_Y_640 MINT1_X_1920_Y_640 1.319
R_VINT1_5789 MINT2_X_1920_Y_960 MINT1_X_1920_Y_960 1.319
R_VINT1_5790 MINT2_X_1920_Y_1280 MINT1_X_1920_Y_1280 1.319
R_VINT1_5791 MINT2_X_1920_Y_1600 MINT1_X_1920_Y_1600 1.319
R_VINT1_5792 MINT2_X_1920_Y_1920 MINT1_X_1920_Y_1920 1.319
R_VINT1_5793 MINT2_X_1920_Y_2240 MINT1_X_1920_Y_2240 1.319
R_VINT1_5794 MINT2_X_1920_Y_2560 MINT1_X_1920_Y_2560 1.319
R_VINT1_5795 MINT2_X_1920_Y_2880 MINT1_X_1920_Y_2880 1.319
R_VINT1_5796 MINT2_X_1920_Y_3200 MINT1_X_1920_Y_3200 1.319
R_VINT1_5797 MINT2_X_1920_Y_3520 MINT1_X_1920_Y_3520 1.319
R_VINT1_5798 MINT2_X_1920_Y_3840 MINT1_X_1920_Y_3840 1.319
R_VINT1_5799 MINT2_X_1920_Y_4160 MINT1_X_1920_Y_4160 1.319
R_VINT1_5800 MINT2_X_1920_Y_4480 MINT1_X_1920_Y_4480 1.319
R_VINT1_5801 MINT2_X_1920_Y_4800 MINT1_X_1920_Y_4800 1.319
R_VINT1_5802 MINT2_X_1920_Y_5120 MINT1_X_1920_Y_5120 1.319
R_VINT1_5803 MINT2_X_1920_Y_5440 MINT1_X_1920_Y_5440 1.319
R_VINT1_5804 MINT2_X_1920_Y_5760 MINT1_X_1920_Y_5760 1.319
R_VINT1_5805 MINT2_X_1920_Y_6080 MINT1_X_1920_Y_6080 1.319
R_VINT1_5806 MINT2_X_1920_Y_6400 MINT1_X_1920_Y_6400 1.319
R_VINT1_5807 MINT2_X_1920_Y_6720 MINT1_X_1920_Y_6720 1.319
R_VINT1_5808 MINT2_X_1920_Y_7040 MINT1_X_1920_Y_7040 1.319
R_VINT1_5809 MINT2_X_1920_Y_7360 MINT1_X_1920_Y_7360 1.319
R_VINT1_5810 MINT2_X_1920_Y_7680 MINT1_X_1920_Y_7680 1.319
R_VINT1_5811 MINT2_X_1920_Y_8000 MINT1_X_1920_Y_8000 1.319
R_VINT1_5812 MINT2_X_1920_Y_8320 MINT1_X_1920_Y_8320 1.319
R_VINT1_5813 MINT2_X_1920_Y_8640 MINT1_X_1920_Y_8640 1.319
R_VINT1_5814 MINT2_X_1920_Y_8960 MINT1_X_1920_Y_8960 1.319
R_VINT1_5815 MINT2_X_1920_Y_9280 MINT1_X_1920_Y_9280 1.319
R_VINT1_5816 MINT2_X_1920_Y_9600 MINT1_X_1920_Y_9600 1.319
R_VINT1_5817 MINT2_X_1920_Y_9920 MINT1_X_1920_Y_9920 1.319
R_VINT1_5818 MINT2_X_2240_Y_0 MINT1_X_2240_Y_0 1.319
R_VINT1_5819 MINT2_X_2240_Y_320 MINT1_X_2240_Y_320 1.319
R_VINT1_5820 MINT2_X_2240_Y_640 MINT1_X_2240_Y_640 1.319
R_VINT1_5821 MINT2_X_2240_Y_960 MINT1_X_2240_Y_960 1.319
R_VINT1_5822 MINT2_X_2240_Y_1280 MINT1_X_2240_Y_1280 1.319
R_VINT1_5823 MINT2_X_2240_Y_1600 MINT1_X_2240_Y_1600 1.319
R_VINT1_5824 MINT2_X_2240_Y_1920 MINT1_X_2240_Y_1920 1.319
R_VINT1_5825 MINT2_X_2240_Y_2240 MINT1_X_2240_Y_2240 1.319
R_VINT1_5826 MINT2_X_2240_Y_2560 MINT1_X_2240_Y_2560 1.319
R_VINT1_5827 MINT2_X_2240_Y_2880 MINT1_X_2240_Y_2880 1.319
R_VINT1_5828 MINT2_X_2240_Y_3200 MINT1_X_2240_Y_3200 1.319
R_VINT1_5829 MINT2_X_2240_Y_3520 MINT1_X_2240_Y_3520 1.319
R_VINT1_5830 MINT2_X_2240_Y_3840 MINT1_X_2240_Y_3840 1.319
R_VINT1_5831 MINT2_X_2240_Y_4160 MINT1_X_2240_Y_4160 1.319
R_VINT1_5832 MINT2_X_2240_Y_4480 MINT1_X_2240_Y_4480 1.319
R_VINT1_5833 MINT2_X_2240_Y_4800 MINT1_X_2240_Y_4800 1.319
R_VINT1_5834 MINT2_X_2240_Y_5120 MINT1_X_2240_Y_5120 1.319
R_VINT1_5835 MINT2_X_2240_Y_5440 MINT1_X_2240_Y_5440 1.319
R_VINT1_5836 MINT2_X_2240_Y_5760 MINT1_X_2240_Y_5760 1.319
R_VINT1_5837 MINT2_X_2240_Y_6080 MINT1_X_2240_Y_6080 1.319
R_VINT1_5838 MINT2_X_2240_Y_6400 MINT1_X_2240_Y_6400 1.319
R_VINT1_5839 MINT2_X_2240_Y_6720 MINT1_X_2240_Y_6720 1.319
R_VINT1_5840 MINT2_X_2240_Y_7040 MINT1_X_2240_Y_7040 1.319
R_VINT1_5841 MINT2_X_2240_Y_7360 MINT1_X_2240_Y_7360 1.319
R_VINT1_5842 MINT2_X_2240_Y_7680 MINT1_X_2240_Y_7680 1.319
R_VINT1_5843 MINT2_X_2240_Y_8000 MINT1_X_2240_Y_8000 1.319
R_VINT1_5844 MINT2_X_2240_Y_8320 MINT1_X_2240_Y_8320 1.319
R_VINT1_5845 MINT2_X_2240_Y_8640 MINT1_X_2240_Y_8640 1.319
R_VINT1_5846 MINT2_X_2240_Y_8960 MINT1_X_2240_Y_8960 1.319
R_VINT1_5847 MINT2_X_2240_Y_9280 MINT1_X_2240_Y_9280 1.319
R_VINT1_5848 MINT2_X_2240_Y_9600 MINT1_X_2240_Y_9600 1.319
R_VINT1_5849 MINT2_X_2240_Y_9920 MINT1_X_2240_Y_9920 1.319
R_VINT1_5850 MINT2_X_2560_Y_0 MINT1_X_2560_Y_0 1.319
R_VINT1_5851 MINT2_X_2560_Y_320 MINT1_X_2560_Y_320 1.319
R_VINT1_5852 MINT2_X_2560_Y_640 MINT1_X_2560_Y_640 1.319
R_VINT1_5853 MINT2_X_2560_Y_960 MINT1_X_2560_Y_960 1.319
R_VINT1_5854 MINT2_X_2560_Y_1280 MINT1_X_2560_Y_1280 1.319
R_VINT1_5855 MINT2_X_2560_Y_1600 MINT1_X_2560_Y_1600 1.319
R_VINT1_5856 MINT2_X_2560_Y_1920 MINT1_X_2560_Y_1920 1.319
R_VINT1_5857 MINT2_X_2560_Y_2240 MINT1_X_2560_Y_2240 1.319
R_VINT1_5858 MINT2_X_2560_Y_2560 MINT1_X_2560_Y_2560 1.319
R_VINT1_5859 MINT2_X_2560_Y_2880 MINT1_X_2560_Y_2880 1.319
R_VINT1_5860 MINT2_X_2560_Y_3200 MINT1_X_2560_Y_3200 1.319
R_VINT1_5861 MINT2_X_2560_Y_3520 MINT1_X_2560_Y_3520 1.319
R_VINT1_5862 MINT2_X_2560_Y_3840 MINT1_X_2560_Y_3840 1.319
R_VINT1_5863 MINT2_X_2560_Y_4160 MINT1_X_2560_Y_4160 1.319
R_VINT1_5864 MINT2_X_2560_Y_4480 MINT1_X_2560_Y_4480 1.319
R_VINT1_5865 MINT2_X_2560_Y_4800 MINT1_X_2560_Y_4800 1.319
R_VINT1_5866 MINT2_X_2560_Y_5120 MINT1_X_2560_Y_5120 1.319
R_VINT1_5867 MINT2_X_2560_Y_5440 MINT1_X_2560_Y_5440 1.319
R_VINT1_5868 MINT2_X_2560_Y_5760 MINT1_X_2560_Y_5760 1.319
R_VINT1_5869 MINT2_X_2560_Y_6080 MINT1_X_2560_Y_6080 1.319
R_VINT1_5870 MINT2_X_2560_Y_6400 MINT1_X_2560_Y_6400 1.319
R_VINT1_5871 MINT2_X_2560_Y_6720 MINT1_X_2560_Y_6720 1.319
R_VINT1_5872 MINT2_X_2560_Y_7040 MINT1_X_2560_Y_7040 1.319
R_VINT1_5873 MINT2_X_2560_Y_7360 MINT1_X_2560_Y_7360 1.319
R_VINT1_5874 MINT2_X_2560_Y_7680 MINT1_X_2560_Y_7680 1.319
R_VINT1_5875 MINT2_X_2560_Y_8000 MINT1_X_2560_Y_8000 1.319
R_VINT1_5876 MINT2_X_2560_Y_8320 MINT1_X_2560_Y_8320 1.319
R_VINT1_5877 MINT2_X_2560_Y_8640 MINT1_X_2560_Y_8640 1.319
R_VINT1_5878 MINT2_X_2560_Y_8960 MINT1_X_2560_Y_8960 1.319
R_VINT1_5879 MINT2_X_2560_Y_9280 MINT1_X_2560_Y_9280 1.319
R_VINT1_5880 MINT2_X_2560_Y_9600 MINT1_X_2560_Y_9600 1.319
R_VINT1_5881 MINT2_X_2560_Y_9920 MINT1_X_2560_Y_9920 1.319
R_VINT1_5882 MINT2_X_2880_Y_0 MINT1_X_2880_Y_0 1.319
R_VINT1_5883 MINT2_X_2880_Y_320 MINT1_X_2880_Y_320 1.319
R_VINT1_5884 MINT2_X_2880_Y_640 MINT1_X_2880_Y_640 1.319
R_VINT1_5885 MINT2_X_2880_Y_960 MINT1_X_2880_Y_960 1.319
R_VINT1_5886 MINT2_X_2880_Y_1280 MINT1_X_2880_Y_1280 1.319
R_VINT1_5887 MINT2_X_2880_Y_1600 MINT1_X_2880_Y_1600 1.319
R_VINT1_5888 MINT2_X_2880_Y_1920 MINT1_X_2880_Y_1920 1.319
R_VINT1_5889 MINT2_X_2880_Y_2240 MINT1_X_2880_Y_2240 1.319
R_VINT1_5890 MINT2_X_2880_Y_2560 MINT1_X_2880_Y_2560 1.319
R_VINT1_5891 MINT2_X_2880_Y_2880 MINT1_X_2880_Y_2880 1.319
R_VINT1_5892 MINT2_X_2880_Y_3200 MINT1_X_2880_Y_3200 1.319
R_VINT1_5893 MINT2_X_2880_Y_3520 MINT1_X_2880_Y_3520 1.319
R_VINT1_5894 MINT2_X_2880_Y_3840 MINT1_X_2880_Y_3840 1.319
R_VINT1_5895 MINT2_X_2880_Y_4160 MINT1_X_2880_Y_4160 1.319
R_VINT1_5896 MINT2_X_2880_Y_4480 MINT1_X_2880_Y_4480 1.319
R_VINT1_5897 MINT2_X_2880_Y_4800 MINT1_X_2880_Y_4800 1.319
R_VINT1_5898 MINT2_X_2880_Y_5120 MINT1_X_2880_Y_5120 1.319
R_VINT1_5899 MINT2_X_2880_Y_5440 MINT1_X_2880_Y_5440 1.319
R_VINT1_5900 MINT2_X_2880_Y_5760 MINT1_X_2880_Y_5760 1.319
R_VINT1_5901 MINT2_X_2880_Y_6080 MINT1_X_2880_Y_6080 1.319
R_VINT1_5902 MINT2_X_2880_Y_6400 MINT1_X_2880_Y_6400 1.319
R_VINT1_5903 MINT2_X_2880_Y_6720 MINT1_X_2880_Y_6720 1.319
R_VINT1_5904 MINT2_X_2880_Y_7040 MINT1_X_2880_Y_7040 1.319
R_VINT1_5905 MINT2_X_2880_Y_7360 MINT1_X_2880_Y_7360 1.319
R_VINT1_5906 MINT2_X_2880_Y_7680 MINT1_X_2880_Y_7680 1.319
R_VINT1_5907 MINT2_X_2880_Y_8000 MINT1_X_2880_Y_8000 1.319
R_VINT1_5908 MINT2_X_2880_Y_8320 MINT1_X_2880_Y_8320 1.319
R_VINT1_5909 MINT2_X_2880_Y_8640 MINT1_X_2880_Y_8640 1.319
R_VINT1_5910 MINT2_X_2880_Y_8960 MINT1_X_2880_Y_8960 1.319
R_VINT1_5911 MINT2_X_2880_Y_9280 MINT1_X_2880_Y_9280 1.319
R_VINT1_5912 MINT2_X_2880_Y_9600 MINT1_X_2880_Y_9600 1.319
R_VINT1_5913 MINT2_X_2880_Y_9920 MINT1_X_2880_Y_9920 1.319
R_VINT1_5914 MINT2_X_3200_Y_0 MINT1_X_3200_Y_0 1.319
R_VINT1_5915 MINT2_X_3200_Y_320 MINT1_X_3200_Y_320 1.319
R_VINT1_5916 MINT2_X_3200_Y_640 MINT1_X_3200_Y_640 1.319
R_VINT1_5917 MINT2_X_3200_Y_960 MINT1_X_3200_Y_960 1.319
R_VINT1_5918 MINT2_X_3200_Y_1280 MINT1_X_3200_Y_1280 1.319
R_VINT1_5919 MINT2_X_3200_Y_1600 MINT1_X_3200_Y_1600 1.319
R_VINT1_5920 MINT2_X_3200_Y_1920 MINT1_X_3200_Y_1920 1.319
R_VINT1_5921 MINT2_X_3200_Y_2240 MINT1_X_3200_Y_2240 1.319
R_VINT1_5922 MINT2_X_3200_Y_2560 MINT1_X_3200_Y_2560 1.319
R_VINT1_5923 MINT2_X_3200_Y_2880 MINT1_X_3200_Y_2880 1.319
R_VINT1_5924 MINT2_X_3200_Y_3200 MINT1_X_3200_Y_3200 1.319
R_VINT1_5925 MINT2_X_3200_Y_3520 MINT1_X_3200_Y_3520 1.319
R_VINT1_5926 MINT2_X_3200_Y_3840 MINT1_X_3200_Y_3840 1.319
R_VINT1_5927 MINT2_X_3200_Y_4160 MINT1_X_3200_Y_4160 1.319
R_VINT1_5928 MINT2_X_3200_Y_4480 MINT1_X_3200_Y_4480 1.319
R_VINT1_5929 MINT2_X_3200_Y_4800 MINT1_X_3200_Y_4800 1.319
R_VINT1_5930 MINT2_X_3200_Y_5120 MINT1_X_3200_Y_5120 1.319
R_VINT1_5931 MINT2_X_3200_Y_5440 MINT1_X_3200_Y_5440 1.319
R_VINT1_5932 MINT2_X_3200_Y_5760 MINT1_X_3200_Y_5760 1.319
R_VINT1_5933 MINT2_X_3200_Y_6080 MINT1_X_3200_Y_6080 1.319
R_VINT1_5934 MINT2_X_3200_Y_6400 MINT1_X_3200_Y_6400 1.319
R_VINT1_5935 MINT2_X_3200_Y_6720 MINT1_X_3200_Y_6720 1.319
R_VINT1_5936 MINT2_X_3200_Y_7040 MINT1_X_3200_Y_7040 1.319
R_VINT1_5937 MINT2_X_3200_Y_7360 MINT1_X_3200_Y_7360 1.319
R_VINT1_5938 MINT2_X_3200_Y_7680 MINT1_X_3200_Y_7680 1.319
R_VINT1_5939 MINT2_X_3200_Y_8000 MINT1_X_3200_Y_8000 1.319
R_VINT1_5940 MINT2_X_3200_Y_8320 MINT1_X_3200_Y_8320 1.319
R_VINT1_5941 MINT2_X_3200_Y_8640 MINT1_X_3200_Y_8640 1.319
R_VINT1_5942 MINT2_X_3200_Y_8960 MINT1_X_3200_Y_8960 1.319
R_VINT1_5943 MINT2_X_3200_Y_9280 MINT1_X_3200_Y_9280 1.319
R_VINT1_5944 MINT2_X_3200_Y_9600 MINT1_X_3200_Y_9600 1.319
R_VINT1_5945 MINT2_X_3200_Y_9920 MINT1_X_3200_Y_9920 1.319
R_VINT1_5946 MINT2_X_3520_Y_0 MINT1_X_3520_Y_0 1.319
R_VINT1_5947 MINT2_X_3520_Y_320 MINT1_X_3520_Y_320 1.319
R_VINT1_5948 MINT2_X_3520_Y_640 MINT1_X_3520_Y_640 1.319
R_VINT1_5949 MINT2_X_3520_Y_960 MINT1_X_3520_Y_960 1.319
R_VINT1_5950 MINT2_X_3520_Y_1280 MINT1_X_3520_Y_1280 1.319
R_VINT1_5951 MINT2_X_3520_Y_1600 MINT1_X_3520_Y_1600 1.319
R_VINT1_5952 MINT2_X_3520_Y_1920 MINT1_X_3520_Y_1920 1.319
R_VINT1_5953 MINT2_X_3520_Y_2240 MINT1_X_3520_Y_2240 1.319
R_VINT1_5954 MINT2_X_3520_Y_2560 MINT1_X_3520_Y_2560 1.319
R_VINT1_5955 MINT2_X_3520_Y_2880 MINT1_X_3520_Y_2880 1.319
R_VINT1_5956 MINT2_X_3520_Y_3200 MINT1_X_3520_Y_3200 1.319
R_VINT1_5957 MINT2_X_3520_Y_3520 MINT1_X_3520_Y_3520 1.319
R_VINT1_5958 MINT2_X_3520_Y_3840 MINT1_X_3520_Y_3840 1.319
R_VINT1_5959 MINT2_X_3520_Y_4160 MINT1_X_3520_Y_4160 1.319
R_VINT1_5960 MINT2_X_3520_Y_4480 MINT1_X_3520_Y_4480 1.319
R_VINT1_5961 MINT2_X_3520_Y_4800 MINT1_X_3520_Y_4800 1.319
R_VINT1_5962 MINT2_X_3520_Y_5120 MINT1_X_3520_Y_5120 1.319
R_VINT1_5963 MINT2_X_3520_Y_5440 MINT1_X_3520_Y_5440 1.319
R_VINT1_5964 MINT2_X_3520_Y_5760 MINT1_X_3520_Y_5760 1.319
R_VINT1_5965 MINT2_X_3520_Y_6080 MINT1_X_3520_Y_6080 1.319
R_VINT1_5966 MINT2_X_3520_Y_6400 MINT1_X_3520_Y_6400 1.319
R_VINT1_5967 MINT2_X_3520_Y_6720 MINT1_X_3520_Y_6720 1.319
R_VINT1_5968 MINT2_X_3520_Y_7040 MINT1_X_3520_Y_7040 1.319
R_VINT1_5969 MINT2_X_3520_Y_7360 MINT1_X_3520_Y_7360 1.319
R_VINT1_5970 MINT2_X_3520_Y_7680 MINT1_X_3520_Y_7680 1.319
R_VINT1_5971 MINT2_X_3520_Y_8000 MINT1_X_3520_Y_8000 1.319
R_VINT1_5972 MINT2_X_3520_Y_8320 MINT1_X_3520_Y_8320 1.319
R_VINT1_5973 MINT2_X_3520_Y_8640 MINT1_X_3520_Y_8640 1.319
R_VINT1_5974 MINT2_X_3520_Y_8960 MINT1_X_3520_Y_8960 1.319
R_VINT1_5975 MINT2_X_3520_Y_9280 MINT1_X_3520_Y_9280 1.319
R_VINT1_5976 MINT2_X_3520_Y_9600 MINT1_X_3520_Y_9600 1.319
R_VINT1_5977 MINT2_X_3520_Y_9920 MINT1_X_3520_Y_9920 1.319
R_VINT1_5978 MINT2_X_3840_Y_0 MINT1_X_3840_Y_0 1.319
R_VINT1_5979 MINT2_X_3840_Y_320 MINT1_X_3840_Y_320 1.319
R_VINT1_5980 MINT2_X_3840_Y_640 MINT1_X_3840_Y_640 1.319
R_VINT1_5981 MINT2_X_3840_Y_960 MINT1_X_3840_Y_960 1.319
R_VINT1_5982 MINT2_X_3840_Y_1280 MINT1_X_3840_Y_1280 1.319
R_VINT1_5983 MINT2_X_3840_Y_1600 MINT1_X_3840_Y_1600 1.319
R_VINT1_5984 MINT2_X_3840_Y_1920 MINT1_X_3840_Y_1920 1.319
R_VINT1_5985 MINT2_X_3840_Y_2240 MINT1_X_3840_Y_2240 1.319
R_VINT1_5986 MINT2_X_3840_Y_2560 MINT1_X_3840_Y_2560 1.319
R_VINT1_5987 MINT2_X_3840_Y_2880 MINT1_X_3840_Y_2880 1.319
R_VINT1_5988 MINT2_X_3840_Y_3200 MINT1_X_3840_Y_3200 1.319
R_VINT1_5989 MINT2_X_3840_Y_3520 MINT1_X_3840_Y_3520 1.319
R_VINT1_5990 MINT2_X_3840_Y_3840 MINT1_X_3840_Y_3840 1.319
R_VINT1_5991 MINT2_X_3840_Y_4160 MINT1_X_3840_Y_4160 1.319
R_VINT1_5992 MINT2_X_3840_Y_4480 MINT1_X_3840_Y_4480 1.319
R_VINT1_5993 MINT2_X_3840_Y_4800 MINT1_X_3840_Y_4800 1.319
R_VINT1_5994 MINT2_X_3840_Y_5120 MINT1_X_3840_Y_5120 1.319
R_VINT1_5995 MINT2_X_3840_Y_5440 MINT1_X_3840_Y_5440 1.319
R_VINT1_5996 MINT2_X_3840_Y_5760 MINT1_X_3840_Y_5760 1.319
R_VINT1_5997 MINT2_X_3840_Y_6080 MINT1_X_3840_Y_6080 1.319
R_VINT1_5998 MINT2_X_3840_Y_6400 MINT1_X_3840_Y_6400 1.319
R_VINT1_5999 MINT2_X_3840_Y_6720 MINT1_X_3840_Y_6720 1.319
R_VINT1_6000 MINT2_X_3840_Y_7040 MINT1_X_3840_Y_7040 1.319
R_VINT1_6001 MINT2_X_3840_Y_7360 MINT1_X_3840_Y_7360 1.319
R_VINT1_6002 MINT2_X_3840_Y_7680 MINT1_X_3840_Y_7680 1.319
R_VINT1_6003 MINT2_X_3840_Y_8000 MINT1_X_3840_Y_8000 1.319
R_VINT1_6004 MINT2_X_3840_Y_8320 MINT1_X_3840_Y_8320 1.319
R_VINT1_6005 MINT2_X_3840_Y_8640 MINT1_X_3840_Y_8640 1.319
R_VINT1_6006 MINT2_X_3840_Y_8960 MINT1_X_3840_Y_8960 1.319
R_VINT1_6007 MINT2_X_3840_Y_9280 MINT1_X_3840_Y_9280 1.319
R_VINT1_6008 MINT2_X_3840_Y_9600 MINT1_X_3840_Y_9600 1.319
R_VINT1_6009 MINT2_X_3840_Y_9920 MINT1_X_3840_Y_9920 1.319
R_VINT1_6010 MINT2_X_4160_Y_0 MINT1_X_4160_Y_0 1.319
R_VINT1_6011 MINT2_X_4160_Y_320 MINT1_X_4160_Y_320 1.319
R_VINT1_6012 MINT2_X_4160_Y_640 MINT1_X_4160_Y_640 1.319
R_VINT1_6013 MINT2_X_4160_Y_960 MINT1_X_4160_Y_960 1.319
R_VINT1_6014 MINT2_X_4160_Y_1280 MINT1_X_4160_Y_1280 1.319
R_VINT1_6015 MINT2_X_4160_Y_1600 MINT1_X_4160_Y_1600 1.319
R_VINT1_6016 MINT2_X_4160_Y_1920 MINT1_X_4160_Y_1920 1.319
R_VINT1_6017 MINT2_X_4160_Y_2240 MINT1_X_4160_Y_2240 1.319
R_VINT1_6018 MINT2_X_4160_Y_2560 MINT1_X_4160_Y_2560 1.319
R_VINT1_6019 MINT2_X_4160_Y_2880 MINT1_X_4160_Y_2880 1.319
R_VINT1_6020 MINT2_X_4160_Y_3200 MINT1_X_4160_Y_3200 1.319
R_VINT1_6021 MINT2_X_4160_Y_3520 MINT1_X_4160_Y_3520 1.319
R_VINT1_6022 MINT2_X_4160_Y_3840 MINT1_X_4160_Y_3840 1.319
R_VINT1_6023 MINT2_X_4160_Y_4160 MINT1_X_4160_Y_4160 1.319
R_VINT1_6024 MINT2_X_4160_Y_4480 MINT1_X_4160_Y_4480 1.319
R_VINT1_6025 MINT2_X_4160_Y_4800 MINT1_X_4160_Y_4800 1.319
R_VINT1_6026 MINT2_X_4160_Y_5120 MINT1_X_4160_Y_5120 1.319
R_VINT1_6027 MINT2_X_4160_Y_5440 MINT1_X_4160_Y_5440 1.319
R_VINT1_6028 MINT2_X_4160_Y_5760 MINT1_X_4160_Y_5760 1.319
R_VINT1_6029 MINT2_X_4160_Y_6080 MINT1_X_4160_Y_6080 1.319
R_VINT1_6030 MINT2_X_4160_Y_6400 MINT1_X_4160_Y_6400 1.319
R_VINT1_6031 MINT2_X_4160_Y_6720 MINT1_X_4160_Y_6720 1.319
R_VINT1_6032 MINT2_X_4160_Y_7040 MINT1_X_4160_Y_7040 1.319
R_VINT1_6033 MINT2_X_4160_Y_7360 MINT1_X_4160_Y_7360 1.319
R_VINT1_6034 MINT2_X_4160_Y_7680 MINT1_X_4160_Y_7680 1.319
R_VINT1_6035 MINT2_X_4160_Y_8000 MINT1_X_4160_Y_8000 1.319
R_VINT1_6036 MINT2_X_4160_Y_8320 MINT1_X_4160_Y_8320 1.319
R_VINT1_6037 MINT2_X_4160_Y_8640 MINT1_X_4160_Y_8640 1.319
R_VINT1_6038 MINT2_X_4160_Y_8960 MINT1_X_4160_Y_8960 1.319
R_VINT1_6039 MINT2_X_4160_Y_9280 MINT1_X_4160_Y_9280 1.319
R_VINT1_6040 MINT2_X_4160_Y_9600 MINT1_X_4160_Y_9600 1.319
R_VINT1_6041 MINT2_X_4160_Y_9920 MINT1_X_4160_Y_9920 1.319
R_VINT1_6042 MINT2_X_4480_Y_0 MINT1_X_4480_Y_0 1.319
R_VINT1_6043 MINT2_X_4480_Y_320 MINT1_X_4480_Y_320 1.319
R_VINT1_6044 MINT2_X_4480_Y_640 MINT1_X_4480_Y_640 1.319
R_VINT1_6045 MINT2_X_4480_Y_960 MINT1_X_4480_Y_960 1.319
R_VINT1_6046 MINT2_X_4480_Y_1280 MINT1_X_4480_Y_1280 1.319
R_VINT1_6047 MINT2_X_4480_Y_1600 MINT1_X_4480_Y_1600 1.319
R_VINT1_6048 MINT2_X_4480_Y_1920 MINT1_X_4480_Y_1920 1.319
R_VINT1_6049 MINT2_X_4480_Y_2240 MINT1_X_4480_Y_2240 1.319
R_VINT1_6050 MINT2_X_4480_Y_2560 MINT1_X_4480_Y_2560 1.319
R_VINT1_6051 MINT2_X_4480_Y_2880 MINT1_X_4480_Y_2880 1.319
R_VINT1_6052 MINT2_X_4480_Y_3200 MINT1_X_4480_Y_3200 1.319
R_VINT1_6053 MINT2_X_4480_Y_3520 MINT1_X_4480_Y_3520 1.319
R_VINT1_6054 MINT2_X_4480_Y_3840 MINT1_X_4480_Y_3840 1.319
R_VINT1_6055 MINT2_X_4480_Y_4160 MINT1_X_4480_Y_4160 1.319
R_VINT1_6056 MINT2_X_4480_Y_4480 MINT1_X_4480_Y_4480 1.319
R_VINT1_6057 MINT2_X_4480_Y_4800 MINT1_X_4480_Y_4800 1.319
R_VINT1_6058 MINT2_X_4480_Y_5120 MINT1_X_4480_Y_5120 1.319
R_VINT1_6059 MINT2_X_4480_Y_5440 MINT1_X_4480_Y_5440 1.319
R_VINT1_6060 MINT2_X_4480_Y_5760 MINT1_X_4480_Y_5760 1.319
R_VINT1_6061 MINT2_X_4480_Y_6080 MINT1_X_4480_Y_6080 1.319
R_VINT1_6062 MINT2_X_4480_Y_6400 MINT1_X_4480_Y_6400 1.319
R_VINT1_6063 MINT2_X_4480_Y_6720 MINT1_X_4480_Y_6720 1.319
R_VINT1_6064 MINT2_X_4480_Y_7040 MINT1_X_4480_Y_7040 1.319
R_VINT1_6065 MINT2_X_4480_Y_7360 MINT1_X_4480_Y_7360 1.319
R_VINT1_6066 MINT2_X_4480_Y_7680 MINT1_X_4480_Y_7680 1.319
R_VINT1_6067 MINT2_X_4480_Y_8000 MINT1_X_4480_Y_8000 1.319
R_VINT1_6068 MINT2_X_4480_Y_8320 MINT1_X_4480_Y_8320 1.319
R_VINT1_6069 MINT2_X_4480_Y_8640 MINT1_X_4480_Y_8640 1.319
R_VINT1_6070 MINT2_X_4480_Y_8960 MINT1_X_4480_Y_8960 1.319
R_VINT1_6071 MINT2_X_4480_Y_9280 MINT1_X_4480_Y_9280 1.319
R_VINT1_6072 MINT2_X_4480_Y_9600 MINT1_X_4480_Y_9600 1.319
R_VINT1_6073 MINT2_X_4480_Y_9920 MINT1_X_4480_Y_9920 1.319
R_VINT1_6074 MINT2_X_4800_Y_0 MINT1_X_4800_Y_0 1.319
R_VINT1_6075 MINT2_X_4800_Y_320 MINT1_X_4800_Y_320 1.319
R_VINT1_6076 MINT2_X_4800_Y_640 MINT1_X_4800_Y_640 1.319
R_VINT1_6077 MINT2_X_4800_Y_960 MINT1_X_4800_Y_960 1.319
R_VINT1_6078 MINT2_X_4800_Y_1280 MINT1_X_4800_Y_1280 1.319
R_VINT1_6079 MINT2_X_4800_Y_1600 MINT1_X_4800_Y_1600 1.319
R_VINT1_6080 MINT2_X_4800_Y_1920 MINT1_X_4800_Y_1920 1.319
R_VINT1_6081 MINT2_X_4800_Y_2240 MINT1_X_4800_Y_2240 1.319
R_VINT1_6082 MINT2_X_4800_Y_2560 MINT1_X_4800_Y_2560 1.319
R_VINT1_6083 MINT2_X_4800_Y_2880 MINT1_X_4800_Y_2880 1.319
R_VINT1_6084 MINT2_X_4800_Y_3200 MINT1_X_4800_Y_3200 1.319
R_VINT1_6085 MINT2_X_4800_Y_3520 MINT1_X_4800_Y_3520 1.319
R_VINT1_6086 MINT2_X_4800_Y_3840 MINT1_X_4800_Y_3840 1.319
R_VINT1_6087 MINT2_X_4800_Y_4160 MINT1_X_4800_Y_4160 1.319
R_VINT1_6088 MINT2_X_4800_Y_4480 MINT1_X_4800_Y_4480 1.319
R_VINT1_6089 MINT2_X_4800_Y_4800 MINT1_X_4800_Y_4800 1.319
R_VINT1_6090 MINT2_X_4800_Y_5120 MINT1_X_4800_Y_5120 1.319
R_VINT1_6091 MINT2_X_4800_Y_5440 MINT1_X_4800_Y_5440 1.319
R_VINT1_6092 MINT2_X_4800_Y_5760 MINT1_X_4800_Y_5760 1.319
R_VINT1_6093 MINT2_X_4800_Y_6080 MINT1_X_4800_Y_6080 1.319
R_VINT1_6094 MINT2_X_4800_Y_6400 MINT1_X_4800_Y_6400 1.319
R_VINT1_6095 MINT2_X_4800_Y_6720 MINT1_X_4800_Y_6720 1.319
R_VINT1_6096 MINT2_X_4800_Y_7040 MINT1_X_4800_Y_7040 1.319
R_VINT1_6097 MINT2_X_4800_Y_7360 MINT1_X_4800_Y_7360 1.319
R_VINT1_6098 MINT2_X_4800_Y_7680 MINT1_X_4800_Y_7680 1.319
R_VINT1_6099 MINT2_X_4800_Y_8000 MINT1_X_4800_Y_8000 1.319
R_VINT1_6100 MINT2_X_4800_Y_8320 MINT1_X_4800_Y_8320 1.319
R_VINT1_6101 MINT2_X_4800_Y_8640 MINT1_X_4800_Y_8640 1.319
R_VINT1_6102 MINT2_X_4800_Y_8960 MINT1_X_4800_Y_8960 1.319
R_VINT1_6103 MINT2_X_4800_Y_9280 MINT1_X_4800_Y_9280 1.319
R_VINT1_6104 MINT2_X_4800_Y_9600 MINT1_X_4800_Y_9600 1.319
R_VINT1_6105 MINT2_X_4800_Y_9920 MINT1_X_4800_Y_9920 1.319
R_VINT1_6106 MINT2_X_5120_Y_0 MINT1_X_5120_Y_0 1.319
R_VINT1_6107 MINT2_X_5120_Y_320 MINT1_X_5120_Y_320 1.319
R_VINT1_6108 MINT2_X_5120_Y_640 MINT1_X_5120_Y_640 1.319
R_VINT1_6109 MINT2_X_5120_Y_960 MINT1_X_5120_Y_960 1.319
R_VINT1_6110 MINT2_X_5120_Y_1280 MINT1_X_5120_Y_1280 1.319
R_VINT1_6111 MINT2_X_5120_Y_1600 MINT1_X_5120_Y_1600 1.319
R_VINT1_6112 MINT2_X_5120_Y_1920 MINT1_X_5120_Y_1920 1.319
R_VINT1_6113 MINT2_X_5120_Y_2240 MINT1_X_5120_Y_2240 1.319
R_VINT1_6114 MINT2_X_5120_Y_2560 MINT1_X_5120_Y_2560 1.319
R_VINT1_6115 MINT2_X_5120_Y_2880 MINT1_X_5120_Y_2880 1.319
R_VINT1_6116 MINT2_X_5120_Y_3200 MINT1_X_5120_Y_3200 1.319
R_VINT1_6117 MINT2_X_5120_Y_3520 MINT1_X_5120_Y_3520 1.319
R_VINT1_6118 MINT2_X_5120_Y_3840 MINT1_X_5120_Y_3840 1.319
R_VINT1_6119 MINT2_X_5120_Y_4160 MINT1_X_5120_Y_4160 1.319
R_VINT1_6120 MINT2_X_5120_Y_4480 MINT1_X_5120_Y_4480 1.319
R_VINT1_6121 MINT2_X_5120_Y_4800 MINT1_X_5120_Y_4800 1.319
R_VINT1_6122 MINT2_X_5120_Y_5120 MINT1_X_5120_Y_5120 1.319
R_VINT1_6123 MINT2_X_5120_Y_5440 MINT1_X_5120_Y_5440 1.319
R_VINT1_6124 MINT2_X_5120_Y_5760 MINT1_X_5120_Y_5760 1.319
R_VINT1_6125 MINT2_X_5120_Y_6080 MINT1_X_5120_Y_6080 1.319
R_VINT1_6126 MINT2_X_5120_Y_6400 MINT1_X_5120_Y_6400 1.319
R_VINT1_6127 MINT2_X_5120_Y_6720 MINT1_X_5120_Y_6720 1.319
R_VINT1_6128 MINT2_X_5120_Y_7040 MINT1_X_5120_Y_7040 1.319
R_VINT1_6129 MINT2_X_5120_Y_7360 MINT1_X_5120_Y_7360 1.319
R_VINT1_6130 MINT2_X_5120_Y_7680 MINT1_X_5120_Y_7680 1.319
R_VINT1_6131 MINT2_X_5120_Y_8000 MINT1_X_5120_Y_8000 1.319
R_VINT1_6132 MINT2_X_5120_Y_8320 MINT1_X_5120_Y_8320 1.319
R_VINT1_6133 MINT2_X_5120_Y_8640 MINT1_X_5120_Y_8640 1.319
R_VINT1_6134 MINT2_X_5120_Y_8960 MINT1_X_5120_Y_8960 1.319
R_VINT1_6135 MINT2_X_5120_Y_9280 MINT1_X_5120_Y_9280 1.319
R_VINT1_6136 MINT2_X_5120_Y_9600 MINT1_X_5120_Y_9600 1.319
R_VINT1_6137 MINT2_X_5120_Y_9920 MINT1_X_5120_Y_9920 1.319
R_VINT1_6138 MINT2_X_5440_Y_0 MINT1_X_5440_Y_0 1.319
R_VINT1_6139 MINT2_X_5440_Y_320 MINT1_X_5440_Y_320 1.319
R_VINT1_6140 MINT2_X_5440_Y_640 MINT1_X_5440_Y_640 1.319
R_VINT1_6141 MINT2_X_5440_Y_960 MINT1_X_5440_Y_960 1.319
R_VINT1_6142 MINT2_X_5440_Y_1280 MINT1_X_5440_Y_1280 1.319
R_VINT1_6143 MINT2_X_5440_Y_1600 MINT1_X_5440_Y_1600 1.319
R_VINT1_6144 MINT2_X_5440_Y_1920 MINT1_X_5440_Y_1920 1.319
R_VINT1_6145 MINT2_X_5440_Y_2240 MINT1_X_5440_Y_2240 1.319
R_VINT1_6146 MINT2_X_5440_Y_2560 MINT1_X_5440_Y_2560 1.319
R_VINT1_6147 MINT2_X_5440_Y_2880 MINT1_X_5440_Y_2880 1.319
R_VINT1_6148 MINT2_X_5440_Y_3200 MINT1_X_5440_Y_3200 1.319
R_VINT1_6149 MINT2_X_5440_Y_3520 MINT1_X_5440_Y_3520 1.319
R_VINT1_6150 MINT2_X_5440_Y_3840 MINT1_X_5440_Y_3840 1.319
R_VINT1_6151 MINT2_X_5440_Y_4160 MINT1_X_5440_Y_4160 1.319
R_VINT1_6152 MINT2_X_5440_Y_4480 MINT1_X_5440_Y_4480 1.319
R_VINT1_6153 MINT2_X_5440_Y_4800 MINT1_X_5440_Y_4800 1.319
R_VINT1_6154 MINT2_X_5440_Y_5120 MINT1_X_5440_Y_5120 1.319
R_VINT1_6155 MINT2_X_5440_Y_5440 MINT1_X_5440_Y_5440 1.319
R_VINT1_6156 MINT2_X_5440_Y_5760 MINT1_X_5440_Y_5760 1.319
R_VINT1_6157 MINT2_X_5440_Y_6080 MINT1_X_5440_Y_6080 1.319
R_VINT1_6158 MINT2_X_5440_Y_6400 MINT1_X_5440_Y_6400 1.319
R_VINT1_6159 MINT2_X_5440_Y_6720 MINT1_X_5440_Y_6720 1.319
R_VINT1_6160 MINT2_X_5440_Y_7040 MINT1_X_5440_Y_7040 1.319
R_VINT1_6161 MINT2_X_5440_Y_7360 MINT1_X_5440_Y_7360 1.319
R_VINT1_6162 MINT2_X_5440_Y_7680 MINT1_X_5440_Y_7680 1.319
R_VINT1_6163 MINT2_X_5440_Y_8000 MINT1_X_5440_Y_8000 1.319
R_VINT1_6164 MINT2_X_5440_Y_8320 MINT1_X_5440_Y_8320 1.319
R_VINT1_6165 MINT2_X_5440_Y_8640 MINT1_X_5440_Y_8640 1.319
R_VINT1_6166 MINT2_X_5440_Y_8960 MINT1_X_5440_Y_8960 1.319
R_VINT1_6167 MINT2_X_5440_Y_9280 MINT1_X_5440_Y_9280 1.319
R_VINT1_6168 MINT2_X_5440_Y_9600 MINT1_X_5440_Y_9600 1.319
R_VINT1_6169 MINT2_X_5440_Y_9920 MINT1_X_5440_Y_9920 1.319
R_VINT1_6170 MINT2_X_5760_Y_0 MINT1_X_5760_Y_0 1.319
R_VINT1_6171 MINT2_X_5760_Y_320 MINT1_X_5760_Y_320 1.319
R_VINT1_6172 MINT2_X_5760_Y_640 MINT1_X_5760_Y_640 1.319
R_VINT1_6173 MINT2_X_5760_Y_960 MINT1_X_5760_Y_960 1.319
R_VINT1_6174 MINT2_X_5760_Y_1280 MINT1_X_5760_Y_1280 1.319
R_VINT1_6175 MINT2_X_5760_Y_1600 MINT1_X_5760_Y_1600 1.319
R_VINT1_6176 MINT2_X_5760_Y_1920 MINT1_X_5760_Y_1920 1.319
R_VINT1_6177 MINT2_X_5760_Y_2240 MINT1_X_5760_Y_2240 1.319
R_VINT1_6178 MINT2_X_5760_Y_2560 MINT1_X_5760_Y_2560 1.319
R_VINT1_6179 MINT2_X_5760_Y_2880 MINT1_X_5760_Y_2880 1.319
R_VINT1_6180 MINT2_X_5760_Y_3200 MINT1_X_5760_Y_3200 1.319
R_VINT1_6181 MINT2_X_5760_Y_3520 MINT1_X_5760_Y_3520 1.319
R_VINT1_6182 MINT2_X_5760_Y_3840 MINT1_X_5760_Y_3840 1.319
R_VINT1_6183 MINT2_X_5760_Y_4160 MINT1_X_5760_Y_4160 1.319
R_VINT1_6184 MINT2_X_5760_Y_4480 MINT1_X_5760_Y_4480 1.319
R_VINT1_6185 MINT2_X_5760_Y_4800 MINT1_X_5760_Y_4800 1.319
R_VINT1_6186 MINT2_X_5760_Y_5120 MINT1_X_5760_Y_5120 1.319
R_VINT1_6187 MINT2_X_5760_Y_5440 MINT1_X_5760_Y_5440 1.319
R_VINT1_6188 MINT2_X_5760_Y_5760 MINT1_X_5760_Y_5760 1.319
R_VINT1_6189 MINT2_X_5760_Y_6080 MINT1_X_5760_Y_6080 1.319
R_VINT1_6190 MINT2_X_5760_Y_6400 MINT1_X_5760_Y_6400 1.319
R_VINT1_6191 MINT2_X_5760_Y_6720 MINT1_X_5760_Y_6720 1.319
R_VINT1_6192 MINT2_X_5760_Y_7040 MINT1_X_5760_Y_7040 1.319
R_VINT1_6193 MINT2_X_5760_Y_7360 MINT1_X_5760_Y_7360 1.319
R_VINT1_6194 MINT2_X_5760_Y_7680 MINT1_X_5760_Y_7680 1.319
R_VINT1_6195 MINT2_X_5760_Y_8000 MINT1_X_5760_Y_8000 1.319
R_VINT1_6196 MINT2_X_5760_Y_8320 MINT1_X_5760_Y_8320 1.319
R_VINT1_6197 MINT2_X_5760_Y_8640 MINT1_X_5760_Y_8640 1.319
R_VINT1_6198 MINT2_X_5760_Y_8960 MINT1_X_5760_Y_8960 1.319
R_VINT1_6199 MINT2_X_5760_Y_9280 MINT1_X_5760_Y_9280 1.319
R_VINT1_6200 MINT2_X_5760_Y_9600 MINT1_X_5760_Y_9600 1.319
R_VINT1_6201 MINT2_X_5760_Y_9920 MINT1_X_5760_Y_9920 1.319
R_VINT1_6202 MINT2_X_6080_Y_0 MINT1_X_6080_Y_0 1.319
R_VINT1_6203 MINT2_X_6080_Y_320 MINT1_X_6080_Y_320 1.319
R_VINT1_6204 MINT2_X_6080_Y_640 MINT1_X_6080_Y_640 1.319
R_VINT1_6205 MINT2_X_6080_Y_960 MINT1_X_6080_Y_960 1.319
R_VINT1_6206 MINT2_X_6080_Y_1280 MINT1_X_6080_Y_1280 1.319
R_VINT1_6207 MINT2_X_6080_Y_1600 MINT1_X_6080_Y_1600 1.319
R_VINT1_6208 MINT2_X_6080_Y_1920 MINT1_X_6080_Y_1920 1.319
R_VINT1_6209 MINT2_X_6080_Y_2240 MINT1_X_6080_Y_2240 1.319
R_VINT1_6210 MINT2_X_6080_Y_2560 MINT1_X_6080_Y_2560 1.319
R_VINT1_6211 MINT2_X_6080_Y_2880 MINT1_X_6080_Y_2880 1.319
R_VINT1_6212 MINT2_X_6080_Y_3200 MINT1_X_6080_Y_3200 1.319
R_VINT1_6213 MINT2_X_6080_Y_3520 MINT1_X_6080_Y_3520 1.319
R_VINT1_6214 MINT2_X_6080_Y_3840 MINT1_X_6080_Y_3840 1.319
R_VINT1_6215 MINT2_X_6080_Y_4160 MINT1_X_6080_Y_4160 1.319
R_VINT1_6216 MINT2_X_6080_Y_4480 MINT1_X_6080_Y_4480 1.319
R_VINT1_6217 MINT2_X_6080_Y_4800 MINT1_X_6080_Y_4800 1.319
R_VINT1_6218 MINT2_X_6080_Y_5120 MINT1_X_6080_Y_5120 1.319
R_VINT1_6219 MINT2_X_6080_Y_5440 MINT1_X_6080_Y_5440 1.319
R_VINT1_6220 MINT2_X_6080_Y_5760 MINT1_X_6080_Y_5760 1.319
R_VINT1_6221 MINT2_X_6080_Y_6080 MINT1_X_6080_Y_6080 1.319
R_VINT1_6222 MINT2_X_6080_Y_6400 MINT1_X_6080_Y_6400 1.319
R_VINT1_6223 MINT2_X_6080_Y_6720 MINT1_X_6080_Y_6720 1.319
R_VINT1_6224 MINT2_X_6080_Y_7040 MINT1_X_6080_Y_7040 1.319
R_VINT1_6225 MINT2_X_6080_Y_7360 MINT1_X_6080_Y_7360 1.319
R_VINT1_6226 MINT2_X_6080_Y_7680 MINT1_X_6080_Y_7680 1.319
R_VINT1_6227 MINT2_X_6080_Y_8000 MINT1_X_6080_Y_8000 1.319
R_VINT1_6228 MINT2_X_6080_Y_8320 MINT1_X_6080_Y_8320 1.319
R_VINT1_6229 MINT2_X_6080_Y_8640 MINT1_X_6080_Y_8640 1.319
R_VINT1_6230 MINT2_X_6080_Y_8960 MINT1_X_6080_Y_8960 1.319
R_VINT1_6231 MINT2_X_6080_Y_9280 MINT1_X_6080_Y_9280 1.319
R_VINT1_6232 MINT2_X_6080_Y_9600 MINT1_X_6080_Y_9600 1.319
R_VINT1_6233 MINT2_X_6080_Y_9920 MINT1_X_6080_Y_9920 1.319
R_VINT1_6234 MINT2_X_6400_Y_0 MINT1_X_6400_Y_0 1.319
R_VINT1_6235 MINT2_X_6400_Y_320 MINT1_X_6400_Y_320 1.319
R_VINT1_6236 MINT2_X_6400_Y_640 MINT1_X_6400_Y_640 1.319
R_VINT1_6237 MINT2_X_6400_Y_960 MINT1_X_6400_Y_960 1.319
R_VINT1_6238 MINT2_X_6400_Y_1280 MINT1_X_6400_Y_1280 1.319
R_VINT1_6239 MINT2_X_6400_Y_1600 MINT1_X_6400_Y_1600 1.319
R_VINT1_6240 MINT2_X_6400_Y_1920 MINT1_X_6400_Y_1920 1.319
R_VINT1_6241 MINT2_X_6400_Y_2240 MINT1_X_6400_Y_2240 1.319
R_VINT1_6242 MINT2_X_6400_Y_2560 MINT1_X_6400_Y_2560 1.319
R_VINT1_6243 MINT2_X_6400_Y_2880 MINT1_X_6400_Y_2880 1.319
R_VINT1_6244 MINT2_X_6400_Y_3200 MINT1_X_6400_Y_3200 1.319
R_VINT1_6245 MINT2_X_6400_Y_3520 MINT1_X_6400_Y_3520 1.319
R_VINT1_6246 MINT2_X_6400_Y_3840 MINT1_X_6400_Y_3840 1.319
R_VINT1_6247 MINT2_X_6400_Y_4160 MINT1_X_6400_Y_4160 1.319
R_VINT1_6248 MINT2_X_6400_Y_4480 MINT1_X_6400_Y_4480 1.319
R_VINT1_6249 MINT2_X_6400_Y_4800 MINT1_X_6400_Y_4800 1.319
R_VINT1_6250 MINT2_X_6400_Y_5120 MINT1_X_6400_Y_5120 1.319
R_VINT1_6251 MINT2_X_6400_Y_5440 MINT1_X_6400_Y_5440 1.319
R_VINT1_6252 MINT2_X_6400_Y_5760 MINT1_X_6400_Y_5760 1.319
R_VINT1_6253 MINT2_X_6400_Y_6080 MINT1_X_6400_Y_6080 1.319
R_VINT1_6254 MINT2_X_6400_Y_6400 MINT1_X_6400_Y_6400 1.319
R_VINT1_6255 MINT2_X_6400_Y_6720 MINT1_X_6400_Y_6720 1.319
R_VINT1_6256 MINT2_X_6400_Y_7040 MINT1_X_6400_Y_7040 1.319
R_VINT1_6257 MINT2_X_6400_Y_7360 MINT1_X_6400_Y_7360 1.319
R_VINT1_6258 MINT2_X_6400_Y_7680 MINT1_X_6400_Y_7680 1.319
R_VINT1_6259 MINT2_X_6400_Y_8000 MINT1_X_6400_Y_8000 1.319
R_VINT1_6260 MINT2_X_6400_Y_8320 MINT1_X_6400_Y_8320 1.319
R_VINT1_6261 MINT2_X_6400_Y_8640 MINT1_X_6400_Y_8640 1.319
R_VINT1_6262 MINT2_X_6400_Y_8960 MINT1_X_6400_Y_8960 1.319
R_VINT1_6263 MINT2_X_6400_Y_9280 MINT1_X_6400_Y_9280 1.319
R_VINT1_6264 MINT2_X_6400_Y_9600 MINT1_X_6400_Y_9600 1.319
R_VINT1_6265 MINT2_X_6400_Y_9920 MINT1_X_6400_Y_9920 1.319
R_VINT1_6266 MINT2_X_6720_Y_0 MINT1_X_6720_Y_0 1.319
R_VINT1_6267 MINT2_X_6720_Y_320 MINT1_X_6720_Y_320 1.319
R_VINT1_6268 MINT2_X_6720_Y_640 MINT1_X_6720_Y_640 1.319
R_VINT1_6269 MINT2_X_6720_Y_960 MINT1_X_6720_Y_960 1.319
R_VINT1_6270 MINT2_X_6720_Y_1280 MINT1_X_6720_Y_1280 1.319
R_VINT1_6271 MINT2_X_6720_Y_1600 MINT1_X_6720_Y_1600 1.319
R_VINT1_6272 MINT2_X_6720_Y_1920 MINT1_X_6720_Y_1920 1.319
R_VINT1_6273 MINT2_X_6720_Y_2240 MINT1_X_6720_Y_2240 1.319
R_VINT1_6274 MINT2_X_6720_Y_2560 MINT1_X_6720_Y_2560 1.319
R_VINT1_6275 MINT2_X_6720_Y_2880 MINT1_X_6720_Y_2880 1.319
R_VINT1_6276 MINT2_X_6720_Y_3200 MINT1_X_6720_Y_3200 1.319
R_VINT1_6277 MINT2_X_6720_Y_3520 MINT1_X_6720_Y_3520 1.319
R_VINT1_6278 MINT2_X_6720_Y_3840 MINT1_X_6720_Y_3840 1.319
R_VINT1_6279 MINT2_X_6720_Y_4160 MINT1_X_6720_Y_4160 1.319
R_VINT1_6280 MINT2_X_6720_Y_4480 MINT1_X_6720_Y_4480 1.319
R_VINT1_6281 MINT2_X_6720_Y_4800 MINT1_X_6720_Y_4800 1.319
R_VINT1_6282 MINT2_X_6720_Y_5120 MINT1_X_6720_Y_5120 1.319
R_VINT1_6283 MINT2_X_6720_Y_5440 MINT1_X_6720_Y_5440 1.319
R_VINT1_6284 MINT2_X_6720_Y_5760 MINT1_X_6720_Y_5760 1.319
R_VINT1_6285 MINT2_X_6720_Y_6080 MINT1_X_6720_Y_6080 1.319
R_VINT1_6286 MINT2_X_6720_Y_6400 MINT1_X_6720_Y_6400 1.319
R_VINT1_6287 MINT2_X_6720_Y_6720 MINT1_X_6720_Y_6720 1.319
R_VINT1_6288 MINT2_X_6720_Y_7040 MINT1_X_6720_Y_7040 1.319
R_VINT1_6289 MINT2_X_6720_Y_7360 MINT1_X_6720_Y_7360 1.319
R_VINT1_6290 MINT2_X_6720_Y_7680 MINT1_X_6720_Y_7680 1.319
R_VINT1_6291 MINT2_X_6720_Y_8000 MINT1_X_6720_Y_8000 1.319
R_VINT1_6292 MINT2_X_6720_Y_8320 MINT1_X_6720_Y_8320 1.319
R_VINT1_6293 MINT2_X_6720_Y_8640 MINT1_X_6720_Y_8640 1.319
R_VINT1_6294 MINT2_X_6720_Y_8960 MINT1_X_6720_Y_8960 1.319
R_VINT1_6295 MINT2_X_6720_Y_9280 MINT1_X_6720_Y_9280 1.319
R_VINT1_6296 MINT2_X_6720_Y_9600 MINT1_X_6720_Y_9600 1.319
R_VINT1_6297 MINT2_X_6720_Y_9920 MINT1_X_6720_Y_9920 1.319
R_VINT1_6298 MINT2_X_7040_Y_0 MINT1_X_7040_Y_0 1.319
R_VINT1_6299 MINT2_X_7040_Y_320 MINT1_X_7040_Y_320 1.319
R_VINT1_6300 MINT2_X_7040_Y_640 MINT1_X_7040_Y_640 1.319
R_VINT1_6301 MINT2_X_7040_Y_960 MINT1_X_7040_Y_960 1.319
R_VINT1_6302 MINT2_X_7040_Y_1280 MINT1_X_7040_Y_1280 1.319
R_VINT1_6303 MINT2_X_7040_Y_1600 MINT1_X_7040_Y_1600 1.319
R_VINT1_6304 MINT2_X_7040_Y_1920 MINT1_X_7040_Y_1920 1.319
R_VINT1_6305 MINT2_X_7040_Y_2240 MINT1_X_7040_Y_2240 1.319
R_VINT1_6306 MINT2_X_7040_Y_2560 MINT1_X_7040_Y_2560 1.319
R_VINT1_6307 MINT2_X_7040_Y_2880 MINT1_X_7040_Y_2880 1.319
R_VINT1_6308 MINT2_X_7040_Y_3200 MINT1_X_7040_Y_3200 1.319
R_VINT1_6309 MINT2_X_7040_Y_3520 MINT1_X_7040_Y_3520 1.319
R_VINT1_6310 MINT2_X_7040_Y_3840 MINT1_X_7040_Y_3840 1.319
R_VINT1_6311 MINT2_X_7040_Y_4160 MINT1_X_7040_Y_4160 1.319
R_VINT1_6312 MINT2_X_7040_Y_4480 MINT1_X_7040_Y_4480 1.319
R_VINT1_6313 MINT2_X_7040_Y_4800 MINT1_X_7040_Y_4800 1.319
R_VINT1_6314 MINT2_X_7040_Y_5120 MINT1_X_7040_Y_5120 1.319
R_VINT1_6315 MINT2_X_7040_Y_5440 MINT1_X_7040_Y_5440 1.319
R_VINT1_6316 MINT2_X_7040_Y_5760 MINT1_X_7040_Y_5760 1.319
R_VINT1_6317 MINT2_X_7040_Y_6080 MINT1_X_7040_Y_6080 1.319
R_VINT1_6318 MINT2_X_7040_Y_6400 MINT1_X_7040_Y_6400 1.319
R_VINT1_6319 MINT2_X_7040_Y_6720 MINT1_X_7040_Y_6720 1.319
R_VINT1_6320 MINT2_X_7040_Y_7040 MINT1_X_7040_Y_7040 1.319
R_VINT1_6321 MINT2_X_7040_Y_7360 MINT1_X_7040_Y_7360 1.319
R_VINT1_6322 MINT2_X_7040_Y_7680 MINT1_X_7040_Y_7680 1.319
R_VINT1_6323 MINT2_X_7040_Y_8000 MINT1_X_7040_Y_8000 1.319
R_VINT1_6324 MINT2_X_7040_Y_8320 MINT1_X_7040_Y_8320 1.319
R_VINT1_6325 MINT2_X_7040_Y_8640 MINT1_X_7040_Y_8640 1.319
R_VINT1_6326 MINT2_X_7040_Y_8960 MINT1_X_7040_Y_8960 1.319
R_VINT1_6327 MINT2_X_7040_Y_9280 MINT1_X_7040_Y_9280 1.319
R_VINT1_6328 MINT2_X_7040_Y_9600 MINT1_X_7040_Y_9600 1.319
R_VINT1_6329 MINT2_X_7040_Y_9920 MINT1_X_7040_Y_9920 1.319
R_VINT1_6330 MINT2_X_7360_Y_0 MINT1_X_7360_Y_0 1.319
R_VINT1_6331 MINT2_X_7360_Y_320 MINT1_X_7360_Y_320 1.319
R_VINT1_6332 MINT2_X_7360_Y_640 MINT1_X_7360_Y_640 1.319
R_VINT1_6333 MINT2_X_7360_Y_960 MINT1_X_7360_Y_960 1.319
R_VINT1_6334 MINT2_X_7360_Y_1280 MINT1_X_7360_Y_1280 1.319
R_VINT1_6335 MINT2_X_7360_Y_1600 MINT1_X_7360_Y_1600 1.319
R_VINT1_6336 MINT2_X_7360_Y_1920 MINT1_X_7360_Y_1920 1.319
R_VINT1_6337 MINT2_X_7360_Y_2240 MINT1_X_7360_Y_2240 1.319
R_VINT1_6338 MINT2_X_7360_Y_2560 MINT1_X_7360_Y_2560 1.319
R_VINT1_6339 MINT2_X_7360_Y_2880 MINT1_X_7360_Y_2880 1.319
R_VINT1_6340 MINT2_X_7360_Y_3200 MINT1_X_7360_Y_3200 1.319
R_VINT1_6341 MINT2_X_7360_Y_3520 MINT1_X_7360_Y_3520 1.319
R_VINT1_6342 MINT2_X_7360_Y_3840 MINT1_X_7360_Y_3840 1.319
R_VINT1_6343 MINT2_X_7360_Y_4160 MINT1_X_7360_Y_4160 1.319
R_VINT1_6344 MINT2_X_7360_Y_4480 MINT1_X_7360_Y_4480 1.319
R_VINT1_6345 MINT2_X_7360_Y_4800 MINT1_X_7360_Y_4800 1.319
R_VINT1_6346 MINT2_X_7360_Y_5120 MINT1_X_7360_Y_5120 1.319
R_VINT1_6347 MINT2_X_7360_Y_5440 MINT1_X_7360_Y_5440 1.319
R_VINT1_6348 MINT2_X_7360_Y_5760 MINT1_X_7360_Y_5760 1.319
R_VINT1_6349 MINT2_X_7360_Y_6080 MINT1_X_7360_Y_6080 1.319
R_VINT1_6350 MINT2_X_7360_Y_6400 MINT1_X_7360_Y_6400 1.319
R_VINT1_6351 MINT2_X_7360_Y_6720 MINT1_X_7360_Y_6720 1.319
R_VINT1_6352 MINT2_X_7360_Y_7040 MINT1_X_7360_Y_7040 1.319
R_VINT1_6353 MINT2_X_7360_Y_7360 MINT1_X_7360_Y_7360 1.319
R_VINT1_6354 MINT2_X_7360_Y_7680 MINT1_X_7360_Y_7680 1.319
R_VINT1_6355 MINT2_X_7360_Y_8000 MINT1_X_7360_Y_8000 1.319
R_VINT1_6356 MINT2_X_7360_Y_8320 MINT1_X_7360_Y_8320 1.319
R_VINT1_6357 MINT2_X_7360_Y_8640 MINT1_X_7360_Y_8640 1.319
R_VINT1_6358 MINT2_X_7360_Y_8960 MINT1_X_7360_Y_8960 1.319
R_VINT1_6359 MINT2_X_7360_Y_9280 MINT1_X_7360_Y_9280 1.319
R_VINT1_6360 MINT2_X_7360_Y_9600 MINT1_X_7360_Y_9600 1.319
R_VINT1_6361 MINT2_X_7360_Y_9920 MINT1_X_7360_Y_9920 1.319
R_VINT1_6362 MINT2_X_7680_Y_0 MINT1_X_7680_Y_0 1.319
R_VINT1_6363 MINT2_X_7680_Y_320 MINT1_X_7680_Y_320 1.319
R_VINT1_6364 MINT2_X_7680_Y_640 MINT1_X_7680_Y_640 1.319
R_VINT1_6365 MINT2_X_7680_Y_960 MINT1_X_7680_Y_960 1.319
R_VINT1_6366 MINT2_X_7680_Y_1280 MINT1_X_7680_Y_1280 1.319
R_VINT1_6367 MINT2_X_7680_Y_1600 MINT1_X_7680_Y_1600 1.319
R_VINT1_6368 MINT2_X_7680_Y_1920 MINT1_X_7680_Y_1920 1.319
R_VINT1_6369 MINT2_X_7680_Y_2240 MINT1_X_7680_Y_2240 1.319
R_VINT1_6370 MINT2_X_7680_Y_2560 MINT1_X_7680_Y_2560 1.319
R_VINT1_6371 MINT2_X_7680_Y_2880 MINT1_X_7680_Y_2880 1.319
R_VINT1_6372 MINT2_X_7680_Y_3200 MINT1_X_7680_Y_3200 1.319
R_VINT1_6373 MINT2_X_7680_Y_3520 MINT1_X_7680_Y_3520 1.319
R_VINT1_6374 MINT2_X_7680_Y_3840 MINT1_X_7680_Y_3840 1.319
R_VINT1_6375 MINT2_X_7680_Y_4160 MINT1_X_7680_Y_4160 1.319
R_VINT1_6376 MINT2_X_7680_Y_4480 MINT1_X_7680_Y_4480 1.319
R_VINT1_6377 MINT2_X_7680_Y_4800 MINT1_X_7680_Y_4800 1.319
R_VINT1_6378 MINT2_X_7680_Y_5120 MINT1_X_7680_Y_5120 1.319
R_VINT1_6379 MINT2_X_7680_Y_5440 MINT1_X_7680_Y_5440 1.319
R_VINT1_6380 MINT2_X_7680_Y_5760 MINT1_X_7680_Y_5760 1.319
R_VINT1_6381 MINT2_X_7680_Y_6080 MINT1_X_7680_Y_6080 1.319
R_VINT1_6382 MINT2_X_7680_Y_6400 MINT1_X_7680_Y_6400 1.319
R_VINT1_6383 MINT2_X_7680_Y_6720 MINT1_X_7680_Y_6720 1.319
R_VINT1_6384 MINT2_X_7680_Y_7040 MINT1_X_7680_Y_7040 1.319
R_VINT1_6385 MINT2_X_7680_Y_7360 MINT1_X_7680_Y_7360 1.319
R_VINT1_6386 MINT2_X_7680_Y_7680 MINT1_X_7680_Y_7680 1.319
R_VINT1_6387 MINT2_X_7680_Y_8000 MINT1_X_7680_Y_8000 1.319
R_VINT1_6388 MINT2_X_7680_Y_8320 MINT1_X_7680_Y_8320 1.319
R_VINT1_6389 MINT2_X_7680_Y_8640 MINT1_X_7680_Y_8640 1.319
R_VINT1_6390 MINT2_X_7680_Y_8960 MINT1_X_7680_Y_8960 1.319
R_VINT1_6391 MINT2_X_7680_Y_9280 MINT1_X_7680_Y_9280 1.319
R_VINT1_6392 MINT2_X_7680_Y_9600 MINT1_X_7680_Y_9600 1.319
R_VINT1_6393 MINT2_X_7680_Y_9920 MINT1_X_7680_Y_9920 1.319
R_VINT1_6394 MINT2_X_8000_Y_0 MINT1_X_8000_Y_0 1.319
R_VINT1_6395 MINT2_X_8000_Y_320 MINT1_X_8000_Y_320 1.319
R_VINT1_6396 MINT2_X_8000_Y_640 MINT1_X_8000_Y_640 1.319
R_VINT1_6397 MINT2_X_8000_Y_960 MINT1_X_8000_Y_960 1.319
R_VINT1_6398 MINT2_X_8000_Y_1280 MINT1_X_8000_Y_1280 1.319
R_VINT1_6399 MINT2_X_8000_Y_1600 MINT1_X_8000_Y_1600 1.319
R_VINT1_6400 MINT2_X_8000_Y_1920 MINT1_X_8000_Y_1920 1.319
R_VINT1_6401 MINT2_X_8000_Y_2240 MINT1_X_8000_Y_2240 1.319
R_VINT1_6402 MINT2_X_8000_Y_2560 MINT1_X_8000_Y_2560 1.319
R_VINT1_6403 MINT2_X_8000_Y_2880 MINT1_X_8000_Y_2880 1.319
R_VINT1_6404 MINT2_X_8000_Y_3200 MINT1_X_8000_Y_3200 1.319
R_VINT1_6405 MINT2_X_8000_Y_3520 MINT1_X_8000_Y_3520 1.319
R_VINT1_6406 MINT2_X_8000_Y_3840 MINT1_X_8000_Y_3840 1.319
R_VINT1_6407 MINT2_X_8000_Y_4160 MINT1_X_8000_Y_4160 1.319
R_VINT1_6408 MINT2_X_8000_Y_4480 MINT1_X_8000_Y_4480 1.319
R_VINT1_6409 MINT2_X_8000_Y_4800 MINT1_X_8000_Y_4800 1.319
R_VINT1_6410 MINT2_X_8000_Y_5120 MINT1_X_8000_Y_5120 1.319
R_VINT1_6411 MINT2_X_8000_Y_5440 MINT1_X_8000_Y_5440 1.319
R_VINT1_6412 MINT2_X_8000_Y_5760 MINT1_X_8000_Y_5760 1.319
R_VINT1_6413 MINT2_X_8000_Y_6080 MINT1_X_8000_Y_6080 1.319
R_VINT1_6414 MINT2_X_8000_Y_6400 MINT1_X_8000_Y_6400 1.319
R_VINT1_6415 MINT2_X_8000_Y_6720 MINT1_X_8000_Y_6720 1.319
R_VINT1_6416 MINT2_X_8000_Y_7040 MINT1_X_8000_Y_7040 1.319
R_VINT1_6417 MINT2_X_8000_Y_7360 MINT1_X_8000_Y_7360 1.319
R_VINT1_6418 MINT2_X_8000_Y_7680 MINT1_X_8000_Y_7680 1.319
R_VINT1_6419 MINT2_X_8000_Y_8000 MINT1_X_8000_Y_8000 1.319
R_VINT1_6420 MINT2_X_8000_Y_8320 MINT1_X_8000_Y_8320 1.319
R_VINT1_6421 MINT2_X_8000_Y_8640 MINT1_X_8000_Y_8640 1.319
R_VINT1_6422 MINT2_X_8000_Y_8960 MINT1_X_8000_Y_8960 1.319
R_VINT1_6423 MINT2_X_8000_Y_9280 MINT1_X_8000_Y_9280 1.319
R_VINT1_6424 MINT2_X_8000_Y_9600 MINT1_X_8000_Y_9600 1.319
R_VINT1_6425 MINT2_X_8000_Y_9920 MINT1_X_8000_Y_9920 1.319
R_VINT1_6426 MINT2_X_8320_Y_0 MINT1_X_8320_Y_0 1.319
R_VINT1_6427 MINT2_X_8320_Y_320 MINT1_X_8320_Y_320 1.319
R_VINT1_6428 MINT2_X_8320_Y_640 MINT1_X_8320_Y_640 1.319
R_VINT1_6429 MINT2_X_8320_Y_960 MINT1_X_8320_Y_960 1.319
R_VINT1_6430 MINT2_X_8320_Y_1280 MINT1_X_8320_Y_1280 1.319
R_VINT1_6431 MINT2_X_8320_Y_1600 MINT1_X_8320_Y_1600 1.319
R_VINT1_6432 MINT2_X_8320_Y_1920 MINT1_X_8320_Y_1920 1.319
R_VINT1_6433 MINT2_X_8320_Y_2240 MINT1_X_8320_Y_2240 1.319
R_VINT1_6434 MINT2_X_8320_Y_2560 MINT1_X_8320_Y_2560 1.319
R_VINT1_6435 MINT2_X_8320_Y_2880 MINT1_X_8320_Y_2880 1.319
R_VINT1_6436 MINT2_X_8320_Y_3200 MINT1_X_8320_Y_3200 1.319
R_VINT1_6437 MINT2_X_8320_Y_3520 MINT1_X_8320_Y_3520 1.319
R_VINT1_6438 MINT2_X_8320_Y_3840 MINT1_X_8320_Y_3840 1.319
R_VINT1_6439 MINT2_X_8320_Y_4160 MINT1_X_8320_Y_4160 1.319
R_VINT1_6440 MINT2_X_8320_Y_4480 MINT1_X_8320_Y_4480 1.319
R_VINT1_6441 MINT2_X_8320_Y_4800 MINT1_X_8320_Y_4800 1.319
R_VINT1_6442 MINT2_X_8320_Y_5120 MINT1_X_8320_Y_5120 1.319
R_VINT1_6443 MINT2_X_8320_Y_5440 MINT1_X_8320_Y_5440 1.319
R_VINT1_6444 MINT2_X_8320_Y_5760 MINT1_X_8320_Y_5760 1.319
R_VINT1_6445 MINT2_X_8320_Y_6080 MINT1_X_8320_Y_6080 1.319
R_VINT1_6446 MINT2_X_8320_Y_6400 MINT1_X_8320_Y_6400 1.319
R_VINT1_6447 MINT2_X_8320_Y_6720 MINT1_X_8320_Y_6720 1.319
R_VINT1_6448 MINT2_X_8320_Y_7040 MINT1_X_8320_Y_7040 1.319
R_VINT1_6449 MINT2_X_8320_Y_7360 MINT1_X_8320_Y_7360 1.319
R_VINT1_6450 MINT2_X_8320_Y_7680 MINT1_X_8320_Y_7680 1.319
R_VINT1_6451 MINT2_X_8320_Y_8000 MINT1_X_8320_Y_8000 1.319
R_VINT1_6452 MINT2_X_8320_Y_8320 MINT1_X_8320_Y_8320 1.319
R_VINT1_6453 MINT2_X_8320_Y_8640 MINT1_X_8320_Y_8640 1.319
R_VINT1_6454 MINT2_X_8320_Y_8960 MINT1_X_8320_Y_8960 1.319
R_VINT1_6455 MINT2_X_8320_Y_9280 MINT1_X_8320_Y_9280 1.319
R_VINT1_6456 MINT2_X_8320_Y_9600 MINT1_X_8320_Y_9600 1.319
R_VINT1_6457 MINT2_X_8320_Y_9920 MINT1_X_8320_Y_9920 1.319
R_VINT1_6458 MINT2_X_8640_Y_0 MINT1_X_8640_Y_0 1.319
R_VINT1_6459 MINT2_X_8640_Y_320 MINT1_X_8640_Y_320 1.319
R_VINT1_6460 MINT2_X_8640_Y_640 MINT1_X_8640_Y_640 1.319
R_VINT1_6461 MINT2_X_8640_Y_960 MINT1_X_8640_Y_960 1.319
R_VINT1_6462 MINT2_X_8640_Y_1280 MINT1_X_8640_Y_1280 1.319
R_VINT1_6463 MINT2_X_8640_Y_1600 MINT1_X_8640_Y_1600 1.319
R_VINT1_6464 MINT2_X_8640_Y_1920 MINT1_X_8640_Y_1920 1.319
R_VINT1_6465 MINT2_X_8640_Y_2240 MINT1_X_8640_Y_2240 1.319
R_VINT1_6466 MINT2_X_8640_Y_2560 MINT1_X_8640_Y_2560 1.319
R_VINT1_6467 MINT2_X_8640_Y_2880 MINT1_X_8640_Y_2880 1.319
R_VINT1_6468 MINT2_X_8640_Y_3200 MINT1_X_8640_Y_3200 1.319
R_VINT1_6469 MINT2_X_8640_Y_3520 MINT1_X_8640_Y_3520 1.319
R_VINT1_6470 MINT2_X_8640_Y_3840 MINT1_X_8640_Y_3840 1.319
R_VINT1_6471 MINT2_X_8640_Y_4160 MINT1_X_8640_Y_4160 1.319
R_VINT1_6472 MINT2_X_8640_Y_4480 MINT1_X_8640_Y_4480 1.319
R_VINT1_6473 MINT2_X_8640_Y_4800 MINT1_X_8640_Y_4800 1.319
R_VINT1_6474 MINT2_X_8640_Y_5120 MINT1_X_8640_Y_5120 1.319
R_VINT1_6475 MINT2_X_8640_Y_5440 MINT1_X_8640_Y_5440 1.319
R_VINT1_6476 MINT2_X_8640_Y_5760 MINT1_X_8640_Y_5760 1.319
R_VINT1_6477 MINT2_X_8640_Y_6080 MINT1_X_8640_Y_6080 1.319
R_VINT1_6478 MINT2_X_8640_Y_6400 MINT1_X_8640_Y_6400 1.319
R_VINT1_6479 MINT2_X_8640_Y_6720 MINT1_X_8640_Y_6720 1.319
R_VINT1_6480 MINT2_X_8640_Y_7040 MINT1_X_8640_Y_7040 1.319
R_VINT1_6481 MINT2_X_8640_Y_7360 MINT1_X_8640_Y_7360 1.319
R_VINT1_6482 MINT2_X_8640_Y_7680 MINT1_X_8640_Y_7680 1.319
R_VINT1_6483 MINT2_X_8640_Y_8000 MINT1_X_8640_Y_8000 1.319
R_VINT1_6484 MINT2_X_8640_Y_8320 MINT1_X_8640_Y_8320 1.319
R_VINT1_6485 MINT2_X_8640_Y_8640 MINT1_X_8640_Y_8640 1.319
R_VINT1_6486 MINT2_X_8640_Y_8960 MINT1_X_8640_Y_8960 1.319
R_VINT1_6487 MINT2_X_8640_Y_9280 MINT1_X_8640_Y_9280 1.319
R_VINT1_6488 MINT2_X_8640_Y_9600 MINT1_X_8640_Y_9600 1.319
R_VINT1_6489 MINT2_X_8640_Y_9920 MINT1_X_8640_Y_9920 1.319
R_VINT1_6490 MINT2_X_8960_Y_0 MINT1_X_8960_Y_0 1.319
R_VINT1_6491 MINT2_X_8960_Y_320 MINT1_X_8960_Y_320 1.319
R_VINT1_6492 MINT2_X_8960_Y_640 MINT1_X_8960_Y_640 1.319
R_VINT1_6493 MINT2_X_8960_Y_960 MINT1_X_8960_Y_960 1.319
R_VINT1_6494 MINT2_X_8960_Y_1280 MINT1_X_8960_Y_1280 1.319
R_VINT1_6495 MINT2_X_8960_Y_1600 MINT1_X_8960_Y_1600 1.319
R_VINT1_6496 MINT2_X_8960_Y_1920 MINT1_X_8960_Y_1920 1.319
R_VINT1_6497 MINT2_X_8960_Y_2240 MINT1_X_8960_Y_2240 1.319
R_VINT1_6498 MINT2_X_8960_Y_2560 MINT1_X_8960_Y_2560 1.319
R_VINT1_6499 MINT2_X_8960_Y_2880 MINT1_X_8960_Y_2880 1.319
R_VINT1_6500 MINT2_X_8960_Y_3200 MINT1_X_8960_Y_3200 1.319
R_VINT1_6501 MINT2_X_8960_Y_3520 MINT1_X_8960_Y_3520 1.319
R_VINT1_6502 MINT2_X_8960_Y_3840 MINT1_X_8960_Y_3840 1.319
R_VINT1_6503 MINT2_X_8960_Y_4160 MINT1_X_8960_Y_4160 1.319
R_VINT1_6504 MINT2_X_8960_Y_4480 MINT1_X_8960_Y_4480 1.319
R_VINT1_6505 MINT2_X_8960_Y_4800 MINT1_X_8960_Y_4800 1.319
R_VINT1_6506 MINT2_X_8960_Y_5120 MINT1_X_8960_Y_5120 1.319
R_VINT1_6507 MINT2_X_8960_Y_5440 MINT1_X_8960_Y_5440 1.319
R_VINT1_6508 MINT2_X_8960_Y_5760 MINT1_X_8960_Y_5760 1.319
R_VINT1_6509 MINT2_X_8960_Y_6080 MINT1_X_8960_Y_6080 1.319
R_VINT1_6510 MINT2_X_8960_Y_6400 MINT1_X_8960_Y_6400 1.319
R_VINT1_6511 MINT2_X_8960_Y_6720 MINT1_X_8960_Y_6720 1.319
R_VINT1_6512 MINT2_X_8960_Y_7040 MINT1_X_8960_Y_7040 1.319
R_VINT1_6513 MINT2_X_8960_Y_7360 MINT1_X_8960_Y_7360 1.319
R_VINT1_6514 MINT2_X_8960_Y_7680 MINT1_X_8960_Y_7680 1.319
R_VINT1_6515 MINT2_X_8960_Y_8000 MINT1_X_8960_Y_8000 1.319
R_VINT1_6516 MINT2_X_8960_Y_8320 MINT1_X_8960_Y_8320 1.319
R_VINT1_6517 MINT2_X_8960_Y_8640 MINT1_X_8960_Y_8640 1.319
R_VINT1_6518 MINT2_X_8960_Y_8960 MINT1_X_8960_Y_8960 1.319
R_VINT1_6519 MINT2_X_8960_Y_9280 MINT1_X_8960_Y_9280 1.319
R_VINT1_6520 MINT2_X_8960_Y_9600 MINT1_X_8960_Y_9600 1.319
R_VINT1_6521 MINT2_X_8960_Y_9920 MINT1_X_8960_Y_9920 1.319
R_VINT1_6522 MINT2_X_9280_Y_0 MINT1_X_9280_Y_0 1.319
R_VINT1_6523 MINT2_X_9280_Y_320 MINT1_X_9280_Y_320 1.319
R_VINT1_6524 MINT2_X_9280_Y_640 MINT1_X_9280_Y_640 1.319
R_VINT1_6525 MINT2_X_9280_Y_960 MINT1_X_9280_Y_960 1.319
R_VINT1_6526 MINT2_X_9280_Y_1280 MINT1_X_9280_Y_1280 1.319
R_VINT1_6527 MINT2_X_9280_Y_1600 MINT1_X_9280_Y_1600 1.319
R_VINT1_6528 MINT2_X_9280_Y_1920 MINT1_X_9280_Y_1920 1.319
R_VINT1_6529 MINT2_X_9280_Y_2240 MINT1_X_9280_Y_2240 1.319
R_VINT1_6530 MINT2_X_9280_Y_2560 MINT1_X_9280_Y_2560 1.319
R_VINT1_6531 MINT2_X_9280_Y_2880 MINT1_X_9280_Y_2880 1.319
R_VINT1_6532 MINT2_X_9280_Y_3200 MINT1_X_9280_Y_3200 1.319
R_VINT1_6533 MINT2_X_9280_Y_3520 MINT1_X_9280_Y_3520 1.319
R_VINT1_6534 MINT2_X_9280_Y_3840 MINT1_X_9280_Y_3840 1.319
R_VINT1_6535 MINT2_X_9280_Y_4160 MINT1_X_9280_Y_4160 1.319
R_VINT1_6536 MINT2_X_9280_Y_4480 MINT1_X_9280_Y_4480 1.319
R_VINT1_6537 MINT2_X_9280_Y_4800 MINT1_X_9280_Y_4800 1.319
R_VINT1_6538 MINT2_X_9280_Y_5120 MINT1_X_9280_Y_5120 1.319
R_VINT1_6539 MINT2_X_9280_Y_5440 MINT1_X_9280_Y_5440 1.319
R_VINT1_6540 MINT2_X_9280_Y_5760 MINT1_X_9280_Y_5760 1.319
R_VINT1_6541 MINT2_X_9280_Y_6080 MINT1_X_9280_Y_6080 1.319
R_VINT1_6542 MINT2_X_9280_Y_6400 MINT1_X_9280_Y_6400 1.319
R_VINT1_6543 MINT2_X_9280_Y_6720 MINT1_X_9280_Y_6720 1.319
R_VINT1_6544 MINT2_X_9280_Y_7040 MINT1_X_9280_Y_7040 1.319
R_VINT1_6545 MINT2_X_9280_Y_7360 MINT1_X_9280_Y_7360 1.319
R_VINT1_6546 MINT2_X_9280_Y_7680 MINT1_X_9280_Y_7680 1.319
R_VINT1_6547 MINT2_X_9280_Y_8000 MINT1_X_9280_Y_8000 1.319
R_VINT1_6548 MINT2_X_9280_Y_8320 MINT1_X_9280_Y_8320 1.319
R_VINT1_6549 MINT2_X_9280_Y_8640 MINT1_X_9280_Y_8640 1.319
R_VINT1_6550 MINT2_X_9280_Y_8960 MINT1_X_9280_Y_8960 1.319
R_VINT1_6551 MINT2_X_9280_Y_9280 MINT1_X_9280_Y_9280 1.319
R_VINT1_6552 MINT2_X_9280_Y_9600 MINT1_X_9280_Y_9600 1.319
R_VINT1_6553 MINT2_X_9280_Y_9920 MINT1_X_9280_Y_9920 1.319
R_VINT1_6554 MINT2_X_9600_Y_0 MINT1_X_9600_Y_0 1.319
R_VINT1_6555 MINT2_X_9600_Y_320 MINT1_X_9600_Y_320 1.319
R_VINT1_6556 MINT2_X_9600_Y_640 MINT1_X_9600_Y_640 1.319
R_VINT1_6557 MINT2_X_9600_Y_960 MINT1_X_9600_Y_960 1.319
R_VINT1_6558 MINT2_X_9600_Y_1280 MINT1_X_9600_Y_1280 1.319
R_VINT1_6559 MINT2_X_9600_Y_1600 MINT1_X_9600_Y_1600 1.319
R_VINT1_6560 MINT2_X_9600_Y_1920 MINT1_X_9600_Y_1920 1.319
R_VINT1_6561 MINT2_X_9600_Y_2240 MINT1_X_9600_Y_2240 1.319
R_VINT1_6562 MINT2_X_9600_Y_2560 MINT1_X_9600_Y_2560 1.319
R_VINT1_6563 MINT2_X_9600_Y_2880 MINT1_X_9600_Y_2880 1.319
R_VINT1_6564 MINT2_X_9600_Y_3200 MINT1_X_9600_Y_3200 1.319
R_VINT1_6565 MINT2_X_9600_Y_3520 MINT1_X_9600_Y_3520 1.319
R_VINT1_6566 MINT2_X_9600_Y_3840 MINT1_X_9600_Y_3840 1.319
R_VINT1_6567 MINT2_X_9600_Y_4160 MINT1_X_9600_Y_4160 1.319
R_VINT1_6568 MINT2_X_9600_Y_4480 MINT1_X_9600_Y_4480 1.319
R_VINT1_6569 MINT2_X_9600_Y_4800 MINT1_X_9600_Y_4800 1.319
R_VINT1_6570 MINT2_X_9600_Y_5120 MINT1_X_9600_Y_5120 1.319
R_VINT1_6571 MINT2_X_9600_Y_5440 MINT1_X_9600_Y_5440 1.319
R_VINT1_6572 MINT2_X_9600_Y_5760 MINT1_X_9600_Y_5760 1.319
R_VINT1_6573 MINT2_X_9600_Y_6080 MINT1_X_9600_Y_6080 1.319
R_VINT1_6574 MINT2_X_9600_Y_6400 MINT1_X_9600_Y_6400 1.319
R_VINT1_6575 MINT2_X_9600_Y_6720 MINT1_X_9600_Y_6720 1.319
R_VINT1_6576 MINT2_X_9600_Y_7040 MINT1_X_9600_Y_7040 1.319
R_VINT1_6577 MINT2_X_9600_Y_7360 MINT1_X_9600_Y_7360 1.319
R_VINT1_6578 MINT2_X_9600_Y_7680 MINT1_X_9600_Y_7680 1.319
R_VINT1_6579 MINT2_X_9600_Y_8000 MINT1_X_9600_Y_8000 1.319
R_VINT1_6580 MINT2_X_9600_Y_8320 MINT1_X_9600_Y_8320 1.319
R_VINT1_6581 MINT2_X_9600_Y_8640 MINT1_X_9600_Y_8640 1.319
R_VINT1_6582 MINT2_X_9600_Y_8960 MINT1_X_9600_Y_8960 1.319
R_VINT1_6583 MINT2_X_9600_Y_9280 MINT1_X_9600_Y_9280 1.319
R_VINT1_6584 MINT2_X_9600_Y_9600 MINT1_X_9600_Y_9600 1.319
R_VINT1_6585 MINT2_X_9600_Y_9920 MINT1_X_9600_Y_9920 1.319
R_VINT1_6586 MINT2_X_9920_Y_0 MINT1_X_9920_Y_0 1.319
R_VINT1_6587 MINT2_X_9920_Y_320 MINT1_X_9920_Y_320 1.319
R_VINT1_6588 MINT2_X_9920_Y_640 MINT1_X_9920_Y_640 1.319
R_VINT1_6589 MINT2_X_9920_Y_960 MINT1_X_9920_Y_960 1.319
R_VINT1_6590 MINT2_X_9920_Y_1280 MINT1_X_9920_Y_1280 1.319
R_VINT1_6591 MINT2_X_9920_Y_1600 MINT1_X_9920_Y_1600 1.319
R_VINT1_6592 MINT2_X_9920_Y_1920 MINT1_X_9920_Y_1920 1.319
R_VINT1_6593 MINT2_X_9920_Y_2240 MINT1_X_9920_Y_2240 1.319
R_VINT1_6594 MINT2_X_9920_Y_2560 MINT1_X_9920_Y_2560 1.319
R_VINT1_6595 MINT2_X_9920_Y_2880 MINT1_X_9920_Y_2880 1.319
R_VINT1_6596 MINT2_X_9920_Y_3200 MINT1_X_9920_Y_3200 1.319
R_VINT1_6597 MINT2_X_9920_Y_3520 MINT1_X_9920_Y_3520 1.319
R_VINT1_6598 MINT2_X_9920_Y_3840 MINT1_X_9920_Y_3840 1.319
R_VINT1_6599 MINT2_X_9920_Y_4160 MINT1_X_9920_Y_4160 1.319
R_VINT1_6600 MINT2_X_9920_Y_4480 MINT1_X_9920_Y_4480 1.319
R_VINT1_6601 MINT2_X_9920_Y_4800 MINT1_X_9920_Y_4800 1.319
R_VINT1_6602 MINT2_X_9920_Y_5120 MINT1_X_9920_Y_5120 1.319
R_VINT1_6603 MINT2_X_9920_Y_5440 MINT1_X_9920_Y_5440 1.319
R_VINT1_6604 MINT2_X_9920_Y_5760 MINT1_X_9920_Y_5760 1.319
R_VINT1_6605 MINT2_X_9920_Y_6080 MINT1_X_9920_Y_6080 1.319
R_VINT1_6606 MINT2_X_9920_Y_6400 MINT1_X_9920_Y_6400 1.319
R_VINT1_6607 MINT2_X_9920_Y_6720 MINT1_X_9920_Y_6720 1.319
R_VINT1_6608 MINT2_X_9920_Y_7040 MINT1_X_9920_Y_7040 1.319
R_VINT1_6609 MINT2_X_9920_Y_7360 MINT1_X_9920_Y_7360 1.319
R_VINT1_6610 MINT2_X_9920_Y_7680 MINT1_X_9920_Y_7680 1.319
R_VINT1_6611 MINT2_X_9920_Y_8000 MINT1_X_9920_Y_8000 1.319
R_VINT1_6612 MINT2_X_9920_Y_8320 MINT1_X_9920_Y_8320 1.319
R_VINT1_6613 MINT2_X_9920_Y_8640 MINT1_X_9920_Y_8640 1.319
R_VINT1_6614 MINT2_X_9920_Y_8960 MINT1_X_9920_Y_8960 1.319
R_VINT1_6615 MINT2_X_9920_Y_9280 MINT1_X_9920_Y_9280 1.319
R_VINT1_6616 MINT2_X_9920_Y_9600 MINT1_X_9920_Y_9600 1.319
R_VINT1_6617 MINT2_X_9920_Y_9920 MINT1_X_9920_Y_9920 1.319
R_V1_6618 MINT1_X_0_Y_0 M1_X_0_Y_0 1.319
R_V1_6619 MINT1_X_0_Y_1024 M1_X_0_Y_1024 1.319
R_V1_6620 MINT1_X_0_Y_2048 M1_X_0_Y_2048 1.319
R_V1_6621 MINT1_X_0_Y_3072 M1_X_0_Y_3072 1.319
R_V1_6622 MINT1_X_0_Y_4096 M1_X_0_Y_4096 1.319
R_V1_6623 MINT1_X_0_Y_5120 M1_X_0_Y_5120 1.319
R_V1_6624 MINT1_X_0_Y_6144 M1_X_0_Y_6144 1.319
R_V1_6625 MINT1_X_0_Y_7168 M1_X_0_Y_7168 1.319
R_V1_6626 MINT1_X_0_Y_8192 M1_X_0_Y_8192 1.319
R_V1_6627 MINT1_X_0_Y_9216 M1_X_0_Y_9216 1.319
R_V1_6628 MINT1_X_320_Y_512 M1_X_320_Y_512 1.319
R_V1_6629 MINT1_X_320_Y_1536 M1_X_320_Y_1536 1.319
R_V1_6630 MINT1_X_320_Y_2560 M1_X_320_Y_2560 1.319
R_V1_6631 MINT1_X_320_Y_3584 M1_X_320_Y_3584 1.319
R_V1_6632 MINT1_X_320_Y_4608 M1_X_320_Y_4608 1.319
R_V1_6633 MINT1_X_320_Y_5632 M1_X_320_Y_5632 1.319
R_V1_6634 MINT1_X_320_Y_6656 M1_X_320_Y_6656 1.319
R_V1_6635 MINT1_X_320_Y_7680 M1_X_320_Y_7680 1.319
R_V1_6636 MINT1_X_320_Y_8704 M1_X_320_Y_8704 1.319
R_V1_6637 MINT1_X_320_Y_9728 M1_X_320_Y_9728 1.319
R_V1_6638 MINT1_X_640_Y_0 M1_X_640_Y_0 1.319
R_V1_6639 MINT1_X_640_Y_1024 M1_X_640_Y_1024 1.319
R_V1_6640 MINT1_X_640_Y_2048 M1_X_640_Y_2048 1.319
R_V1_6641 MINT1_X_640_Y_3072 M1_X_640_Y_3072 1.319
R_V1_6642 MINT1_X_640_Y_4096 M1_X_640_Y_4096 1.319
R_V1_6643 MINT1_X_640_Y_5120 M1_X_640_Y_5120 1.319
R_V1_6644 MINT1_X_640_Y_6144 M1_X_640_Y_6144 1.319
R_V1_6645 MINT1_X_640_Y_7168 M1_X_640_Y_7168 1.319
R_V1_6646 MINT1_X_640_Y_8192 M1_X_640_Y_8192 1.319
R_V1_6647 MINT1_X_640_Y_9216 M1_X_640_Y_9216 1.319
R_V1_6648 MINT1_X_960_Y_512 M1_X_960_Y_512 1.319
R_V1_6649 MINT1_X_960_Y_1536 M1_X_960_Y_1536 1.319
R_V1_6650 MINT1_X_960_Y_2560 M1_X_960_Y_2560 1.319
R_V1_6651 MINT1_X_960_Y_3584 M1_X_960_Y_3584 1.319
R_V1_6652 MINT1_X_960_Y_4608 M1_X_960_Y_4608 1.319
R_V1_6653 MINT1_X_960_Y_5632 M1_X_960_Y_5632 1.319
R_V1_6654 MINT1_X_960_Y_6656 M1_X_960_Y_6656 1.319
R_V1_6655 MINT1_X_960_Y_7680 M1_X_960_Y_7680 1.319
R_V1_6656 MINT1_X_960_Y_8704 M1_X_960_Y_8704 1.319
R_V1_6657 MINT1_X_960_Y_9728 M1_X_960_Y_9728 1.319
R_V1_6658 MINT1_X_1280_Y_0 M1_X_1280_Y_0 1.319
R_V1_6659 MINT1_X_1280_Y_1024 M1_X_1280_Y_1024 1.319
R_V1_6660 MINT1_X_1280_Y_2048 M1_X_1280_Y_2048 1.319
R_V1_6661 MINT1_X_1280_Y_3072 M1_X_1280_Y_3072 1.319
R_V1_6662 MINT1_X_1280_Y_4096 M1_X_1280_Y_4096 1.319
R_V1_6663 MINT1_X_1280_Y_5120 M1_X_1280_Y_5120 1.319
R_V1_6664 MINT1_X_1280_Y_6144 M1_X_1280_Y_6144 1.319
R_V1_6665 MINT1_X_1280_Y_7168 M1_X_1280_Y_7168 1.319
R_V1_6666 MINT1_X_1280_Y_8192 M1_X_1280_Y_8192 1.319
R_V1_6667 MINT1_X_1280_Y_9216 M1_X_1280_Y_9216 1.319
R_V1_6668 MINT1_X_1600_Y_512 M1_X_1600_Y_512 1.319
R_V1_6669 MINT1_X_1600_Y_1536 M1_X_1600_Y_1536 1.319
R_V1_6670 MINT1_X_1600_Y_2560 M1_X_1600_Y_2560 1.319
R_V1_6671 MINT1_X_1600_Y_3584 M1_X_1600_Y_3584 1.319
R_V1_6672 MINT1_X_1600_Y_4608 M1_X_1600_Y_4608 1.319
R_V1_6673 MINT1_X_1600_Y_5632 M1_X_1600_Y_5632 1.319
R_V1_6674 MINT1_X_1600_Y_6656 M1_X_1600_Y_6656 1.319
R_V1_6675 MINT1_X_1600_Y_7680 M1_X_1600_Y_7680 1.319
R_V1_6676 MINT1_X_1600_Y_8704 M1_X_1600_Y_8704 1.319
R_V1_6677 MINT1_X_1600_Y_9728 M1_X_1600_Y_9728 1.319
R_V1_6678 MINT1_X_1920_Y_0 M1_X_1920_Y_0 1.319
R_V1_6679 MINT1_X_1920_Y_1024 M1_X_1920_Y_1024 1.319
R_V1_6680 MINT1_X_1920_Y_2048 M1_X_1920_Y_2048 1.319
R_V1_6681 MINT1_X_1920_Y_3072 M1_X_1920_Y_3072 1.319
R_V1_6682 MINT1_X_1920_Y_4096 M1_X_1920_Y_4096 1.319
R_V1_6683 MINT1_X_1920_Y_5120 M1_X_1920_Y_5120 1.319
R_V1_6684 MINT1_X_1920_Y_6144 M1_X_1920_Y_6144 1.319
R_V1_6685 MINT1_X_1920_Y_7168 M1_X_1920_Y_7168 1.319
R_V1_6686 MINT1_X_1920_Y_8192 M1_X_1920_Y_8192 1.319
R_V1_6687 MINT1_X_1920_Y_9216 M1_X_1920_Y_9216 1.319
R_V1_6688 MINT1_X_2240_Y_512 M1_X_2240_Y_512 1.319
R_V1_6689 MINT1_X_2240_Y_1536 M1_X_2240_Y_1536 1.319
R_V1_6690 MINT1_X_2240_Y_2560 M1_X_2240_Y_2560 1.319
R_V1_6691 MINT1_X_2240_Y_3584 M1_X_2240_Y_3584 1.319
R_V1_6692 MINT1_X_2240_Y_4608 M1_X_2240_Y_4608 1.319
R_V1_6693 MINT1_X_2240_Y_5632 M1_X_2240_Y_5632 1.319
R_V1_6694 MINT1_X_2240_Y_6656 M1_X_2240_Y_6656 1.319
R_V1_6695 MINT1_X_2240_Y_7680 M1_X_2240_Y_7680 1.319
R_V1_6696 MINT1_X_2240_Y_8704 M1_X_2240_Y_8704 1.319
R_V1_6697 MINT1_X_2240_Y_9728 M1_X_2240_Y_9728 1.319
R_V1_6698 MINT1_X_2560_Y_0 M1_X_2560_Y_0 1.319
R_V1_6699 MINT1_X_2560_Y_1024 M1_X_2560_Y_1024 1.319
R_V1_6700 MINT1_X_2560_Y_2048 M1_X_2560_Y_2048 1.319
R_V1_6701 MINT1_X_2560_Y_3072 M1_X_2560_Y_3072 1.319
R_V1_6702 MINT1_X_2560_Y_4096 M1_X_2560_Y_4096 1.319
R_V1_6703 MINT1_X_2560_Y_5120 M1_X_2560_Y_5120 1.319
R_V1_6704 MINT1_X_2560_Y_6144 M1_X_2560_Y_6144 1.319
R_V1_6705 MINT1_X_2560_Y_7168 M1_X_2560_Y_7168 1.319
R_V1_6706 MINT1_X_2560_Y_8192 M1_X_2560_Y_8192 1.319
R_V1_6707 MINT1_X_2560_Y_9216 M1_X_2560_Y_9216 1.319
R_V1_6708 MINT1_X_2880_Y_512 M1_X_2880_Y_512 1.319
R_V1_6709 MINT1_X_2880_Y_1536 M1_X_2880_Y_1536 1.319
R_V1_6710 MINT1_X_2880_Y_2560 M1_X_2880_Y_2560 1.319
R_V1_6711 MINT1_X_2880_Y_3584 M1_X_2880_Y_3584 1.319
R_V1_6712 MINT1_X_2880_Y_4608 M1_X_2880_Y_4608 1.319
R_V1_6713 MINT1_X_2880_Y_5632 M1_X_2880_Y_5632 1.319
R_V1_6714 MINT1_X_2880_Y_6656 M1_X_2880_Y_6656 1.319
R_V1_6715 MINT1_X_2880_Y_7680 M1_X_2880_Y_7680 1.319
R_V1_6716 MINT1_X_2880_Y_8704 M1_X_2880_Y_8704 1.319
R_V1_6717 MINT1_X_2880_Y_9728 M1_X_2880_Y_9728 1.319
R_V1_6718 MINT1_X_3200_Y_0 M1_X_3200_Y_0 1.319
R_V1_6719 MINT1_X_3200_Y_1024 M1_X_3200_Y_1024 1.319
R_V1_6720 MINT1_X_3200_Y_2048 M1_X_3200_Y_2048 1.319
R_V1_6721 MINT1_X_3200_Y_3072 M1_X_3200_Y_3072 1.319
R_V1_6722 MINT1_X_3200_Y_4096 M1_X_3200_Y_4096 1.319
R_V1_6723 MINT1_X_3200_Y_5120 M1_X_3200_Y_5120 1.319
R_V1_6724 MINT1_X_3200_Y_6144 M1_X_3200_Y_6144 1.319
R_V1_6725 MINT1_X_3200_Y_7168 M1_X_3200_Y_7168 1.319
R_V1_6726 MINT1_X_3200_Y_8192 M1_X_3200_Y_8192 1.319
R_V1_6727 MINT1_X_3200_Y_9216 M1_X_3200_Y_9216 1.319
R_V1_6728 MINT1_X_3520_Y_512 M1_X_3520_Y_512 1.319
R_V1_6729 MINT1_X_3520_Y_1536 M1_X_3520_Y_1536 1.319
R_V1_6730 MINT1_X_3520_Y_2560 M1_X_3520_Y_2560 1.319
R_V1_6731 MINT1_X_3520_Y_3584 M1_X_3520_Y_3584 1.319
R_V1_6732 MINT1_X_3520_Y_4608 M1_X_3520_Y_4608 1.319
R_V1_6733 MINT1_X_3520_Y_5632 M1_X_3520_Y_5632 1.319
R_V1_6734 MINT1_X_3520_Y_6656 M1_X_3520_Y_6656 1.319
R_V1_6735 MINT1_X_3520_Y_7680 M1_X_3520_Y_7680 1.319
R_V1_6736 MINT1_X_3520_Y_8704 M1_X_3520_Y_8704 1.319
R_V1_6737 MINT1_X_3520_Y_9728 M1_X_3520_Y_9728 1.319
R_V1_6738 MINT1_X_3840_Y_0 M1_X_3840_Y_0 1.319
R_V1_6739 MINT1_X_3840_Y_1024 M1_X_3840_Y_1024 1.319
R_V1_6740 MINT1_X_3840_Y_2048 M1_X_3840_Y_2048 1.319
R_V1_6741 MINT1_X_3840_Y_3072 M1_X_3840_Y_3072 1.319
R_V1_6742 MINT1_X_3840_Y_4096 M1_X_3840_Y_4096 1.319
R_V1_6743 MINT1_X_3840_Y_5120 M1_X_3840_Y_5120 1.319
R_V1_6744 MINT1_X_3840_Y_6144 M1_X_3840_Y_6144 1.319
R_V1_6745 MINT1_X_3840_Y_7168 M1_X_3840_Y_7168 1.319
R_V1_6746 MINT1_X_3840_Y_8192 M1_X_3840_Y_8192 1.319
R_V1_6747 MINT1_X_3840_Y_9216 M1_X_3840_Y_9216 1.319
R_V1_6748 MINT1_X_4160_Y_512 M1_X_4160_Y_512 1.319
R_V1_6749 MINT1_X_4160_Y_1536 M1_X_4160_Y_1536 1.319
R_V1_6750 MINT1_X_4160_Y_2560 M1_X_4160_Y_2560 1.319
R_V1_6751 MINT1_X_4160_Y_3584 M1_X_4160_Y_3584 1.319
R_V1_6752 MINT1_X_4160_Y_4608 M1_X_4160_Y_4608 1.319
R_V1_6753 MINT1_X_4160_Y_5632 M1_X_4160_Y_5632 1.319
R_V1_6754 MINT1_X_4160_Y_6656 M1_X_4160_Y_6656 1.319
R_V1_6755 MINT1_X_4160_Y_7680 M1_X_4160_Y_7680 1.319
R_V1_6756 MINT1_X_4160_Y_8704 M1_X_4160_Y_8704 1.319
R_V1_6757 MINT1_X_4160_Y_9728 M1_X_4160_Y_9728 1.319
R_V1_6758 MINT1_X_4480_Y_0 M1_X_4480_Y_0 1.319
R_V1_6759 MINT1_X_4480_Y_1024 M1_X_4480_Y_1024 1.319
R_V1_6760 MINT1_X_4480_Y_2048 M1_X_4480_Y_2048 1.319
R_V1_6761 MINT1_X_4480_Y_3072 M1_X_4480_Y_3072 1.319
R_V1_6762 MINT1_X_4480_Y_4096 M1_X_4480_Y_4096 1.319
R_V1_6763 MINT1_X_4480_Y_5120 M1_X_4480_Y_5120 1.319
R_V1_6764 MINT1_X_4480_Y_6144 M1_X_4480_Y_6144 1.319
R_V1_6765 MINT1_X_4480_Y_7168 M1_X_4480_Y_7168 1.319
R_V1_6766 MINT1_X_4480_Y_8192 M1_X_4480_Y_8192 1.319
R_V1_6767 MINT1_X_4480_Y_9216 M1_X_4480_Y_9216 1.319
R_V1_6768 MINT1_X_4800_Y_512 M1_X_4800_Y_512 1.319
R_V1_6769 MINT1_X_4800_Y_1536 M1_X_4800_Y_1536 1.319
R_V1_6770 MINT1_X_4800_Y_2560 M1_X_4800_Y_2560 1.319
R_V1_6771 MINT1_X_4800_Y_3584 M1_X_4800_Y_3584 1.319
R_V1_6772 MINT1_X_4800_Y_4608 M1_X_4800_Y_4608 1.319
R_V1_6773 MINT1_X_4800_Y_5632 M1_X_4800_Y_5632 1.319
R_V1_6774 MINT1_X_4800_Y_6656 M1_X_4800_Y_6656 1.319
R_V1_6775 MINT1_X_4800_Y_7680 M1_X_4800_Y_7680 1.319
R_V1_6776 MINT1_X_4800_Y_8704 M1_X_4800_Y_8704 1.319
R_V1_6777 MINT1_X_4800_Y_9728 M1_X_4800_Y_9728 1.319
R_V1_6778 MINT1_X_5120_Y_0 M1_X_5120_Y_0 1.319
R_V1_6779 MINT1_X_5120_Y_1024 M1_X_5120_Y_1024 1.319
R_V1_6780 MINT1_X_5120_Y_2048 M1_X_5120_Y_2048 1.319
R_V1_6781 MINT1_X_5120_Y_3072 M1_X_5120_Y_3072 1.319
R_V1_6782 MINT1_X_5120_Y_4096 M1_X_5120_Y_4096 1.319
R_V1_6783 MINT1_X_5120_Y_5120 M1_X_5120_Y_5120 1.319
R_V1_6784 MINT1_X_5120_Y_6144 M1_X_5120_Y_6144 1.319
R_V1_6785 MINT1_X_5120_Y_7168 M1_X_5120_Y_7168 1.319
R_V1_6786 MINT1_X_5120_Y_8192 M1_X_5120_Y_8192 1.319
R_V1_6787 MINT1_X_5120_Y_9216 M1_X_5120_Y_9216 1.319
R_V1_6788 MINT1_X_5440_Y_512 M1_X_5440_Y_512 1.319
R_V1_6789 MINT1_X_5440_Y_1536 M1_X_5440_Y_1536 1.319
R_V1_6790 MINT1_X_5440_Y_2560 M1_X_5440_Y_2560 1.319
R_V1_6791 MINT1_X_5440_Y_3584 M1_X_5440_Y_3584 1.319
R_V1_6792 MINT1_X_5440_Y_4608 M1_X_5440_Y_4608 1.319
R_V1_6793 MINT1_X_5440_Y_5632 M1_X_5440_Y_5632 1.319
R_V1_6794 MINT1_X_5440_Y_6656 M1_X_5440_Y_6656 1.319
R_V1_6795 MINT1_X_5440_Y_7680 M1_X_5440_Y_7680 1.319
R_V1_6796 MINT1_X_5440_Y_8704 M1_X_5440_Y_8704 1.319
R_V1_6797 MINT1_X_5440_Y_9728 M1_X_5440_Y_9728 1.319
R_V1_6798 MINT1_X_5760_Y_0 M1_X_5760_Y_0 1.319
R_V1_6799 MINT1_X_5760_Y_1024 M1_X_5760_Y_1024 1.319
R_V1_6800 MINT1_X_5760_Y_2048 M1_X_5760_Y_2048 1.319
R_V1_6801 MINT1_X_5760_Y_3072 M1_X_5760_Y_3072 1.319
R_V1_6802 MINT1_X_5760_Y_4096 M1_X_5760_Y_4096 1.319
R_V1_6803 MINT1_X_5760_Y_5120 M1_X_5760_Y_5120 1.319
R_V1_6804 MINT1_X_5760_Y_6144 M1_X_5760_Y_6144 1.319
R_V1_6805 MINT1_X_5760_Y_7168 M1_X_5760_Y_7168 1.319
R_V1_6806 MINT1_X_5760_Y_8192 M1_X_5760_Y_8192 1.319
R_V1_6807 MINT1_X_5760_Y_9216 M1_X_5760_Y_9216 1.319
R_V1_6808 MINT1_X_6080_Y_512 M1_X_6080_Y_512 1.319
R_V1_6809 MINT1_X_6080_Y_1536 M1_X_6080_Y_1536 1.319
R_V1_6810 MINT1_X_6080_Y_2560 M1_X_6080_Y_2560 1.319
R_V1_6811 MINT1_X_6080_Y_3584 M1_X_6080_Y_3584 1.319
R_V1_6812 MINT1_X_6080_Y_4608 M1_X_6080_Y_4608 1.319
R_V1_6813 MINT1_X_6080_Y_5632 M1_X_6080_Y_5632 1.319
R_V1_6814 MINT1_X_6080_Y_6656 M1_X_6080_Y_6656 1.319
R_V1_6815 MINT1_X_6080_Y_7680 M1_X_6080_Y_7680 1.319
R_V1_6816 MINT1_X_6080_Y_8704 M1_X_6080_Y_8704 1.319
R_V1_6817 MINT1_X_6080_Y_9728 M1_X_6080_Y_9728 1.319
R_V1_6818 MINT1_X_6400_Y_0 M1_X_6400_Y_0 1.319
R_V1_6819 MINT1_X_6400_Y_1024 M1_X_6400_Y_1024 1.319
R_V1_6820 MINT1_X_6400_Y_2048 M1_X_6400_Y_2048 1.319
R_V1_6821 MINT1_X_6400_Y_3072 M1_X_6400_Y_3072 1.319
R_V1_6822 MINT1_X_6400_Y_4096 M1_X_6400_Y_4096 1.319
R_V1_6823 MINT1_X_6400_Y_5120 M1_X_6400_Y_5120 1.319
R_V1_6824 MINT1_X_6400_Y_6144 M1_X_6400_Y_6144 1.319
R_V1_6825 MINT1_X_6400_Y_7168 M1_X_6400_Y_7168 1.319
R_V1_6826 MINT1_X_6400_Y_8192 M1_X_6400_Y_8192 1.319
R_V1_6827 MINT1_X_6400_Y_9216 M1_X_6400_Y_9216 1.319
R_V1_6828 MINT1_X_6720_Y_512 M1_X_6720_Y_512 1.319
R_V1_6829 MINT1_X_6720_Y_1536 M1_X_6720_Y_1536 1.319
R_V1_6830 MINT1_X_6720_Y_2560 M1_X_6720_Y_2560 1.319
R_V1_6831 MINT1_X_6720_Y_3584 M1_X_6720_Y_3584 1.319
R_V1_6832 MINT1_X_6720_Y_4608 M1_X_6720_Y_4608 1.319
R_V1_6833 MINT1_X_6720_Y_5632 M1_X_6720_Y_5632 1.319
R_V1_6834 MINT1_X_6720_Y_6656 M1_X_6720_Y_6656 1.319
R_V1_6835 MINT1_X_6720_Y_7680 M1_X_6720_Y_7680 1.319
R_V1_6836 MINT1_X_6720_Y_8704 M1_X_6720_Y_8704 1.319
R_V1_6837 MINT1_X_6720_Y_9728 M1_X_6720_Y_9728 1.319
R_V1_6838 MINT1_X_7040_Y_0 M1_X_7040_Y_0 1.319
R_V1_6839 MINT1_X_7040_Y_1024 M1_X_7040_Y_1024 1.319
R_V1_6840 MINT1_X_7040_Y_2048 M1_X_7040_Y_2048 1.319
R_V1_6841 MINT1_X_7040_Y_3072 M1_X_7040_Y_3072 1.319
R_V1_6842 MINT1_X_7040_Y_4096 M1_X_7040_Y_4096 1.319
R_V1_6843 MINT1_X_7040_Y_5120 M1_X_7040_Y_5120 1.319
R_V1_6844 MINT1_X_7040_Y_6144 M1_X_7040_Y_6144 1.319
R_V1_6845 MINT1_X_7040_Y_7168 M1_X_7040_Y_7168 1.319
R_V1_6846 MINT1_X_7040_Y_8192 M1_X_7040_Y_8192 1.319
R_V1_6847 MINT1_X_7040_Y_9216 M1_X_7040_Y_9216 1.319
R_V1_6848 MINT1_X_7360_Y_512 M1_X_7360_Y_512 1.319
R_V1_6849 MINT1_X_7360_Y_1536 M1_X_7360_Y_1536 1.319
R_V1_6850 MINT1_X_7360_Y_2560 M1_X_7360_Y_2560 1.319
R_V1_6851 MINT1_X_7360_Y_3584 M1_X_7360_Y_3584 1.319
R_V1_6852 MINT1_X_7360_Y_4608 M1_X_7360_Y_4608 1.319
R_V1_6853 MINT1_X_7360_Y_5632 M1_X_7360_Y_5632 1.319
R_V1_6854 MINT1_X_7360_Y_6656 M1_X_7360_Y_6656 1.319
R_V1_6855 MINT1_X_7360_Y_7680 M1_X_7360_Y_7680 1.319
R_V1_6856 MINT1_X_7360_Y_8704 M1_X_7360_Y_8704 1.319
R_V1_6857 MINT1_X_7360_Y_9728 M1_X_7360_Y_9728 1.319
R_V1_6858 MINT1_X_7680_Y_0 M1_X_7680_Y_0 1.319
R_V1_6859 MINT1_X_7680_Y_1024 M1_X_7680_Y_1024 1.319
R_V1_6860 MINT1_X_7680_Y_2048 M1_X_7680_Y_2048 1.319
R_V1_6861 MINT1_X_7680_Y_3072 M1_X_7680_Y_3072 1.319
R_V1_6862 MINT1_X_7680_Y_4096 M1_X_7680_Y_4096 1.319
R_V1_6863 MINT1_X_7680_Y_5120 M1_X_7680_Y_5120 1.319
R_V1_6864 MINT1_X_7680_Y_6144 M1_X_7680_Y_6144 1.319
R_V1_6865 MINT1_X_7680_Y_7168 M1_X_7680_Y_7168 1.319
R_V1_6866 MINT1_X_7680_Y_8192 M1_X_7680_Y_8192 1.319
R_V1_6867 MINT1_X_7680_Y_9216 M1_X_7680_Y_9216 1.319
R_V1_6868 MINT1_X_8000_Y_512 M1_X_8000_Y_512 1.319
R_V1_6869 MINT1_X_8000_Y_1536 M1_X_8000_Y_1536 1.319
R_V1_6870 MINT1_X_8000_Y_2560 M1_X_8000_Y_2560 1.319
R_V1_6871 MINT1_X_8000_Y_3584 M1_X_8000_Y_3584 1.319
R_V1_6872 MINT1_X_8000_Y_4608 M1_X_8000_Y_4608 1.319
R_V1_6873 MINT1_X_8000_Y_5632 M1_X_8000_Y_5632 1.319
R_V1_6874 MINT1_X_8000_Y_6656 M1_X_8000_Y_6656 1.319
R_V1_6875 MINT1_X_8000_Y_7680 M1_X_8000_Y_7680 1.319
R_V1_6876 MINT1_X_8000_Y_8704 M1_X_8000_Y_8704 1.319
R_V1_6877 MINT1_X_8000_Y_9728 M1_X_8000_Y_9728 1.319
R_V1_6878 MINT1_X_8320_Y_0 M1_X_8320_Y_0 1.319
R_V1_6879 MINT1_X_8320_Y_1024 M1_X_8320_Y_1024 1.319
R_V1_6880 MINT1_X_8320_Y_2048 M1_X_8320_Y_2048 1.319
R_V1_6881 MINT1_X_8320_Y_3072 M1_X_8320_Y_3072 1.319
R_V1_6882 MINT1_X_8320_Y_4096 M1_X_8320_Y_4096 1.319
R_V1_6883 MINT1_X_8320_Y_5120 M1_X_8320_Y_5120 1.319
R_V1_6884 MINT1_X_8320_Y_6144 M1_X_8320_Y_6144 1.319
R_V1_6885 MINT1_X_8320_Y_7168 M1_X_8320_Y_7168 1.319
R_V1_6886 MINT1_X_8320_Y_8192 M1_X_8320_Y_8192 1.319
R_V1_6887 MINT1_X_8320_Y_9216 M1_X_8320_Y_9216 1.319
R_V1_6888 MINT1_X_8640_Y_512 M1_X_8640_Y_512 1.319
R_V1_6889 MINT1_X_8640_Y_1536 M1_X_8640_Y_1536 1.319
R_V1_6890 MINT1_X_8640_Y_2560 M1_X_8640_Y_2560 1.319
R_V1_6891 MINT1_X_8640_Y_3584 M1_X_8640_Y_3584 1.319
R_V1_6892 MINT1_X_8640_Y_4608 M1_X_8640_Y_4608 1.319
R_V1_6893 MINT1_X_8640_Y_5632 M1_X_8640_Y_5632 1.319
R_V1_6894 MINT1_X_8640_Y_6656 M1_X_8640_Y_6656 1.319
R_V1_6895 MINT1_X_8640_Y_7680 M1_X_8640_Y_7680 1.319
R_V1_6896 MINT1_X_8640_Y_8704 M1_X_8640_Y_8704 1.319
R_V1_6897 MINT1_X_8640_Y_9728 M1_X_8640_Y_9728 1.319
R_V1_6898 MINT1_X_8960_Y_0 M1_X_8960_Y_0 1.319
R_V1_6899 MINT1_X_8960_Y_1024 M1_X_8960_Y_1024 1.319
R_V1_6900 MINT1_X_8960_Y_2048 M1_X_8960_Y_2048 1.319
R_V1_6901 MINT1_X_8960_Y_3072 M1_X_8960_Y_3072 1.319
R_V1_6902 MINT1_X_8960_Y_4096 M1_X_8960_Y_4096 1.319
R_V1_6903 MINT1_X_8960_Y_5120 M1_X_8960_Y_5120 1.319
R_V1_6904 MINT1_X_8960_Y_6144 M1_X_8960_Y_6144 1.319
R_V1_6905 MINT1_X_8960_Y_7168 M1_X_8960_Y_7168 1.319
R_V1_6906 MINT1_X_8960_Y_8192 M1_X_8960_Y_8192 1.319
R_V1_6907 MINT1_X_8960_Y_9216 M1_X_8960_Y_9216 1.319
R_V1_6908 MINT1_X_9280_Y_512 M1_X_9280_Y_512 1.319
R_V1_6909 MINT1_X_9280_Y_1536 M1_X_9280_Y_1536 1.319
R_V1_6910 MINT1_X_9280_Y_2560 M1_X_9280_Y_2560 1.319
R_V1_6911 MINT1_X_9280_Y_3584 M1_X_9280_Y_3584 1.319
R_V1_6912 MINT1_X_9280_Y_4608 M1_X_9280_Y_4608 1.319
R_V1_6913 MINT1_X_9280_Y_5632 M1_X_9280_Y_5632 1.319
R_V1_6914 MINT1_X_9280_Y_6656 M1_X_9280_Y_6656 1.319
R_V1_6915 MINT1_X_9280_Y_7680 M1_X_9280_Y_7680 1.319
R_V1_6916 MINT1_X_9280_Y_8704 M1_X_9280_Y_8704 1.319
R_V1_6917 MINT1_X_9280_Y_9728 M1_X_9280_Y_9728 1.319
R_V1_6918 MINT1_X_9600_Y_0 M1_X_9600_Y_0 1.319
R_V1_6919 MINT1_X_9600_Y_1024 M1_X_9600_Y_1024 1.319
R_V1_6920 MINT1_X_9600_Y_2048 M1_X_9600_Y_2048 1.319
R_V1_6921 MINT1_X_9600_Y_3072 M1_X_9600_Y_3072 1.319
R_V1_6922 MINT1_X_9600_Y_4096 M1_X_9600_Y_4096 1.319
R_V1_6923 MINT1_X_9600_Y_5120 M1_X_9600_Y_5120 1.319
R_V1_6924 MINT1_X_9600_Y_6144 M1_X_9600_Y_6144 1.319
R_V1_6925 MINT1_X_9600_Y_7168 M1_X_9600_Y_7168 1.319
R_V1_6926 MINT1_X_9600_Y_8192 M1_X_9600_Y_8192 1.319
R_V1_6927 MINT1_X_9600_Y_9216 M1_X_9600_Y_9216 1.319
R_V1_6928 MINT1_X_9920_Y_512 M1_X_9920_Y_512 1.319
R_V1_6929 MINT1_X_9920_Y_1536 M1_X_9920_Y_1536 1.319
R_V1_6930 MINT1_X_9920_Y_2560 M1_X_9920_Y_2560 1.319
R_V1_6931 MINT1_X_9920_Y_3584 M1_X_9920_Y_3584 1.319
R_V1_6932 MINT1_X_9920_Y_4608 M1_X_9920_Y_4608 1.319
R_V1_6933 MINT1_X_9920_Y_5632 M1_X_9920_Y_5632 1.319
R_V1_6934 MINT1_X_9920_Y_6656 M1_X_9920_Y_6656 1.319
R_V1_6935 MINT1_X_9920_Y_7680 M1_X_9920_Y_7680 1.319
R_V1_6936 MINT1_X_9920_Y_8704 M1_X_9920_Y_8704 1.319
R_V1_6937 MINT1_X_9920_Y_9728 M1_X_9920_Y_9728 1.319

* === Node Capacitances ===
* Aggregated C/2 contributions per node
C_M1_X_0_Y_0 M1_X_0_Y_0 0 1.8237e-17
C_M1_X_0_Y_1024 M1_X_0_Y_1024 0 1.8237e-17
C_M1_X_0_Y_1536 M1_X_0_Y_1536 0 9.1187e-18
C_M1_X_0_Y_2048 M1_X_0_Y_2048 0 1.8237e-17
C_M1_X_0_Y_2560 M1_X_0_Y_2560 0 9.1187e-18
C_M1_X_0_Y_3072 M1_X_0_Y_3072 0 1.8237e-17
C_M1_X_0_Y_3584 M1_X_0_Y_3584 0 9.1187e-18
C_M1_X_0_Y_4096 M1_X_0_Y_4096 0 1.8237e-17
C_M1_X_0_Y_4608 M1_X_0_Y_4608 0 9.1187e-18
C_M1_X_0_Y_512 M1_X_0_Y_512 0 9.1187e-18
C_M1_X_0_Y_5120 M1_X_0_Y_5120 0 1.8237e-17
C_M1_X_0_Y_5632 M1_X_0_Y_5632 0 9.1187e-18
C_M1_X_0_Y_6144 M1_X_0_Y_6144 0 1.8237e-17
C_M1_X_0_Y_6656 M1_X_0_Y_6656 0 9.1187e-18
C_M1_X_0_Y_7168 M1_X_0_Y_7168 0 1.8237e-17
C_M1_X_0_Y_7680 M1_X_0_Y_7680 0 9.1187e-18
C_M1_X_0_Y_8192 M1_X_0_Y_8192 0 1.8237e-17
C_M1_X_0_Y_8704 M1_X_0_Y_8704 0 9.1187e-18
C_M1_X_0_Y_9216 M1_X_0_Y_9216 0 1.8237e-17
C_M1_X_0_Y_9728 M1_X_0_Y_9728 0 9.1187e-18
C_M1_X_10000_Y_0 M1_X_10000_Y_0 0 1.1398e-17
C_M1_X_10000_Y_1024 M1_X_10000_Y_1024 0 1.1398e-17
C_M1_X_10000_Y_1536 M1_X_10000_Y_1536 0 2.2797e-18
C_M1_X_10000_Y_2048 M1_X_10000_Y_2048 0 1.1398e-17
C_M1_X_10000_Y_2560 M1_X_10000_Y_2560 0 2.2797e-18
C_M1_X_10000_Y_3072 M1_X_10000_Y_3072 0 1.1398e-17
C_M1_X_10000_Y_3584 M1_X_10000_Y_3584 0 2.2797e-18
C_M1_X_10000_Y_4096 M1_X_10000_Y_4096 0 1.1398e-17
C_M1_X_10000_Y_4608 M1_X_10000_Y_4608 0 2.2797e-18
C_M1_X_10000_Y_512 M1_X_10000_Y_512 0 2.2797e-18
C_M1_X_10000_Y_5120 M1_X_10000_Y_5120 0 1.1398e-17
C_M1_X_10000_Y_5632 M1_X_10000_Y_5632 0 2.2797e-18
C_M1_X_10000_Y_6144 M1_X_10000_Y_6144 0 1.1398e-17
C_M1_X_10000_Y_6656 M1_X_10000_Y_6656 0 2.2797e-18
C_M1_X_10000_Y_7168 M1_X_10000_Y_7168 0 1.1398e-17
C_M1_X_10000_Y_7680 M1_X_10000_Y_7680 0 2.2797e-18
C_M1_X_10000_Y_8192 M1_X_10000_Y_8192 0 1.1398e-17
C_M1_X_10000_Y_8704 M1_X_10000_Y_8704 0 2.2797e-18
C_M1_X_10000_Y_9216 M1_X_10000_Y_9216 0 1.1398e-17
C_M1_X_10000_Y_9728 M1_X_10000_Y_9728 0 2.2797e-18
C_M1_X_1280_Y_0 M1_X_1280_Y_0 0 3.6475e-17
C_M1_X_1280_Y_1024 M1_X_1280_Y_1024 0 3.6475e-17
C_M1_X_1280_Y_2048 M1_X_1280_Y_2048 0 3.6475e-17
C_M1_X_1280_Y_3072 M1_X_1280_Y_3072 0 3.6475e-17
C_M1_X_1280_Y_4096 M1_X_1280_Y_4096 0 3.6475e-17
C_M1_X_1280_Y_5120 M1_X_1280_Y_5120 0 3.6475e-17
C_M1_X_1280_Y_6144 M1_X_1280_Y_6144 0 3.6475e-17
C_M1_X_1280_Y_7168 M1_X_1280_Y_7168 0 3.6475e-17
C_M1_X_1280_Y_8192 M1_X_1280_Y_8192 0 3.6475e-17
C_M1_X_1280_Y_9216 M1_X_1280_Y_9216 0 3.6475e-17
C_M1_X_1600_Y_1536 M1_X_1600_Y_1536 0 3.6475e-17
C_M1_X_1600_Y_2560 M1_X_1600_Y_2560 0 3.6475e-17
C_M1_X_1600_Y_3584 M1_X_1600_Y_3584 0 3.6475e-17
C_M1_X_1600_Y_4608 M1_X_1600_Y_4608 0 3.6475e-17
C_M1_X_1600_Y_512 M1_X_1600_Y_512 0 3.6475e-17
C_M1_X_1600_Y_5632 M1_X_1600_Y_5632 0 3.6475e-17
C_M1_X_1600_Y_6656 M1_X_1600_Y_6656 0 3.6475e-17
C_M1_X_1600_Y_7680 M1_X_1600_Y_7680 0 3.6475e-17
C_M1_X_1600_Y_8704 M1_X_1600_Y_8704 0 3.6475e-17
C_M1_X_1600_Y_9728 M1_X_1600_Y_9728 0 3.6475e-17
C_M1_X_1920_Y_0 M1_X_1920_Y_0 0 3.6475e-17
C_M1_X_1920_Y_1024 M1_X_1920_Y_1024 0 3.6475e-17
C_M1_X_1920_Y_2048 M1_X_1920_Y_2048 0 3.6475e-17
C_M1_X_1920_Y_3072 M1_X_1920_Y_3072 0 3.6475e-17
C_M1_X_1920_Y_4096 M1_X_1920_Y_4096 0 3.6475e-17
C_M1_X_1920_Y_5120 M1_X_1920_Y_5120 0 3.6475e-17
C_M1_X_1920_Y_6144 M1_X_1920_Y_6144 0 3.6475e-17
C_M1_X_1920_Y_7168 M1_X_1920_Y_7168 0 3.6475e-17
C_M1_X_1920_Y_8192 M1_X_1920_Y_8192 0 3.6475e-17
C_M1_X_1920_Y_9216 M1_X_1920_Y_9216 0 3.6475e-17
C_M1_X_2240_Y_1536 M1_X_2240_Y_1536 0 3.6475e-17
C_M1_X_2240_Y_2560 M1_X_2240_Y_2560 0 3.6475e-17
C_M1_X_2240_Y_3584 M1_X_2240_Y_3584 0 3.6475e-17
C_M1_X_2240_Y_4608 M1_X_2240_Y_4608 0 3.6475e-17
C_M1_X_2240_Y_512 M1_X_2240_Y_512 0 3.6475e-17
C_M1_X_2240_Y_5632 M1_X_2240_Y_5632 0 3.6475e-17
C_M1_X_2240_Y_6656 M1_X_2240_Y_6656 0 3.6475e-17
C_M1_X_2240_Y_7680 M1_X_2240_Y_7680 0 3.6475e-17
C_M1_X_2240_Y_8704 M1_X_2240_Y_8704 0 3.6475e-17
C_M1_X_2240_Y_9728 M1_X_2240_Y_9728 0 3.6475e-17
C_M1_X_2560_Y_0 M1_X_2560_Y_0 0 3.6475e-17
C_M1_X_2560_Y_1024 M1_X_2560_Y_1024 0 3.6475e-17
C_M1_X_2560_Y_2048 M1_X_2560_Y_2048 0 3.6475e-17
C_M1_X_2560_Y_3072 M1_X_2560_Y_3072 0 3.6475e-17
C_M1_X_2560_Y_4096 M1_X_2560_Y_4096 0 3.6475e-17
C_M1_X_2560_Y_5120 M1_X_2560_Y_5120 0 3.6475e-17
C_M1_X_2560_Y_6144 M1_X_2560_Y_6144 0 3.6475e-17
C_M1_X_2560_Y_7168 M1_X_2560_Y_7168 0 3.6475e-17
C_M1_X_2560_Y_8192 M1_X_2560_Y_8192 0 3.6475e-17
C_M1_X_2560_Y_9216 M1_X_2560_Y_9216 0 3.6475e-17
C_M1_X_2880_Y_1536 M1_X_2880_Y_1536 0 3.6475e-17
C_M1_X_2880_Y_2560 M1_X_2880_Y_2560 0 3.6475e-17
C_M1_X_2880_Y_3584 M1_X_2880_Y_3584 0 3.6475e-17
C_M1_X_2880_Y_4608 M1_X_2880_Y_4608 0 3.6475e-17
C_M1_X_2880_Y_512 M1_X_2880_Y_512 0 3.6475e-17
C_M1_X_2880_Y_5632 M1_X_2880_Y_5632 0 3.6475e-17
C_M1_X_2880_Y_6656 M1_X_2880_Y_6656 0 3.6475e-17
C_M1_X_2880_Y_7680 M1_X_2880_Y_7680 0 3.6475e-17
C_M1_X_2880_Y_8704 M1_X_2880_Y_8704 0 3.6475e-17
C_M1_X_2880_Y_9728 M1_X_2880_Y_9728 0 3.6475e-17
C_M1_X_3200_Y_0 M1_X_3200_Y_0 0 3.6475e-17
C_M1_X_3200_Y_1024 M1_X_3200_Y_1024 0 3.6475e-17
C_M1_X_3200_Y_2048 M1_X_3200_Y_2048 0 3.6475e-17
C_M1_X_3200_Y_3072 M1_X_3200_Y_3072 0 3.6475e-17
C_M1_X_3200_Y_4096 M1_X_3200_Y_4096 0 3.6475e-17
C_M1_X_3200_Y_5120 M1_X_3200_Y_5120 0 3.6475e-17
C_M1_X_3200_Y_6144 M1_X_3200_Y_6144 0 3.6475e-17
C_M1_X_3200_Y_7168 M1_X_3200_Y_7168 0 3.6475e-17
C_M1_X_3200_Y_8192 M1_X_3200_Y_8192 0 3.6475e-17
C_M1_X_3200_Y_9216 M1_X_3200_Y_9216 0 3.6475e-17
C_M1_X_320_Y_1536 M1_X_320_Y_1536 0 2.7356e-17
C_M1_X_320_Y_2560 M1_X_320_Y_2560 0 2.7356e-17
C_M1_X_320_Y_3584 M1_X_320_Y_3584 0 2.7356e-17
C_M1_X_320_Y_4608 M1_X_320_Y_4608 0 2.7356e-17
C_M1_X_320_Y_512 M1_X_320_Y_512 0 2.7356e-17
C_M1_X_320_Y_5632 M1_X_320_Y_5632 0 2.7356e-17
C_M1_X_320_Y_6656 M1_X_320_Y_6656 0 2.7356e-17
C_M1_X_320_Y_7680 M1_X_320_Y_7680 0 2.7356e-17
C_M1_X_320_Y_8704 M1_X_320_Y_8704 0 2.7356e-17
C_M1_X_320_Y_9728 M1_X_320_Y_9728 0 2.7356e-17
C_M1_X_3520_Y_1536 M1_X_3520_Y_1536 0 3.6475e-17
C_M1_X_3520_Y_2560 M1_X_3520_Y_2560 0 3.6475e-17
C_M1_X_3520_Y_3584 M1_X_3520_Y_3584 0 3.6475e-17
C_M1_X_3520_Y_4608 M1_X_3520_Y_4608 0 3.6475e-17
C_M1_X_3520_Y_512 M1_X_3520_Y_512 0 3.6475e-17
C_M1_X_3520_Y_5632 M1_X_3520_Y_5632 0 3.6475e-17
C_M1_X_3520_Y_6656 M1_X_3520_Y_6656 0 3.6475e-17
C_M1_X_3520_Y_7680 M1_X_3520_Y_7680 0 3.6475e-17
C_M1_X_3520_Y_8704 M1_X_3520_Y_8704 0 3.6475e-17
C_M1_X_3520_Y_9728 M1_X_3520_Y_9728 0 3.6475e-17
C_M1_X_3840_Y_0 M1_X_3840_Y_0 0 3.6475e-17
C_M1_X_3840_Y_1024 M1_X_3840_Y_1024 0 3.6475e-17
C_M1_X_3840_Y_2048 M1_X_3840_Y_2048 0 3.6475e-17
C_M1_X_3840_Y_3072 M1_X_3840_Y_3072 0 3.6475e-17
C_M1_X_3840_Y_4096 M1_X_3840_Y_4096 0 3.6475e-17
C_M1_X_3840_Y_5120 M1_X_3840_Y_5120 0 3.6475e-17
C_M1_X_3840_Y_6144 M1_X_3840_Y_6144 0 3.6475e-17
C_M1_X_3840_Y_7168 M1_X_3840_Y_7168 0 3.6475e-17
C_M1_X_3840_Y_8192 M1_X_3840_Y_8192 0 3.6475e-17
C_M1_X_3840_Y_9216 M1_X_3840_Y_9216 0 3.6475e-17
C_M1_X_4160_Y_1536 M1_X_4160_Y_1536 0 3.6475e-17
C_M1_X_4160_Y_2560 M1_X_4160_Y_2560 0 3.6475e-17
C_M1_X_4160_Y_3584 M1_X_4160_Y_3584 0 3.6475e-17
C_M1_X_4160_Y_4608 M1_X_4160_Y_4608 0 3.6475e-17
C_M1_X_4160_Y_512 M1_X_4160_Y_512 0 3.6475e-17
C_M1_X_4160_Y_5632 M1_X_4160_Y_5632 0 3.6475e-17
C_M1_X_4160_Y_6656 M1_X_4160_Y_6656 0 3.6475e-17
C_M1_X_4160_Y_7680 M1_X_4160_Y_7680 0 3.6475e-17
C_M1_X_4160_Y_8704 M1_X_4160_Y_8704 0 3.6475e-17
C_M1_X_4160_Y_9728 M1_X_4160_Y_9728 0 3.6475e-17
C_M1_X_4480_Y_0 M1_X_4480_Y_0 0 3.6475e-17
C_M1_X_4480_Y_1024 M1_X_4480_Y_1024 0 3.6475e-17
C_M1_X_4480_Y_2048 M1_X_4480_Y_2048 0 3.6475e-17
C_M1_X_4480_Y_3072 M1_X_4480_Y_3072 0 3.6475e-17
C_M1_X_4480_Y_4096 M1_X_4480_Y_4096 0 3.6475e-17
C_M1_X_4480_Y_5120 M1_X_4480_Y_5120 0 3.6475e-17
C_M1_X_4480_Y_6144 M1_X_4480_Y_6144 0 3.6475e-17
C_M1_X_4480_Y_7168 M1_X_4480_Y_7168 0 3.6475e-17
C_M1_X_4480_Y_8192 M1_X_4480_Y_8192 0 3.6475e-17
C_M1_X_4480_Y_9216 M1_X_4480_Y_9216 0 3.6475e-17
C_M1_X_4800_Y_1536 M1_X_4800_Y_1536 0 3.6475e-17
C_M1_X_4800_Y_2560 M1_X_4800_Y_2560 0 3.6475e-17
C_M1_X_4800_Y_3584 M1_X_4800_Y_3584 0 3.6475e-17
C_M1_X_4800_Y_4608 M1_X_4800_Y_4608 0 3.6475e-17
C_M1_X_4800_Y_512 M1_X_4800_Y_512 0 3.6475e-17
C_M1_X_4800_Y_5632 M1_X_4800_Y_5632 0 3.6475e-17
C_M1_X_4800_Y_6656 M1_X_4800_Y_6656 0 3.6475e-17
C_M1_X_4800_Y_7680 M1_X_4800_Y_7680 0 3.6475e-17
C_M1_X_4800_Y_8704 M1_X_4800_Y_8704 0 3.6475e-17
C_M1_X_4800_Y_9728 M1_X_4800_Y_9728 0 3.6475e-17
C_M1_X_5120_Y_0 M1_X_5120_Y_0 0 3.6475e-17
C_M1_X_5120_Y_1024 M1_X_5120_Y_1024 0 3.6475e-17
C_M1_X_5120_Y_2048 M1_X_5120_Y_2048 0 3.6475e-17
C_M1_X_5120_Y_3072 M1_X_5120_Y_3072 0 3.6475e-17
C_M1_X_5120_Y_4096 M1_X_5120_Y_4096 0 3.6475e-17
C_M1_X_5120_Y_5120 M1_X_5120_Y_5120 0 3.6475e-17
C_M1_X_5120_Y_6144 M1_X_5120_Y_6144 0 3.6475e-17
C_M1_X_5120_Y_7168 M1_X_5120_Y_7168 0 3.6475e-17
C_M1_X_5120_Y_8192 M1_X_5120_Y_8192 0 3.6475e-17
C_M1_X_5120_Y_9216 M1_X_5120_Y_9216 0 3.6475e-17
C_M1_X_5440_Y_1536 M1_X_5440_Y_1536 0 3.6475e-17
C_M1_X_5440_Y_2560 M1_X_5440_Y_2560 0 3.6475e-17
C_M1_X_5440_Y_3584 M1_X_5440_Y_3584 0 3.6475e-17
C_M1_X_5440_Y_4608 M1_X_5440_Y_4608 0 3.6475e-17
C_M1_X_5440_Y_512 M1_X_5440_Y_512 0 3.6475e-17
C_M1_X_5440_Y_5632 M1_X_5440_Y_5632 0 3.6475e-17
C_M1_X_5440_Y_6656 M1_X_5440_Y_6656 0 3.6475e-17
C_M1_X_5440_Y_7680 M1_X_5440_Y_7680 0 3.6475e-17
C_M1_X_5440_Y_8704 M1_X_5440_Y_8704 0 3.6475e-17
C_M1_X_5440_Y_9728 M1_X_5440_Y_9728 0 3.6475e-17
C_M1_X_5760_Y_0 M1_X_5760_Y_0 0 3.6475e-17
C_M1_X_5760_Y_1024 M1_X_5760_Y_1024 0 3.6475e-17
C_M1_X_5760_Y_2048 M1_X_5760_Y_2048 0 3.6475e-17
C_M1_X_5760_Y_3072 M1_X_5760_Y_3072 0 3.6475e-17
C_M1_X_5760_Y_4096 M1_X_5760_Y_4096 0 3.6475e-17
C_M1_X_5760_Y_5120 M1_X_5760_Y_5120 0 3.6475e-17
C_M1_X_5760_Y_6144 M1_X_5760_Y_6144 0 3.6475e-17
C_M1_X_5760_Y_7168 M1_X_5760_Y_7168 0 3.6475e-17
C_M1_X_5760_Y_8192 M1_X_5760_Y_8192 0 3.6475e-17
C_M1_X_5760_Y_9216 M1_X_5760_Y_9216 0 3.6475e-17
C_M1_X_6080_Y_1536 M1_X_6080_Y_1536 0 3.6475e-17
C_M1_X_6080_Y_2560 M1_X_6080_Y_2560 0 3.6475e-17
C_M1_X_6080_Y_3584 M1_X_6080_Y_3584 0 3.6475e-17
C_M1_X_6080_Y_4608 M1_X_6080_Y_4608 0 3.6475e-17
C_M1_X_6080_Y_512 M1_X_6080_Y_512 0 3.6475e-17
C_M1_X_6080_Y_5632 M1_X_6080_Y_5632 0 3.6475e-17
C_M1_X_6080_Y_6656 M1_X_6080_Y_6656 0 3.6475e-17
C_M1_X_6080_Y_7680 M1_X_6080_Y_7680 0 3.6475e-17
C_M1_X_6080_Y_8704 M1_X_6080_Y_8704 0 3.6475e-17
C_M1_X_6080_Y_9728 M1_X_6080_Y_9728 0 3.6475e-17
C_M1_X_6400_Y_0 M1_X_6400_Y_0 0 3.6475e-17
C_M1_X_6400_Y_1024 M1_X_6400_Y_1024 0 3.6475e-17
C_M1_X_6400_Y_2048 M1_X_6400_Y_2048 0 3.6475e-17
C_M1_X_6400_Y_3072 M1_X_6400_Y_3072 0 3.6475e-17
C_M1_X_6400_Y_4096 M1_X_6400_Y_4096 0 3.6475e-17
C_M1_X_6400_Y_5120 M1_X_6400_Y_5120 0 3.6475e-17
C_M1_X_6400_Y_6144 M1_X_6400_Y_6144 0 3.6475e-17
C_M1_X_6400_Y_7168 M1_X_6400_Y_7168 0 3.6475e-17
C_M1_X_6400_Y_8192 M1_X_6400_Y_8192 0 3.6475e-17
C_M1_X_6400_Y_9216 M1_X_6400_Y_9216 0 3.6475e-17
C_M1_X_640_Y_0 M1_X_640_Y_0 0 3.6475e-17
C_M1_X_640_Y_1024 M1_X_640_Y_1024 0 3.6475e-17
C_M1_X_640_Y_2048 M1_X_640_Y_2048 0 3.6475e-17
C_M1_X_640_Y_3072 M1_X_640_Y_3072 0 3.6475e-17
C_M1_X_640_Y_4096 M1_X_640_Y_4096 0 3.6475e-17
C_M1_X_640_Y_5120 M1_X_640_Y_5120 0 3.6475e-17
C_M1_X_640_Y_6144 M1_X_640_Y_6144 0 3.6475e-17
C_M1_X_640_Y_7168 M1_X_640_Y_7168 0 3.6475e-17
C_M1_X_640_Y_8192 M1_X_640_Y_8192 0 3.6475e-17
C_M1_X_640_Y_9216 M1_X_640_Y_9216 0 3.6475e-17
C_M1_X_6720_Y_1536 M1_X_6720_Y_1536 0 3.6475e-17
C_M1_X_6720_Y_2560 M1_X_6720_Y_2560 0 3.6475e-17
C_M1_X_6720_Y_3584 M1_X_6720_Y_3584 0 3.6475e-17
C_M1_X_6720_Y_4608 M1_X_6720_Y_4608 0 3.6475e-17
C_M1_X_6720_Y_512 M1_X_6720_Y_512 0 3.6475e-17
C_M1_X_6720_Y_5632 M1_X_6720_Y_5632 0 3.6475e-17
C_M1_X_6720_Y_6656 M1_X_6720_Y_6656 0 3.6475e-17
C_M1_X_6720_Y_7680 M1_X_6720_Y_7680 0 3.6475e-17
C_M1_X_6720_Y_8704 M1_X_6720_Y_8704 0 3.6475e-17
C_M1_X_6720_Y_9728 M1_X_6720_Y_9728 0 3.6475e-17
C_M1_X_7040_Y_0 M1_X_7040_Y_0 0 3.6475e-17
C_M1_X_7040_Y_1024 M1_X_7040_Y_1024 0 3.6475e-17
C_M1_X_7040_Y_2048 M1_X_7040_Y_2048 0 3.6475e-17
C_M1_X_7040_Y_3072 M1_X_7040_Y_3072 0 3.6475e-17
C_M1_X_7040_Y_4096 M1_X_7040_Y_4096 0 3.6475e-17
C_M1_X_7040_Y_5120 M1_X_7040_Y_5120 0 3.6475e-17
C_M1_X_7040_Y_6144 M1_X_7040_Y_6144 0 3.6475e-17
C_M1_X_7040_Y_7168 M1_X_7040_Y_7168 0 3.6475e-17
C_M1_X_7040_Y_8192 M1_X_7040_Y_8192 0 3.6475e-17
C_M1_X_7040_Y_9216 M1_X_7040_Y_9216 0 3.6475e-17
C_M1_X_7360_Y_1536 M1_X_7360_Y_1536 0 3.6475e-17
C_M1_X_7360_Y_2560 M1_X_7360_Y_2560 0 3.6475e-17
C_M1_X_7360_Y_3584 M1_X_7360_Y_3584 0 3.6475e-17
C_M1_X_7360_Y_4608 M1_X_7360_Y_4608 0 3.6475e-17
C_M1_X_7360_Y_512 M1_X_7360_Y_512 0 3.6475e-17
C_M1_X_7360_Y_5632 M1_X_7360_Y_5632 0 3.6475e-17
C_M1_X_7360_Y_6656 M1_X_7360_Y_6656 0 3.6475e-17
C_M1_X_7360_Y_7680 M1_X_7360_Y_7680 0 3.6475e-17
C_M1_X_7360_Y_8704 M1_X_7360_Y_8704 0 3.6475e-17
C_M1_X_7360_Y_9728 M1_X_7360_Y_9728 0 3.6475e-17
C_M1_X_7680_Y_0 M1_X_7680_Y_0 0 3.6475e-17
C_M1_X_7680_Y_1024 M1_X_7680_Y_1024 0 3.6475e-17
C_M1_X_7680_Y_2048 M1_X_7680_Y_2048 0 3.6475e-17
C_M1_X_7680_Y_3072 M1_X_7680_Y_3072 0 3.6475e-17
C_M1_X_7680_Y_4096 M1_X_7680_Y_4096 0 3.6475e-17
C_M1_X_7680_Y_5120 M1_X_7680_Y_5120 0 3.6475e-17
C_M1_X_7680_Y_6144 M1_X_7680_Y_6144 0 3.6475e-17
C_M1_X_7680_Y_7168 M1_X_7680_Y_7168 0 3.6475e-17
C_M1_X_7680_Y_8192 M1_X_7680_Y_8192 0 3.6475e-17
C_M1_X_7680_Y_9216 M1_X_7680_Y_9216 0 3.6475e-17
C_M1_X_8000_Y_1536 M1_X_8000_Y_1536 0 3.6475e-17
C_M1_X_8000_Y_2560 M1_X_8000_Y_2560 0 3.6475e-17
C_M1_X_8000_Y_3584 M1_X_8000_Y_3584 0 3.6475e-17
C_M1_X_8000_Y_4608 M1_X_8000_Y_4608 0 3.6475e-17
C_M1_X_8000_Y_512 M1_X_8000_Y_512 0 3.6475e-17
C_M1_X_8000_Y_5632 M1_X_8000_Y_5632 0 3.6475e-17
C_M1_X_8000_Y_6656 M1_X_8000_Y_6656 0 3.6475e-17
C_M1_X_8000_Y_7680 M1_X_8000_Y_7680 0 3.6475e-17
C_M1_X_8000_Y_8704 M1_X_8000_Y_8704 0 3.6475e-17
C_M1_X_8000_Y_9728 M1_X_8000_Y_9728 0 3.6475e-17
C_M1_X_8320_Y_0 M1_X_8320_Y_0 0 3.6475e-17
C_M1_X_8320_Y_1024 M1_X_8320_Y_1024 0 3.6475e-17
C_M1_X_8320_Y_2048 M1_X_8320_Y_2048 0 3.6475e-17
C_M1_X_8320_Y_3072 M1_X_8320_Y_3072 0 3.6475e-17
C_M1_X_8320_Y_4096 M1_X_8320_Y_4096 0 3.6475e-17
C_M1_X_8320_Y_5120 M1_X_8320_Y_5120 0 3.6475e-17
C_M1_X_8320_Y_6144 M1_X_8320_Y_6144 0 3.6475e-17
C_M1_X_8320_Y_7168 M1_X_8320_Y_7168 0 3.6475e-17
C_M1_X_8320_Y_8192 M1_X_8320_Y_8192 0 3.6475e-17
C_M1_X_8320_Y_9216 M1_X_8320_Y_9216 0 3.6475e-17
C_M1_X_8640_Y_1536 M1_X_8640_Y_1536 0 3.6475e-17
C_M1_X_8640_Y_2560 M1_X_8640_Y_2560 0 3.6475e-17
C_M1_X_8640_Y_3584 M1_X_8640_Y_3584 0 3.6475e-17
C_M1_X_8640_Y_4608 M1_X_8640_Y_4608 0 3.6475e-17
C_M1_X_8640_Y_512 M1_X_8640_Y_512 0 3.6475e-17
C_M1_X_8640_Y_5632 M1_X_8640_Y_5632 0 3.6475e-17
C_M1_X_8640_Y_6656 M1_X_8640_Y_6656 0 3.6475e-17
C_M1_X_8640_Y_7680 M1_X_8640_Y_7680 0 3.6475e-17
C_M1_X_8640_Y_8704 M1_X_8640_Y_8704 0 3.6475e-17
C_M1_X_8640_Y_9728 M1_X_8640_Y_9728 0 3.6475e-17
C_M1_X_8960_Y_0 M1_X_8960_Y_0 0 3.6475e-17
C_M1_X_8960_Y_1024 M1_X_8960_Y_1024 0 3.6475e-17
C_M1_X_8960_Y_2048 M1_X_8960_Y_2048 0 3.6475e-17
C_M1_X_8960_Y_3072 M1_X_8960_Y_3072 0 3.6475e-17
C_M1_X_8960_Y_4096 M1_X_8960_Y_4096 0 3.6475e-17
C_M1_X_8960_Y_5120 M1_X_8960_Y_5120 0 3.6475e-17
C_M1_X_8960_Y_6144 M1_X_8960_Y_6144 0 3.6475e-17
C_M1_X_8960_Y_7168 M1_X_8960_Y_7168 0 3.6475e-17
C_M1_X_8960_Y_8192 M1_X_8960_Y_8192 0 3.6475e-17
C_M1_X_8960_Y_9216 M1_X_8960_Y_9216 0 3.6475e-17
C_M1_X_9280_Y_1536 M1_X_9280_Y_1536 0 3.6475e-17
C_M1_X_9280_Y_2560 M1_X_9280_Y_2560 0 3.6475e-17
C_M1_X_9280_Y_3584 M1_X_9280_Y_3584 0 3.6475e-17
C_M1_X_9280_Y_4608 M1_X_9280_Y_4608 0 3.6475e-17
C_M1_X_9280_Y_512 M1_X_9280_Y_512 0 3.6475e-17
C_M1_X_9280_Y_5632 M1_X_9280_Y_5632 0 3.6475e-17
C_M1_X_9280_Y_6656 M1_X_9280_Y_6656 0 3.6475e-17
C_M1_X_9280_Y_7680 M1_X_9280_Y_7680 0 3.6475e-17
C_M1_X_9280_Y_8704 M1_X_9280_Y_8704 0 3.6475e-17
C_M1_X_9280_Y_9728 M1_X_9280_Y_9728 0 3.6475e-17
C_M1_X_9600_Y_0 M1_X_9600_Y_0 0 2.9636e-17
C_M1_X_9600_Y_1024 M1_X_9600_Y_1024 0 2.9636e-17
C_M1_X_9600_Y_2048 M1_X_9600_Y_2048 0 2.9636e-17
C_M1_X_9600_Y_3072 M1_X_9600_Y_3072 0 2.9636e-17
C_M1_X_9600_Y_4096 M1_X_9600_Y_4096 0 2.9636e-17
C_M1_X_9600_Y_5120 M1_X_9600_Y_5120 0 2.9636e-17
C_M1_X_9600_Y_6144 M1_X_9600_Y_6144 0 2.9636e-17
C_M1_X_9600_Y_7168 M1_X_9600_Y_7168 0 2.9636e-17
C_M1_X_9600_Y_8192 M1_X_9600_Y_8192 0 2.9636e-17
C_M1_X_9600_Y_9216 M1_X_9600_Y_9216 0 2.9636e-17
C_M1_X_960_Y_1536 M1_X_960_Y_1536 0 3.6475e-17
C_M1_X_960_Y_2560 M1_X_960_Y_2560 0 3.6475e-17
C_M1_X_960_Y_3584 M1_X_960_Y_3584 0 3.6475e-17
C_M1_X_960_Y_4608 M1_X_960_Y_4608 0 3.6475e-17
C_M1_X_960_Y_512 M1_X_960_Y_512 0 3.6475e-17
C_M1_X_960_Y_5632 M1_X_960_Y_5632 0 3.6475e-17
C_M1_X_960_Y_6656 M1_X_960_Y_6656 0 3.6475e-17
C_M1_X_960_Y_7680 M1_X_960_Y_7680 0 3.6475e-17
C_M1_X_960_Y_8704 M1_X_960_Y_8704 0 3.6475e-17
C_M1_X_960_Y_9728 M1_X_960_Y_9728 0 3.6475e-17
C_M1_X_9920_Y_1536 M1_X_9920_Y_1536 0 2.0517e-17
C_M1_X_9920_Y_2560 M1_X_9920_Y_2560 0 2.0517e-17
C_M1_X_9920_Y_3584 M1_X_9920_Y_3584 0 2.0517e-17
C_M1_X_9920_Y_4608 M1_X_9920_Y_4608 0 2.0517e-17
C_M1_X_9920_Y_512 M1_X_9920_Y_512 0 2.0517e-17
C_M1_X_9920_Y_5632 M1_X_9920_Y_5632 0 2.0517e-17
C_M1_X_9920_Y_6656 M1_X_9920_Y_6656 0 2.0517e-17
C_M1_X_9920_Y_7680 M1_X_9920_Y_7680 0 2.0517e-17
C_M1_X_9920_Y_8704 M1_X_9920_Y_8704 0 2.0517e-17
C_M1_X_9920_Y_9728 M1_X_9920_Y_9728 0 2.0517e-17
C_MG1_X_0_Y_0 MG1_X_0_Y_0 0 8.4856e-18
C_MG1_X_0_Y_10000 MG1_X_0_Y_10000 0 5.1015e-18
C_MG1_X_0_Y_1075 MG1_X_0_Y_1075 0 8.8392e-18
C_MG1_X_0_Y_1120 MG1_X_0_Y_1120 0 8.4856e-18
C_MG1_X_0_Y_1612 MG1_X_0_Y_1612 0 8.8392e-18
C_MG1_X_0_Y_1680 MG1_X_0_Y_1680 0 8.4856e-18
C_MG1_X_0_Y_2150 MG1_X_0_Y_2150 0 8.8392e-18
C_MG1_X_0_Y_2240 MG1_X_0_Y_2240 0 8.4856e-18
C_MG1_X_0_Y_2688 MG1_X_0_Y_2688 0 8.8392e-18
C_MG1_X_0_Y_2800 MG1_X_0_Y_2800 0 8.4856e-18
C_MG1_X_0_Y_3225 MG1_X_0_Y_3225 0 8.8392e-18
C_MG1_X_0_Y_3360 MG1_X_0_Y_3360 0 8.4856e-18
C_MG1_X_0_Y_3763 MG1_X_0_Y_3763 0 8.8392e-18
C_MG1_X_0_Y_3920 MG1_X_0_Y_3920 0 8.4856e-18
C_MG1_X_0_Y_4300 MG1_X_0_Y_4300 0 8.8392e-18
C_MG1_X_0_Y_4480 MG1_X_0_Y_4480 0 8.4856e-18
C_MG1_X_0_Y_4838 MG1_X_0_Y_4838 0 8.8392e-18
C_MG1_X_0_Y_5040 MG1_X_0_Y_5040 0 8.4856e-18
C_MG1_X_0_Y_537 MG1_X_0_Y_537 0 8.8392e-18
C_MG1_X_0_Y_5376 MG1_X_0_Y_5376 0 8.8392e-18
C_MG1_X_0_Y_560 MG1_X_0_Y_560 0 8.4856e-18
C_MG1_X_0_Y_5600 MG1_X_0_Y_5600 0 8.4856e-18
C_MG1_X_0_Y_5913 MG1_X_0_Y_5913 0 8.8392e-18
C_MG1_X_0_Y_6160 MG1_X_0_Y_6160 0 8.4856e-18
C_MG1_X_0_Y_6451 MG1_X_0_Y_6451 0 8.8392e-18
C_MG1_X_0_Y_6720 MG1_X_0_Y_6720 0 8.4856e-18
C_MG1_X_0_Y_6988 MG1_X_0_Y_6988 0 8.8392e-18
C_MG1_X_0_Y_7280 MG1_X_0_Y_7280 0 8.4856e-18
C_MG1_X_0_Y_7526 MG1_X_0_Y_7526 0 8.8392e-18
C_MG1_X_0_Y_7840 MG1_X_0_Y_7840 0 8.4856e-18
C_MG1_X_0_Y_8064 MG1_X_0_Y_8064 0 8.8392e-18
C_MG1_X_0_Y_8400 MG1_X_0_Y_8400 0 8.4856e-18
C_MG1_X_0_Y_8601 MG1_X_0_Y_8601 0 8.8392e-18
C_MG1_X_0_Y_8960 MG1_X_0_Y_8960 0 8.4856e-18
C_MG1_X_0_Y_9139 MG1_X_0_Y_9139 0 8.8392e-18
C_MG1_X_0_Y_9520 MG1_X_0_Y_9520 0 8.4856e-18
C_MG1_X_0_Y_9676 MG1_X_0_Y_9676 0 7.5764e-18
C_MG1_X_1075_Y_0 MG1_X_1075_Y_0 0 8.4856e-18
C_MG1_X_1075_Y_10000 MG1_X_1075_Y_10000 0 5.1015e-18
C_MG1_X_1075_Y_1075 MG1_X_1075_Y_1075 0 8.8392e-18
C_MG1_X_1075_Y_1120 MG1_X_1075_Y_1120 0 8.4856e-18
C_MG1_X_1075_Y_1612 MG1_X_1075_Y_1612 0 8.8392e-18
C_MG1_X_1075_Y_1680 MG1_X_1075_Y_1680 0 8.4856e-18
C_MG1_X_1075_Y_2150 MG1_X_1075_Y_2150 0 8.8392e-18
C_MG1_X_1075_Y_2240 MG1_X_1075_Y_2240 0 8.4856e-18
C_MG1_X_1075_Y_2688 MG1_X_1075_Y_2688 0 8.8392e-18
C_MG1_X_1075_Y_2800 MG1_X_1075_Y_2800 0 8.4856e-18
C_MG1_X_1075_Y_3225 MG1_X_1075_Y_3225 0 8.8392e-18
C_MG1_X_1075_Y_3360 MG1_X_1075_Y_3360 0 8.4856e-18
C_MG1_X_1075_Y_3763 MG1_X_1075_Y_3763 0 8.8392e-18
C_MG1_X_1075_Y_3920 MG1_X_1075_Y_3920 0 8.4856e-18
C_MG1_X_1075_Y_4300 MG1_X_1075_Y_4300 0 8.8392e-18
C_MG1_X_1075_Y_4480 MG1_X_1075_Y_4480 0 8.4856e-18
C_MG1_X_1075_Y_4838 MG1_X_1075_Y_4838 0 8.8392e-18
C_MG1_X_1075_Y_5040 MG1_X_1075_Y_5040 0 8.4856e-18
C_MG1_X_1075_Y_537 MG1_X_1075_Y_537 0 8.8392e-18
C_MG1_X_1075_Y_5376 MG1_X_1075_Y_5376 0 8.8392e-18
C_MG1_X_1075_Y_560 MG1_X_1075_Y_560 0 8.4856e-18
C_MG1_X_1075_Y_5600 MG1_X_1075_Y_5600 0 8.4856e-18
C_MG1_X_1075_Y_5913 MG1_X_1075_Y_5913 0 8.8392e-18
C_MG1_X_1075_Y_6160 MG1_X_1075_Y_6160 0 8.4856e-18
C_MG1_X_1075_Y_6451 MG1_X_1075_Y_6451 0 8.8392e-18
C_MG1_X_1075_Y_6720 MG1_X_1075_Y_6720 0 8.4856e-18
C_MG1_X_1075_Y_6988 MG1_X_1075_Y_6988 0 8.8392e-18
C_MG1_X_1075_Y_7280 MG1_X_1075_Y_7280 0 8.4856e-18
C_MG1_X_1075_Y_7526 MG1_X_1075_Y_7526 0 8.8392e-18
C_MG1_X_1075_Y_7840 MG1_X_1075_Y_7840 0 8.4856e-18
C_MG1_X_1075_Y_8064 MG1_X_1075_Y_8064 0 8.8392e-18
C_MG1_X_1075_Y_8400 MG1_X_1075_Y_8400 0 8.4856e-18
C_MG1_X_1075_Y_8601 MG1_X_1075_Y_8601 0 8.8392e-18
C_MG1_X_1075_Y_8960 MG1_X_1075_Y_8960 0 8.4856e-18
C_MG1_X_1075_Y_9139 MG1_X_1075_Y_9139 0 8.8392e-18
C_MG1_X_1075_Y_9520 MG1_X_1075_Y_9520 0 8.4856e-18
C_MG1_X_1075_Y_9676 MG1_X_1075_Y_9676 0 7.5764e-18
C_MG1_X_1344_Y_0 MG1_X_1344_Y_0 0 4.2428e-18
C_MG1_X_1344_Y_10000 MG1_X_1344_Y_10000 0 8.5866e-19
C_MG1_X_1344_Y_1120 MG1_X_1344_Y_1120 0 8.4856e-18
C_MG1_X_1344_Y_1344 MG1_X_1344_Y_1344 0 8.8392e-18
C_MG1_X_1344_Y_1680 MG1_X_1344_Y_1680 0 8.4856e-18
C_MG1_X_1344_Y_1881 MG1_X_1344_Y_1881 0 8.8392e-18
C_MG1_X_1344_Y_2240 MG1_X_1344_Y_2240 0 8.4856e-18
C_MG1_X_1344_Y_2419 MG1_X_1344_Y_2419 0 8.8392e-18
C_MG1_X_1344_Y_268 MG1_X_1344_Y_268 0 8.8392e-18
C_MG1_X_1344_Y_2800 MG1_X_1344_Y_2800 0 8.4856e-18
C_MG1_X_1344_Y_2956 MG1_X_1344_Y_2956 0 8.8392e-18
C_MG1_X_1344_Y_3360 MG1_X_1344_Y_3360 0 8.4856e-18
C_MG1_X_1344_Y_3494 MG1_X_1344_Y_3494 0 8.8392e-18
C_MG1_X_1344_Y_3920 MG1_X_1344_Y_3920 0 8.4856e-18
C_MG1_X_1344_Y_4032 MG1_X_1344_Y_4032 0 8.8392e-18
C_MG1_X_1344_Y_4480 MG1_X_1344_Y_4480 0 8.4856e-18
C_MG1_X_1344_Y_4569 MG1_X_1344_Y_4569 0 8.8392e-18
C_MG1_X_1344_Y_5040 MG1_X_1344_Y_5040 0 8.4856e-18
C_MG1_X_1344_Y_5107 MG1_X_1344_Y_5107 0 8.8392e-18
C_MG1_X_1344_Y_560 MG1_X_1344_Y_560 0 8.4856e-18
C_MG1_X_1344_Y_5600 MG1_X_1344_Y_5600 0 8.4856e-18
C_MG1_X_1344_Y_5644 MG1_X_1344_Y_5644 0 8.8392e-18
C_MG1_X_1344_Y_6160 MG1_X_1344_Y_6160 0 8.4856e-18
C_MG1_X_1344_Y_6182 MG1_X_1344_Y_6182 0 8.8392e-18
C_MG1_X_1344_Y_6720 MG1_X_1344_Y_6720 0 1.6971e-17
C_MG1_X_1344_Y_7257 MG1_X_1344_Y_7257 0 8.8392e-18
C_MG1_X_1344_Y_7280 MG1_X_1344_Y_7280 0 8.4856e-18
C_MG1_X_1344_Y_7795 MG1_X_1344_Y_7795 0 8.8392e-18
C_MG1_X_1344_Y_7840 MG1_X_1344_Y_7840 0 8.4856e-18
C_MG1_X_1344_Y_806 MG1_X_1344_Y_806 0 8.8392e-18
C_MG1_X_1344_Y_8332 MG1_X_1344_Y_8332 0 8.8392e-18
C_MG1_X_1344_Y_8400 MG1_X_1344_Y_8400 0 8.4856e-18
C_MG1_X_1344_Y_8870 MG1_X_1344_Y_8870 0 8.8392e-18
C_MG1_X_1344_Y_8960 MG1_X_1344_Y_8960 0 8.4856e-18
C_MG1_X_1344_Y_9408 MG1_X_1344_Y_9408 0 8.8392e-18
C_MG1_X_1344_Y_9520 MG1_X_1344_Y_9520 0 8.4856e-18
C_MG1_X_1344_Y_9945 MG1_X_1344_Y_9945 0 7.5764e-18
C_MG1_X_1612_Y_0 MG1_X_1612_Y_0 0 8.4856e-18
C_MG1_X_1612_Y_10000 MG1_X_1612_Y_10000 0 5.1015e-18
C_MG1_X_1612_Y_1075 MG1_X_1612_Y_1075 0 8.8392e-18
C_MG1_X_1612_Y_1120 MG1_X_1612_Y_1120 0 8.4856e-18
C_MG1_X_1612_Y_1612 MG1_X_1612_Y_1612 0 8.8392e-18
C_MG1_X_1612_Y_1680 MG1_X_1612_Y_1680 0 8.4856e-18
C_MG1_X_1612_Y_2150 MG1_X_1612_Y_2150 0 8.8392e-18
C_MG1_X_1612_Y_2240 MG1_X_1612_Y_2240 0 8.4856e-18
C_MG1_X_1612_Y_2688 MG1_X_1612_Y_2688 0 8.8392e-18
C_MG1_X_1612_Y_2800 MG1_X_1612_Y_2800 0 8.4856e-18
C_MG1_X_1612_Y_3225 MG1_X_1612_Y_3225 0 8.8392e-18
C_MG1_X_1612_Y_3360 MG1_X_1612_Y_3360 0 8.4856e-18
C_MG1_X_1612_Y_3763 MG1_X_1612_Y_3763 0 8.8392e-18
C_MG1_X_1612_Y_3920 MG1_X_1612_Y_3920 0 8.4856e-18
C_MG1_X_1612_Y_4300 MG1_X_1612_Y_4300 0 8.8392e-18
C_MG1_X_1612_Y_4480 MG1_X_1612_Y_4480 0 8.4856e-18
C_MG1_X_1612_Y_4838 MG1_X_1612_Y_4838 0 8.8392e-18
C_MG1_X_1612_Y_5040 MG1_X_1612_Y_5040 0 8.4856e-18
C_MG1_X_1612_Y_537 MG1_X_1612_Y_537 0 8.8392e-18
C_MG1_X_1612_Y_5376 MG1_X_1612_Y_5376 0 8.8392e-18
C_MG1_X_1612_Y_560 MG1_X_1612_Y_560 0 8.4856e-18
C_MG1_X_1612_Y_5600 MG1_X_1612_Y_5600 0 8.4856e-18
C_MG1_X_1612_Y_5913 MG1_X_1612_Y_5913 0 8.8392e-18
C_MG1_X_1612_Y_6160 MG1_X_1612_Y_6160 0 8.4856e-18
C_MG1_X_1612_Y_6451 MG1_X_1612_Y_6451 0 8.8392e-18
C_MG1_X_1612_Y_6720 MG1_X_1612_Y_6720 0 8.4856e-18
C_MG1_X_1612_Y_6988 MG1_X_1612_Y_6988 0 8.8392e-18
C_MG1_X_1612_Y_7280 MG1_X_1612_Y_7280 0 8.4856e-18
C_MG1_X_1612_Y_7526 MG1_X_1612_Y_7526 0 8.8392e-18
C_MG1_X_1612_Y_7840 MG1_X_1612_Y_7840 0 8.4856e-18
C_MG1_X_1612_Y_8064 MG1_X_1612_Y_8064 0 8.8392e-18
C_MG1_X_1612_Y_8400 MG1_X_1612_Y_8400 0 8.4856e-18
C_MG1_X_1612_Y_8601 MG1_X_1612_Y_8601 0 8.8392e-18
C_MG1_X_1612_Y_8960 MG1_X_1612_Y_8960 0 8.4856e-18
C_MG1_X_1612_Y_9139 MG1_X_1612_Y_9139 0 8.8392e-18
C_MG1_X_1612_Y_9520 MG1_X_1612_Y_9520 0 8.4856e-18
C_MG1_X_1612_Y_9676 MG1_X_1612_Y_9676 0 7.5764e-18
C_MG1_X_1881_Y_0 MG1_X_1881_Y_0 0 4.2428e-18
C_MG1_X_1881_Y_10000 MG1_X_1881_Y_10000 0 8.5866e-19
C_MG1_X_1881_Y_1120 MG1_X_1881_Y_1120 0 8.4856e-18
C_MG1_X_1881_Y_1344 MG1_X_1881_Y_1344 0 8.8392e-18
C_MG1_X_1881_Y_1680 MG1_X_1881_Y_1680 0 8.4856e-18
C_MG1_X_1881_Y_1881 MG1_X_1881_Y_1881 0 8.8392e-18
C_MG1_X_1881_Y_2240 MG1_X_1881_Y_2240 0 8.4856e-18
C_MG1_X_1881_Y_2419 MG1_X_1881_Y_2419 0 8.8392e-18
C_MG1_X_1881_Y_268 MG1_X_1881_Y_268 0 8.8392e-18
C_MG1_X_1881_Y_2800 MG1_X_1881_Y_2800 0 8.4856e-18
C_MG1_X_1881_Y_2956 MG1_X_1881_Y_2956 0 8.8392e-18
C_MG1_X_1881_Y_3360 MG1_X_1881_Y_3360 0 8.4856e-18
C_MG1_X_1881_Y_3494 MG1_X_1881_Y_3494 0 8.8392e-18
C_MG1_X_1881_Y_3920 MG1_X_1881_Y_3920 0 8.4856e-18
C_MG1_X_1881_Y_4032 MG1_X_1881_Y_4032 0 8.8392e-18
C_MG1_X_1881_Y_4480 MG1_X_1881_Y_4480 0 8.4856e-18
C_MG1_X_1881_Y_4569 MG1_X_1881_Y_4569 0 8.8392e-18
C_MG1_X_1881_Y_5040 MG1_X_1881_Y_5040 0 8.4856e-18
C_MG1_X_1881_Y_5107 MG1_X_1881_Y_5107 0 8.8392e-18
C_MG1_X_1881_Y_560 MG1_X_1881_Y_560 0 8.4856e-18
C_MG1_X_1881_Y_5600 MG1_X_1881_Y_5600 0 8.4856e-18
C_MG1_X_1881_Y_5644 MG1_X_1881_Y_5644 0 8.8392e-18
C_MG1_X_1881_Y_6160 MG1_X_1881_Y_6160 0 8.4856e-18
C_MG1_X_1881_Y_6182 MG1_X_1881_Y_6182 0 8.8392e-18
C_MG1_X_1881_Y_6720 MG1_X_1881_Y_6720 0 1.6971e-17
C_MG1_X_1881_Y_7257 MG1_X_1881_Y_7257 0 8.8392e-18
C_MG1_X_1881_Y_7280 MG1_X_1881_Y_7280 0 8.4856e-18
C_MG1_X_1881_Y_7795 MG1_X_1881_Y_7795 0 8.8392e-18
C_MG1_X_1881_Y_7840 MG1_X_1881_Y_7840 0 8.4856e-18
C_MG1_X_1881_Y_806 MG1_X_1881_Y_806 0 8.8392e-18
C_MG1_X_1881_Y_8332 MG1_X_1881_Y_8332 0 8.8392e-18
C_MG1_X_1881_Y_8400 MG1_X_1881_Y_8400 0 8.4856e-18
C_MG1_X_1881_Y_8870 MG1_X_1881_Y_8870 0 8.8392e-18
C_MG1_X_1881_Y_8960 MG1_X_1881_Y_8960 0 8.4856e-18
C_MG1_X_1881_Y_9408 MG1_X_1881_Y_9408 0 8.8392e-18
C_MG1_X_1881_Y_9520 MG1_X_1881_Y_9520 0 8.4856e-18
C_MG1_X_1881_Y_9945 MG1_X_1881_Y_9945 0 7.5764e-18
C_MG1_X_2150_Y_0 MG1_X_2150_Y_0 0 8.4856e-18
C_MG1_X_2150_Y_10000 MG1_X_2150_Y_10000 0 5.1015e-18
C_MG1_X_2150_Y_1075 MG1_X_2150_Y_1075 0 8.8392e-18
C_MG1_X_2150_Y_1120 MG1_X_2150_Y_1120 0 8.4856e-18
C_MG1_X_2150_Y_1612 MG1_X_2150_Y_1612 0 8.8392e-18
C_MG1_X_2150_Y_1680 MG1_X_2150_Y_1680 0 8.4856e-18
C_MG1_X_2150_Y_2150 MG1_X_2150_Y_2150 0 8.8392e-18
C_MG1_X_2150_Y_2240 MG1_X_2150_Y_2240 0 8.4856e-18
C_MG1_X_2150_Y_2688 MG1_X_2150_Y_2688 0 8.8392e-18
C_MG1_X_2150_Y_2800 MG1_X_2150_Y_2800 0 8.4856e-18
C_MG1_X_2150_Y_3225 MG1_X_2150_Y_3225 0 8.8392e-18
C_MG1_X_2150_Y_3360 MG1_X_2150_Y_3360 0 8.4856e-18
C_MG1_X_2150_Y_3763 MG1_X_2150_Y_3763 0 8.8392e-18
C_MG1_X_2150_Y_3920 MG1_X_2150_Y_3920 0 8.4856e-18
C_MG1_X_2150_Y_4300 MG1_X_2150_Y_4300 0 8.8392e-18
C_MG1_X_2150_Y_4480 MG1_X_2150_Y_4480 0 8.4856e-18
C_MG1_X_2150_Y_4838 MG1_X_2150_Y_4838 0 8.8392e-18
C_MG1_X_2150_Y_5040 MG1_X_2150_Y_5040 0 8.4856e-18
C_MG1_X_2150_Y_537 MG1_X_2150_Y_537 0 8.8392e-18
C_MG1_X_2150_Y_5376 MG1_X_2150_Y_5376 0 8.8392e-18
C_MG1_X_2150_Y_560 MG1_X_2150_Y_560 0 8.4856e-18
C_MG1_X_2150_Y_5600 MG1_X_2150_Y_5600 0 8.4856e-18
C_MG1_X_2150_Y_5913 MG1_X_2150_Y_5913 0 8.8392e-18
C_MG1_X_2150_Y_6160 MG1_X_2150_Y_6160 0 8.4856e-18
C_MG1_X_2150_Y_6451 MG1_X_2150_Y_6451 0 8.8392e-18
C_MG1_X_2150_Y_6720 MG1_X_2150_Y_6720 0 8.4856e-18
C_MG1_X_2150_Y_6988 MG1_X_2150_Y_6988 0 8.8392e-18
C_MG1_X_2150_Y_7280 MG1_X_2150_Y_7280 0 8.4856e-18
C_MG1_X_2150_Y_7526 MG1_X_2150_Y_7526 0 8.8392e-18
C_MG1_X_2150_Y_7840 MG1_X_2150_Y_7840 0 8.4856e-18
C_MG1_X_2150_Y_8064 MG1_X_2150_Y_8064 0 8.8392e-18
C_MG1_X_2150_Y_8400 MG1_X_2150_Y_8400 0 8.4856e-18
C_MG1_X_2150_Y_8601 MG1_X_2150_Y_8601 0 8.8392e-18
C_MG1_X_2150_Y_8960 MG1_X_2150_Y_8960 0 8.4856e-18
C_MG1_X_2150_Y_9139 MG1_X_2150_Y_9139 0 8.8392e-18
C_MG1_X_2150_Y_9520 MG1_X_2150_Y_9520 0 8.4856e-18
C_MG1_X_2150_Y_9676 MG1_X_2150_Y_9676 0 7.5764e-18
C_MG1_X_2419_Y_0 MG1_X_2419_Y_0 0 4.2428e-18
C_MG1_X_2419_Y_10000 MG1_X_2419_Y_10000 0 8.5866e-19
C_MG1_X_2419_Y_1120 MG1_X_2419_Y_1120 0 8.4856e-18
C_MG1_X_2419_Y_1344 MG1_X_2419_Y_1344 0 8.8392e-18
C_MG1_X_2419_Y_1680 MG1_X_2419_Y_1680 0 8.4856e-18
C_MG1_X_2419_Y_1881 MG1_X_2419_Y_1881 0 8.8392e-18
C_MG1_X_2419_Y_2240 MG1_X_2419_Y_2240 0 8.4856e-18
C_MG1_X_2419_Y_2419 MG1_X_2419_Y_2419 0 8.8392e-18
C_MG1_X_2419_Y_268 MG1_X_2419_Y_268 0 8.8392e-18
C_MG1_X_2419_Y_2800 MG1_X_2419_Y_2800 0 8.4856e-18
C_MG1_X_2419_Y_2956 MG1_X_2419_Y_2956 0 8.8392e-18
C_MG1_X_2419_Y_3360 MG1_X_2419_Y_3360 0 8.4856e-18
C_MG1_X_2419_Y_3494 MG1_X_2419_Y_3494 0 8.8392e-18
C_MG1_X_2419_Y_3920 MG1_X_2419_Y_3920 0 8.4856e-18
C_MG1_X_2419_Y_4032 MG1_X_2419_Y_4032 0 8.8392e-18
C_MG1_X_2419_Y_4480 MG1_X_2419_Y_4480 0 8.4856e-18
C_MG1_X_2419_Y_4569 MG1_X_2419_Y_4569 0 8.8392e-18
C_MG1_X_2419_Y_5040 MG1_X_2419_Y_5040 0 8.4856e-18
C_MG1_X_2419_Y_5107 MG1_X_2419_Y_5107 0 8.8392e-18
C_MG1_X_2419_Y_560 MG1_X_2419_Y_560 0 8.4856e-18
C_MG1_X_2419_Y_5600 MG1_X_2419_Y_5600 0 8.4856e-18
C_MG1_X_2419_Y_5644 MG1_X_2419_Y_5644 0 8.8392e-18
C_MG1_X_2419_Y_6160 MG1_X_2419_Y_6160 0 8.4856e-18
C_MG1_X_2419_Y_6182 MG1_X_2419_Y_6182 0 8.8392e-18
C_MG1_X_2419_Y_6720 MG1_X_2419_Y_6720 0 1.6971e-17
C_MG1_X_2419_Y_7257 MG1_X_2419_Y_7257 0 8.8392e-18
C_MG1_X_2419_Y_7280 MG1_X_2419_Y_7280 0 8.4856e-18
C_MG1_X_2419_Y_7795 MG1_X_2419_Y_7795 0 8.8392e-18
C_MG1_X_2419_Y_7840 MG1_X_2419_Y_7840 0 8.4856e-18
C_MG1_X_2419_Y_806 MG1_X_2419_Y_806 0 8.8392e-18
C_MG1_X_2419_Y_8332 MG1_X_2419_Y_8332 0 8.8392e-18
C_MG1_X_2419_Y_8400 MG1_X_2419_Y_8400 0 8.4856e-18
C_MG1_X_2419_Y_8870 MG1_X_2419_Y_8870 0 8.8392e-18
C_MG1_X_2419_Y_8960 MG1_X_2419_Y_8960 0 8.4856e-18
C_MG1_X_2419_Y_9408 MG1_X_2419_Y_9408 0 8.8392e-18
C_MG1_X_2419_Y_9520 MG1_X_2419_Y_9520 0 8.4856e-18
C_MG1_X_2419_Y_9945 MG1_X_2419_Y_9945 0 7.5764e-18
C_MG1_X_2688_Y_0 MG1_X_2688_Y_0 0 8.4856e-18
C_MG1_X_2688_Y_10000 MG1_X_2688_Y_10000 0 5.1015e-18
C_MG1_X_2688_Y_1075 MG1_X_2688_Y_1075 0 8.8392e-18
C_MG1_X_2688_Y_1120 MG1_X_2688_Y_1120 0 8.4856e-18
C_MG1_X_2688_Y_1612 MG1_X_2688_Y_1612 0 8.8392e-18
C_MG1_X_2688_Y_1680 MG1_X_2688_Y_1680 0 8.4856e-18
C_MG1_X_2688_Y_2150 MG1_X_2688_Y_2150 0 8.8392e-18
C_MG1_X_2688_Y_2240 MG1_X_2688_Y_2240 0 8.4856e-18
C_MG1_X_2688_Y_2688 MG1_X_2688_Y_2688 0 8.8392e-18
C_MG1_X_2688_Y_2800 MG1_X_2688_Y_2800 0 8.4856e-18
C_MG1_X_2688_Y_3225 MG1_X_2688_Y_3225 0 8.8392e-18
C_MG1_X_2688_Y_3360 MG1_X_2688_Y_3360 0 8.4856e-18
C_MG1_X_2688_Y_3763 MG1_X_2688_Y_3763 0 8.8392e-18
C_MG1_X_2688_Y_3920 MG1_X_2688_Y_3920 0 8.4856e-18
C_MG1_X_2688_Y_4300 MG1_X_2688_Y_4300 0 8.8392e-18
C_MG1_X_2688_Y_4480 MG1_X_2688_Y_4480 0 8.4856e-18
C_MG1_X_2688_Y_4838 MG1_X_2688_Y_4838 0 8.8392e-18
C_MG1_X_2688_Y_5040 MG1_X_2688_Y_5040 0 8.4856e-18
C_MG1_X_2688_Y_537 MG1_X_2688_Y_537 0 8.8392e-18
C_MG1_X_2688_Y_5376 MG1_X_2688_Y_5376 0 8.8392e-18
C_MG1_X_2688_Y_560 MG1_X_2688_Y_560 0 8.4856e-18
C_MG1_X_2688_Y_5600 MG1_X_2688_Y_5600 0 8.4856e-18
C_MG1_X_2688_Y_5913 MG1_X_2688_Y_5913 0 8.8392e-18
C_MG1_X_2688_Y_6160 MG1_X_2688_Y_6160 0 8.4856e-18
C_MG1_X_2688_Y_6451 MG1_X_2688_Y_6451 0 8.8392e-18
C_MG1_X_2688_Y_6720 MG1_X_2688_Y_6720 0 8.4856e-18
C_MG1_X_2688_Y_6988 MG1_X_2688_Y_6988 0 8.8392e-18
C_MG1_X_2688_Y_7280 MG1_X_2688_Y_7280 0 8.4856e-18
C_MG1_X_2688_Y_7526 MG1_X_2688_Y_7526 0 8.8392e-18
C_MG1_X_2688_Y_7840 MG1_X_2688_Y_7840 0 8.4856e-18
C_MG1_X_2688_Y_8064 MG1_X_2688_Y_8064 0 8.8392e-18
C_MG1_X_2688_Y_8400 MG1_X_2688_Y_8400 0 8.4856e-18
C_MG1_X_2688_Y_8601 MG1_X_2688_Y_8601 0 8.8392e-18
C_MG1_X_2688_Y_8960 MG1_X_2688_Y_8960 0 8.4856e-18
C_MG1_X_2688_Y_9139 MG1_X_2688_Y_9139 0 8.8392e-18
C_MG1_X_2688_Y_9520 MG1_X_2688_Y_9520 0 8.4856e-18
C_MG1_X_2688_Y_9676 MG1_X_2688_Y_9676 0 7.5764e-18
C_MG1_X_268_Y_0 MG1_X_268_Y_0 0 4.2428e-18
C_MG1_X_268_Y_10000 MG1_X_268_Y_10000 0 8.5866e-19
C_MG1_X_268_Y_1120 MG1_X_268_Y_1120 0 8.4856e-18
C_MG1_X_268_Y_1344 MG1_X_268_Y_1344 0 8.8392e-18
C_MG1_X_268_Y_1680 MG1_X_268_Y_1680 0 8.4856e-18
C_MG1_X_268_Y_1881 MG1_X_268_Y_1881 0 8.8392e-18
C_MG1_X_268_Y_2240 MG1_X_268_Y_2240 0 8.4856e-18
C_MG1_X_268_Y_2419 MG1_X_268_Y_2419 0 8.8392e-18
C_MG1_X_268_Y_268 MG1_X_268_Y_268 0 8.8392e-18
C_MG1_X_268_Y_2800 MG1_X_268_Y_2800 0 8.4856e-18
C_MG1_X_268_Y_2956 MG1_X_268_Y_2956 0 8.8392e-18
C_MG1_X_268_Y_3360 MG1_X_268_Y_3360 0 8.4856e-18
C_MG1_X_268_Y_3494 MG1_X_268_Y_3494 0 8.8392e-18
C_MG1_X_268_Y_3920 MG1_X_268_Y_3920 0 8.4856e-18
C_MG1_X_268_Y_4032 MG1_X_268_Y_4032 0 8.8392e-18
C_MG1_X_268_Y_4480 MG1_X_268_Y_4480 0 8.4856e-18
C_MG1_X_268_Y_4569 MG1_X_268_Y_4569 0 8.8392e-18
C_MG1_X_268_Y_5040 MG1_X_268_Y_5040 0 8.4856e-18
C_MG1_X_268_Y_5107 MG1_X_268_Y_5107 0 8.8392e-18
C_MG1_X_268_Y_560 MG1_X_268_Y_560 0 8.4856e-18
C_MG1_X_268_Y_5600 MG1_X_268_Y_5600 0 8.4856e-18
C_MG1_X_268_Y_5644 MG1_X_268_Y_5644 0 8.8392e-18
C_MG1_X_268_Y_6160 MG1_X_268_Y_6160 0 8.4856e-18
C_MG1_X_268_Y_6182 MG1_X_268_Y_6182 0 8.8392e-18
C_MG1_X_268_Y_6720 MG1_X_268_Y_6720 0 1.6971e-17
C_MG1_X_268_Y_7257 MG1_X_268_Y_7257 0 8.8392e-18
C_MG1_X_268_Y_7280 MG1_X_268_Y_7280 0 8.4856e-18
C_MG1_X_268_Y_7795 MG1_X_268_Y_7795 0 8.8392e-18
C_MG1_X_268_Y_7840 MG1_X_268_Y_7840 0 8.4856e-18
C_MG1_X_268_Y_806 MG1_X_268_Y_806 0 8.8392e-18
C_MG1_X_268_Y_8332 MG1_X_268_Y_8332 0 8.8392e-18
C_MG1_X_268_Y_8400 MG1_X_268_Y_8400 0 8.4856e-18
C_MG1_X_268_Y_8870 MG1_X_268_Y_8870 0 8.8392e-18
C_MG1_X_268_Y_8960 MG1_X_268_Y_8960 0 8.4856e-18
C_MG1_X_268_Y_9408 MG1_X_268_Y_9408 0 8.8392e-18
C_MG1_X_268_Y_9520 MG1_X_268_Y_9520 0 8.4856e-18
C_MG1_X_268_Y_9945 MG1_X_268_Y_9945 0 7.5764e-18
C_MG1_X_2956_Y_0 MG1_X_2956_Y_0 0 4.2428e-18
C_MG1_X_2956_Y_10000 MG1_X_2956_Y_10000 0 8.5866e-19
C_MG1_X_2956_Y_1120 MG1_X_2956_Y_1120 0 8.4856e-18
C_MG1_X_2956_Y_1344 MG1_X_2956_Y_1344 0 8.8392e-18
C_MG1_X_2956_Y_1680 MG1_X_2956_Y_1680 0 8.4856e-18
C_MG1_X_2956_Y_1881 MG1_X_2956_Y_1881 0 8.8392e-18
C_MG1_X_2956_Y_2240 MG1_X_2956_Y_2240 0 8.4856e-18
C_MG1_X_2956_Y_2419 MG1_X_2956_Y_2419 0 8.8392e-18
C_MG1_X_2956_Y_268 MG1_X_2956_Y_268 0 8.8392e-18
C_MG1_X_2956_Y_2800 MG1_X_2956_Y_2800 0 8.4856e-18
C_MG1_X_2956_Y_2956 MG1_X_2956_Y_2956 0 8.8392e-18
C_MG1_X_2956_Y_3360 MG1_X_2956_Y_3360 0 8.4856e-18
C_MG1_X_2956_Y_3494 MG1_X_2956_Y_3494 0 8.8392e-18
C_MG1_X_2956_Y_3920 MG1_X_2956_Y_3920 0 8.4856e-18
C_MG1_X_2956_Y_4032 MG1_X_2956_Y_4032 0 8.8392e-18
C_MG1_X_2956_Y_4480 MG1_X_2956_Y_4480 0 8.4856e-18
C_MG1_X_2956_Y_4569 MG1_X_2956_Y_4569 0 8.8392e-18
C_MG1_X_2956_Y_5040 MG1_X_2956_Y_5040 0 8.4856e-18
C_MG1_X_2956_Y_5107 MG1_X_2956_Y_5107 0 8.8392e-18
C_MG1_X_2956_Y_560 MG1_X_2956_Y_560 0 8.4856e-18
C_MG1_X_2956_Y_5600 MG1_X_2956_Y_5600 0 8.4856e-18
C_MG1_X_2956_Y_5644 MG1_X_2956_Y_5644 0 8.8392e-18
C_MG1_X_2956_Y_6160 MG1_X_2956_Y_6160 0 8.4856e-18
C_MG1_X_2956_Y_6182 MG1_X_2956_Y_6182 0 8.8392e-18
C_MG1_X_2956_Y_6720 MG1_X_2956_Y_6720 0 1.6971e-17
C_MG1_X_2956_Y_7257 MG1_X_2956_Y_7257 0 8.8392e-18
C_MG1_X_2956_Y_7280 MG1_X_2956_Y_7280 0 8.4856e-18
C_MG1_X_2956_Y_7795 MG1_X_2956_Y_7795 0 8.8392e-18
C_MG1_X_2956_Y_7840 MG1_X_2956_Y_7840 0 8.4856e-18
C_MG1_X_2956_Y_806 MG1_X_2956_Y_806 0 8.8392e-18
C_MG1_X_2956_Y_8332 MG1_X_2956_Y_8332 0 8.8392e-18
C_MG1_X_2956_Y_8400 MG1_X_2956_Y_8400 0 8.4856e-18
C_MG1_X_2956_Y_8870 MG1_X_2956_Y_8870 0 8.8392e-18
C_MG1_X_2956_Y_8960 MG1_X_2956_Y_8960 0 8.4856e-18
C_MG1_X_2956_Y_9408 MG1_X_2956_Y_9408 0 8.8392e-18
C_MG1_X_2956_Y_9520 MG1_X_2956_Y_9520 0 8.4856e-18
C_MG1_X_2956_Y_9945 MG1_X_2956_Y_9945 0 7.5764e-18
C_MG1_X_3225_Y_0 MG1_X_3225_Y_0 0 8.4856e-18
C_MG1_X_3225_Y_10000 MG1_X_3225_Y_10000 0 5.1015e-18
C_MG1_X_3225_Y_1075 MG1_X_3225_Y_1075 0 8.8392e-18
C_MG1_X_3225_Y_1120 MG1_X_3225_Y_1120 0 8.4856e-18
C_MG1_X_3225_Y_1612 MG1_X_3225_Y_1612 0 8.8392e-18
C_MG1_X_3225_Y_1680 MG1_X_3225_Y_1680 0 8.4856e-18
C_MG1_X_3225_Y_2150 MG1_X_3225_Y_2150 0 8.8392e-18
C_MG1_X_3225_Y_2240 MG1_X_3225_Y_2240 0 8.4856e-18
C_MG1_X_3225_Y_2688 MG1_X_3225_Y_2688 0 8.8392e-18
C_MG1_X_3225_Y_2800 MG1_X_3225_Y_2800 0 8.4856e-18
C_MG1_X_3225_Y_3225 MG1_X_3225_Y_3225 0 8.8392e-18
C_MG1_X_3225_Y_3360 MG1_X_3225_Y_3360 0 8.4856e-18
C_MG1_X_3225_Y_3763 MG1_X_3225_Y_3763 0 8.8392e-18
C_MG1_X_3225_Y_3920 MG1_X_3225_Y_3920 0 8.4856e-18
C_MG1_X_3225_Y_4300 MG1_X_3225_Y_4300 0 8.8392e-18
C_MG1_X_3225_Y_4480 MG1_X_3225_Y_4480 0 8.4856e-18
C_MG1_X_3225_Y_4838 MG1_X_3225_Y_4838 0 8.8392e-18
C_MG1_X_3225_Y_5040 MG1_X_3225_Y_5040 0 8.4856e-18
C_MG1_X_3225_Y_537 MG1_X_3225_Y_537 0 8.8392e-18
C_MG1_X_3225_Y_5376 MG1_X_3225_Y_5376 0 8.8392e-18
C_MG1_X_3225_Y_560 MG1_X_3225_Y_560 0 8.4856e-18
C_MG1_X_3225_Y_5600 MG1_X_3225_Y_5600 0 8.4856e-18
C_MG1_X_3225_Y_5913 MG1_X_3225_Y_5913 0 8.8392e-18
C_MG1_X_3225_Y_6160 MG1_X_3225_Y_6160 0 8.4856e-18
C_MG1_X_3225_Y_6451 MG1_X_3225_Y_6451 0 8.8392e-18
C_MG1_X_3225_Y_6720 MG1_X_3225_Y_6720 0 8.4856e-18
C_MG1_X_3225_Y_6988 MG1_X_3225_Y_6988 0 8.8392e-18
C_MG1_X_3225_Y_7280 MG1_X_3225_Y_7280 0 8.4856e-18
C_MG1_X_3225_Y_7526 MG1_X_3225_Y_7526 0 8.8392e-18
C_MG1_X_3225_Y_7840 MG1_X_3225_Y_7840 0 8.4856e-18
C_MG1_X_3225_Y_8064 MG1_X_3225_Y_8064 0 8.8392e-18
C_MG1_X_3225_Y_8400 MG1_X_3225_Y_8400 0 8.4856e-18
C_MG1_X_3225_Y_8601 MG1_X_3225_Y_8601 0 8.8392e-18
C_MG1_X_3225_Y_8960 MG1_X_3225_Y_8960 0 8.4856e-18
C_MG1_X_3225_Y_9139 MG1_X_3225_Y_9139 0 8.8392e-18
C_MG1_X_3225_Y_9520 MG1_X_3225_Y_9520 0 8.4856e-18
C_MG1_X_3225_Y_9676 MG1_X_3225_Y_9676 0 7.5764e-18
C_MG1_X_3494_Y_0 MG1_X_3494_Y_0 0 4.2428e-18
C_MG1_X_3494_Y_10000 MG1_X_3494_Y_10000 0 8.5866e-19
C_MG1_X_3494_Y_1120 MG1_X_3494_Y_1120 0 8.4856e-18
C_MG1_X_3494_Y_1344 MG1_X_3494_Y_1344 0 8.8392e-18
C_MG1_X_3494_Y_1680 MG1_X_3494_Y_1680 0 8.4856e-18
C_MG1_X_3494_Y_1881 MG1_X_3494_Y_1881 0 8.8392e-18
C_MG1_X_3494_Y_2240 MG1_X_3494_Y_2240 0 8.4856e-18
C_MG1_X_3494_Y_2419 MG1_X_3494_Y_2419 0 8.8392e-18
C_MG1_X_3494_Y_268 MG1_X_3494_Y_268 0 8.8392e-18
C_MG1_X_3494_Y_2800 MG1_X_3494_Y_2800 0 8.4856e-18
C_MG1_X_3494_Y_2956 MG1_X_3494_Y_2956 0 8.8392e-18
C_MG1_X_3494_Y_3360 MG1_X_3494_Y_3360 0 8.4856e-18
C_MG1_X_3494_Y_3494 MG1_X_3494_Y_3494 0 8.8392e-18
C_MG1_X_3494_Y_3920 MG1_X_3494_Y_3920 0 8.4856e-18
C_MG1_X_3494_Y_4032 MG1_X_3494_Y_4032 0 8.8392e-18
C_MG1_X_3494_Y_4480 MG1_X_3494_Y_4480 0 8.4856e-18
C_MG1_X_3494_Y_4569 MG1_X_3494_Y_4569 0 8.8392e-18
C_MG1_X_3494_Y_5040 MG1_X_3494_Y_5040 0 8.4856e-18
C_MG1_X_3494_Y_5107 MG1_X_3494_Y_5107 0 8.8392e-18
C_MG1_X_3494_Y_560 MG1_X_3494_Y_560 0 8.4856e-18
C_MG1_X_3494_Y_5600 MG1_X_3494_Y_5600 0 8.4856e-18
C_MG1_X_3494_Y_5644 MG1_X_3494_Y_5644 0 8.8392e-18
C_MG1_X_3494_Y_6160 MG1_X_3494_Y_6160 0 8.4856e-18
C_MG1_X_3494_Y_6182 MG1_X_3494_Y_6182 0 8.8392e-18
C_MG1_X_3494_Y_6720 MG1_X_3494_Y_6720 0 1.6971e-17
C_MG1_X_3494_Y_7257 MG1_X_3494_Y_7257 0 8.8392e-18
C_MG1_X_3494_Y_7280 MG1_X_3494_Y_7280 0 8.4856e-18
C_MG1_X_3494_Y_7795 MG1_X_3494_Y_7795 0 8.8392e-18
C_MG1_X_3494_Y_7840 MG1_X_3494_Y_7840 0 8.4856e-18
C_MG1_X_3494_Y_806 MG1_X_3494_Y_806 0 8.8392e-18
C_MG1_X_3494_Y_8332 MG1_X_3494_Y_8332 0 8.8392e-18
C_MG1_X_3494_Y_8400 MG1_X_3494_Y_8400 0 8.4856e-18
C_MG1_X_3494_Y_8870 MG1_X_3494_Y_8870 0 8.8392e-18
C_MG1_X_3494_Y_8960 MG1_X_3494_Y_8960 0 8.4856e-18
C_MG1_X_3494_Y_9408 MG1_X_3494_Y_9408 0 8.8392e-18
C_MG1_X_3494_Y_9520 MG1_X_3494_Y_9520 0 8.4856e-18
C_MG1_X_3494_Y_9945 MG1_X_3494_Y_9945 0 7.5764e-18
C_MG1_X_3763_Y_0 MG1_X_3763_Y_0 0 8.4856e-18
C_MG1_X_3763_Y_10000 MG1_X_3763_Y_10000 0 5.1015e-18
C_MG1_X_3763_Y_1075 MG1_X_3763_Y_1075 0 8.8392e-18
C_MG1_X_3763_Y_1120 MG1_X_3763_Y_1120 0 8.4856e-18
C_MG1_X_3763_Y_1612 MG1_X_3763_Y_1612 0 8.8392e-18
C_MG1_X_3763_Y_1680 MG1_X_3763_Y_1680 0 8.4856e-18
C_MG1_X_3763_Y_2150 MG1_X_3763_Y_2150 0 8.8392e-18
C_MG1_X_3763_Y_2240 MG1_X_3763_Y_2240 0 8.4856e-18
C_MG1_X_3763_Y_2688 MG1_X_3763_Y_2688 0 8.8392e-18
C_MG1_X_3763_Y_2800 MG1_X_3763_Y_2800 0 8.4856e-18
C_MG1_X_3763_Y_3225 MG1_X_3763_Y_3225 0 8.8392e-18
C_MG1_X_3763_Y_3360 MG1_X_3763_Y_3360 0 8.4856e-18
C_MG1_X_3763_Y_3763 MG1_X_3763_Y_3763 0 8.8392e-18
C_MG1_X_3763_Y_3920 MG1_X_3763_Y_3920 0 8.4856e-18
C_MG1_X_3763_Y_4300 MG1_X_3763_Y_4300 0 8.8392e-18
C_MG1_X_3763_Y_4480 MG1_X_3763_Y_4480 0 8.4856e-18
C_MG1_X_3763_Y_4838 MG1_X_3763_Y_4838 0 8.8392e-18
C_MG1_X_3763_Y_5040 MG1_X_3763_Y_5040 0 8.4856e-18
C_MG1_X_3763_Y_537 MG1_X_3763_Y_537 0 8.8392e-18
C_MG1_X_3763_Y_5376 MG1_X_3763_Y_5376 0 8.8392e-18
C_MG1_X_3763_Y_560 MG1_X_3763_Y_560 0 8.4856e-18
C_MG1_X_3763_Y_5600 MG1_X_3763_Y_5600 0 8.4856e-18
C_MG1_X_3763_Y_5913 MG1_X_3763_Y_5913 0 8.8392e-18
C_MG1_X_3763_Y_6160 MG1_X_3763_Y_6160 0 8.4856e-18
C_MG1_X_3763_Y_6451 MG1_X_3763_Y_6451 0 8.8392e-18
C_MG1_X_3763_Y_6720 MG1_X_3763_Y_6720 0 8.4856e-18
C_MG1_X_3763_Y_6988 MG1_X_3763_Y_6988 0 8.8392e-18
C_MG1_X_3763_Y_7280 MG1_X_3763_Y_7280 0 8.4856e-18
C_MG1_X_3763_Y_7526 MG1_X_3763_Y_7526 0 8.8392e-18
C_MG1_X_3763_Y_7840 MG1_X_3763_Y_7840 0 8.4856e-18
C_MG1_X_3763_Y_8064 MG1_X_3763_Y_8064 0 8.8392e-18
C_MG1_X_3763_Y_8400 MG1_X_3763_Y_8400 0 8.4856e-18
C_MG1_X_3763_Y_8601 MG1_X_3763_Y_8601 0 8.8392e-18
C_MG1_X_3763_Y_8960 MG1_X_3763_Y_8960 0 8.4856e-18
C_MG1_X_3763_Y_9139 MG1_X_3763_Y_9139 0 8.8392e-18
C_MG1_X_3763_Y_9520 MG1_X_3763_Y_9520 0 8.4856e-18
C_MG1_X_3763_Y_9676 MG1_X_3763_Y_9676 0 7.5764e-18
C_MG1_X_4032_Y_0 MG1_X_4032_Y_0 0 4.2428e-18
C_MG1_X_4032_Y_10000 MG1_X_4032_Y_10000 0 8.5866e-19
C_MG1_X_4032_Y_1120 MG1_X_4032_Y_1120 0 8.4856e-18
C_MG1_X_4032_Y_1344 MG1_X_4032_Y_1344 0 8.8392e-18
C_MG1_X_4032_Y_1680 MG1_X_4032_Y_1680 0 8.4856e-18
C_MG1_X_4032_Y_1881 MG1_X_4032_Y_1881 0 8.8392e-18
C_MG1_X_4032_Y_2240 MG1_X_4032_Y_2240 0 8.4856e-18
C_MG1_X_4032_Y_2419 MG1_X_4032_Y_2419 0 8.8392e-18
C_MG1_X_4032_Y_268 MG1_X_4032_Y_268 0 8.8392e-18
C_MG1_X_4032_Y_2800 MG1_X_4032_Y_2800 0 8.4856e-18
C_MG1_X_4032_Y_2956 MG1_X_4032_Y_2956 0 8.8392e-18
C_MG1_X_4032_Y_3360 MG1_X_4032_Y_3360 0 8.4856e-18
C_MG1_X_4032_Y_3494 MG1_X_4032_Y_3494 0 8.8392e-18
C_MG1_X_4032_Y_3920 MG1_X_4032_Y_3920 0 8.4856e-18
C_MG1_X_4032_Y_4032 MG1_X_4032_Y_4032 0 8.8392e-18
C_MG1_X_4032_Y_4480 MG1_X_4032_Y_4480 0 8.4856e-18
C_MG1_X_4032_Y_4569 MG1_X_4032_Y_4569 0 8.8392e-18
C_MG1_X_4032_Y_5040 MG1_X_4032_Y_5040 0 8.4856e-18
C_MG1_X_4032_Y_5107 MG1_X_4032_Y_5107 0 8.8392e-18
C_MG1_X_4032_Y_560 MG1_X_4032_Y_560 0 8.4856e-18
C_MG1_X_4032_Y_5600 MG1_X_4032_Y_5600 0 8.4856e-18
C_MG1_X_4032_Y_5644 MG1_X_4032_Y_5644 0 8.8392e-18
C_MG1_X_4032_Y_6160 MG1_X_4032_Y_6160 0 8.4856e-18
C_MG1_X_4032_Y_6182 MG1_X_4032_Y_6182 0 8.8392e-18
C_MG1_X_4032_Y_6720 MG1_X_4032_Y_6720 0 1.6971e-17
C_MG1_X_4032_Y_7257 MG1_X_4032_Y_7257 0 8.8392e-18
C_MG1_X_4032_Y_7280 MG1_X_4032_Y_7280 0 8.4856e-18
C_MG1_X_4032_Y_7795 MG1_X_4032_Y_7795 0 8.8392e-18
C_MG1_X_4032_Y_7840 MG1_X_4032_Y_7840 0 8.4856e-18
C_MG1_X_4032_Y_806 MG1_X_4032_Y_806 0 8.8392e-18
C_MG1_X_4032_Y_8332 MG1_X_4032_Y_8332 0 8.8392e-18
C_MG1_X_4032_Y_8400 MG1_X_4032_Y_8400 0 8.4856e-18
C_MG1_X_4032_Y_8870 MG1_X_4032_Y_8870 0 8.8392e-18
C_MG1_X_4032_Y_8960 MG1_X_4032_Y_8960 0 8.4856e-18
C_MG1_X_4032_Y_9408 MG1_X_4032_Y_9408 0 8.8392e-18
C_MG1_X_4032_Y_9520 MG1_X_4032_Y_9520 0 8.4856e-18
C_MG1_X_4032_Y_9945 MG1_X_4032_Y_9945 0 7.5764e-18
C_MG1_X_4300_Y_0 MG1_X_4300_Y_0 0 8.4856e-18
C_MG1_X_4300_Y_10000 MG1_X_4300_Y_10000 0 5.1015e-18
C_MG1_X_4300_Y_1075 MG1_X_4300_Y_1075 0 8.8392e-18
C_MG1_X_4300_Y_1120 MG1_X_4300_Y_1120 0 8.4856e-18
C_MG1_X_4300_Y_1612 MG1_X_4300_Y_1612 0 8.8392e-18
C_MG1_X_4300_Y_1680 MG1_X_4300_Y_1680 0 8.4856e-18
C_MG1_X_4300_Y_2150 MG1_X_4300_Y_2150 0 8.8392e-18
C_MG1_X_4300_Y_2240 MG1_X_4300_Y_2240 0 8.4856e-18
C_MG1_X_4300_Y_2688 MG1_X_4300_Y_2688 0 8.8392e-18
C_MG1_X_4300_Y_2800 MG1_X_4300_Y_2800 0 8.4856e-18
C_MG1_X_4300_Y_3225 MG1_X_4300_Y_3225 0 8.8392e-18
C_MG1_X_4300_Y_3360 MG1_X_4300_Y_3360 0 8.4856e-18
C_MG1_X_4300_Y_3763 MG1_X_4300_Y_3763 0 8.8392e-18
C_MG1_X_4300_Y_3920 MG1_X_4300_Y_3920 0 8.4856e-18
C_MG1_X_4300_Y_4300 MG1_X_4300_Y_4300 0 8.8392e-18
C_MG1_X_4300_Y_4480 MG1_X_4300_Y_4480 0 8.4856e-18
C_MG1_X_4300_Y_4838 MG1_X_4300_Y_4838 0 8.8392e-18
C_MG1_X_4300_Y_5040 MG1_X_4300_Y_5040 0 8.4856e-18
C_MG1_X_4300_Y_537 MG1_X_4300_Y_537 0 8.8392e-18
C_MG1_X_4300_Y_5376 MG1_X_4300_Y_5376 0 8.8392e-18
C_MG1_X_4300_Y_560 MG1_X_4300_Y_560 0 8.4856e-18
C_MG1_X_4300_Y_5600 MG1_X_4300_Y_5600 0 8.4856e-18
C_MG1_X_4300_Y_5913 MG1_X_4300_Y_5913 0 8.8392e-18
C_MG1_X_4300_Y_6160 MG1_X_4300_Y_6160 0 8.4856e-18
C_MG1_X_4300_Y_6451 MG1_X_4300_Y_6451 0 8.8392e-18
C_MG1_X_4300_Y_6720 MG1_X_4300_Y_6720 0 8.4856e-18
C_MG1_X_4300_Y_6988 MG1_X_4300_Y_6988 0 8.8392e-18
C_MG1_X_4300_Y_7280 MG1_X_4300_Y_7280 0 8.4856e-18
C_MG1_X_4300_Y_7526 MG1_X_4300_Y_7526 0 8.8392e-18
C_MG1_X_4300_Y_7840 MG1_X_4300_Y_7840 0 8.4856e-18
C_MG1_X_4300_Y_8064 MG1_X_4300_Y_8064 0 8.8392e-18
C_MG1_X_4300_Y_8400 MG1_X_4300_Y_8400 0 8.4856e-18
C_MG1_X_4300_Y_8601 MG1_X_4300_Y_8601 0 8.8392e-18
C_MG1_X_4300_Y_8960 MG1_X_4300_Y_8960 0 8.4856e-18
C_MG1_X_4300_Y_9139 MG1_X_4300_Y_9139 0 8.8392e-18
C_MG1_X_4300_Y_9520 MG1_X_4300_Y_9520 0 8.4856e-18
C_MG1_X_4300_Y_9676 MG1_X_4300_Y_9676 0 7.5764e-18
C_MG1_X_4569_Y_0 MG1_X_4569_Y_0 0 4.2428e-18
C_MG1_X_4569_Y_10000 MG1_X_4569_Y_10000 0 8.5866e-19
C_MG1_X_4569_Y_1120 MG1_X_4569_Y_1120 0 8.4856e-18
C_MG1_X_4569_Y_1344 MG1_X_4569_Y_1344 0 8.8392e-18
C_MG1_X_4569_Y_1680 MG1_X_4569_Y_1680 0 8.4856e-18
C_MG1_X_4569_Y_1881 MG1_X_4569_Y_1881 0 8.8392e-18
C_MG1_X_4569_Y_2240 MG1_X_4569_Y_2240 0 8.4856e-18
C_MG1_X_4569_Y_2419 MG1_X_4569_Y_2419 0 8.8392e-18
C_MG1_X_4569_Y_268 MG1_X_4569_Y_268 0 8.8392e-18
C_MG1_X_4569_Y_2800 MG1_X_4569_Y_2800 0 8.4856e-18
C_MG1_X_4569_Y_2956 MG1_X_4569_Y_2956 0 8.8392e-18
C_MG1_X_4569_Y_3360 MG1_X_4569_Y_3360 0 8.4856e-18
C_MG1_X_4569_Y_3494 MG1_X_4569_Y_3494 0 8.8392e-18
C_MG1_X_4569_Y_3920 MG1_X_4569_Y_3920 0 8.4856e-18
C_MG1_X_4569_Y_4032 MG1_X_4569_Y_4032 0 8.8392e-18
C_MG1_X_4569_Y_4480 MG1_X_4569_Y_4480 0 8.4856e-18
C_MG1_X_4569_Y_4569 MG1_X_4569_Y_4569 0 8.8392e-18
C_MG1_X_4569_Y_5040 MG1_X_4569_Y_5040 0 8.4856e-18
C_MG1_X_4569_Y_5107 MG1_X_4569_Y_5107 0 8.8392e-18
C_MG1_X_4569_Y_560 MG1_X_4569_Y_560 0 8.4856e-18
C_MG1_X_4569_Y_5600 MG1_X_4569_Y_5600 0 8.4856e-18
C_MG1_X_4569_Y_5644 MG1_X_4569_Y_5644 0 8.8392e-18
C_MG1_X_4569_Y_6160 MG1_X_4569_Y_6160 0 8.4856e-18
C_MG1_X_4569_Y_6182 MG1_X_4569_Y_6182 0 8.8392e-18
C_MG1_X_4569_Y_6720 MG1_X_4569_Y_6720 0 1.6971e-17
C_MG1_X_4569_Y_7257 MG1_X_4569_Y_7257 0 8.8392e-18
C_MG1_X_4569_Y_7280 MG1_X_4569_Y_7280 0 8.4856e-18
C_MG1_X_4569_Y_7795 MG1_X_4569_Y_7795 0 8.8392e-18
C_MG1_X_4569_Y_7840 MG1_X_4569_Y_7840 0 8.4856e-18
C_MG1_X_4569_Y_806 MG1_X_4569_Y_806 0 8.8392e-18
C_MG1_X_4569_Y_8332 MG1_X_4569_Y_8332 0 8.8392e-18
C_MG1_X_4569_Y_8400 MG1_X_4569_Y_8400 0 8.4856e-18
C_MG1_X_4569_Y_8870 MG1_X_4569_Y_8870 0 8.8392e-18
C_MG1_X_4569_Y_8960 MG1_X_4569_Y_8960 0 8.4856e-18
C_MG1_X_4569_Y_9408 MG1_X_4569_Y_9408 0 8.8392e-18
C_MG1_X_4569_Y_9520 MG1_X_4569_Y_9520 0 8.4856e-18
C_MG1_X_4569_Y_9945 MG1_X_4569_Y_9945 0 7.5764e-18
C_MG1_X_4838_Y_0 MG1_X_4838_Y_0 0 8.4856e-18
C_MG1_X_4838_Y_10000 MG1_X_4838_Y_10000 0 5.1015e-18
C_MG1_X_4838_Y_1075 MG1_X_4838_Y_1075 0 8.8392e-18
C_MG1_X_4838_Y_1120 MG1_X_4838_Y_1120 0 8.4856e-18
C_MG1_X_4838_Y_1612 MG1_X_4838_Y_1612 0 8.8392e-18
C_MG1_X_4838_Y_1680 MG1_X_4838_Y_1680 0 8.4856e-18
C_MG1_X_4838_Y_2150 MG1_X_4838_Y_2150 0 8.8392e-18
C_MG1_X_4838_Y_2240 MG1_X_4838_Y_2240 0 8.4856e-18
C_MG1_X_4838_Y_2688 MG1_X_4838_Y_2688 0 8.8392e-18
C_MG1_X_4838_Y_2800 MG1_X_4838_Y_2800 0 8.4856e-18
C_MG1_X_4838_Y_3225 MG1_X_4838_Y_3225 0 8.8392e-18
C_MG1_X_4838_Y_3360 MG1_X_4838_Y_3360 0 8.4856e-18
C_MG1_X_4838_Y_3763 MG1_X_4838_Y_3763 0 8.8392e-18
C_MG1_X_4838_Y_3920 MG1_X_4838_Y_3920 0 8.4856e-18
C_MG1_X_4838_Y_4300 MG1_X_4838_Y_4300 0 8.8392e-18
C_MG1_X_4838_Y_4480 MG1_X_4838_Y_4480 0 8.4856e-18
C_MG1_X_4838_Y_4838 MG1_X_4838_Y_4838 0 8.8392e-18
C_MG1_X_4838_Y_5040 MG1_X_4838_Y_5040 0 8.4856e-18
C_MG1_X_4838_Y_537 MG1_X_4838_Y_537 0 8.8392e-18
C_MG1_X_4838_Y_5376 MG1_X_4838_Y_5376 0 8.8392e-18
C_MG1_X_4838_Y_560 MG1_X_4838_Y_560 0 8.4856e-18
C_MG1_X_4838_Y_5600 MG1_X_4838_Y_5600 0 8.4856e-18
C_MG1_X_4838_Y_5913 MG1_X_4838_Y_5913 0 8.8392e-18
C_MG1_X_4838_Y_6160 MG1_X_4838_Y_6160 0 8.4856e-18
C_MG1_X_4838_Y_6451 MG1_X_4838_Y_6451 0 8.8392e-18
C_MG1_X_4838_Y_6720 MG1_X_4838_Y_6720 0 8.4856e-18
C_MG1_X_4838_Y_6988 MG1_X_4838_Y_6988 0 8.8392e-18
C_MG1_X_4838_Y_7280 MG1_X_4838_Y_7280 0 8.4856e-18
C_MG1_X_4838_Y_7526 MG1_X_4838_Y_7526 0 8.8392e-18
C_MG1_X_4838_Y_7840 MG1_X_4838_Y_7840 0 8.4856e-18
C_MG1_X_4838_Y_8064 MG1_X_4838_Y_8064 0 8.8392e-18
C_MG1_X_4838_Y_8400 MG1_X_4838_Y_8400 0 8.4856e-18
C_MG1_X_4838_Y_8601 MG1_X_4838_Y_8601 0 8.8392e-18
C_MG1_X_4838_Y_8960 MG1_X_4838_Y_8960 0 8.4856e-18
C_MG1_X_4838_Y_9139 MG1_X_4838_Y_9139 0 8.8392e-18
C_MG1_X_4838_Y_9520 MG1_X_4838_Y_9520 0 8.4856e-18
C_MG1_X_4838_Y_9676 MG1_X_4838_Y_9676 0 7.5764e-18
C_MG1_X_5107_Y_0 MG1_X_5107_Y_0 0 4.2428e-18
C_MG1_X_5107_Y_10000 MG1_X_5107_Y_10000 0 8.5866e-19
C_MG1_X_5107_Y_1120 MG1_X_5107_Y_1120 0 8.4856e-18
C_MG1_X_5107_Y_1344 MG1_X_5107_Y_1344 0 8.8392e-18
C_MG1_X_5107_Y_1680 MG1_X_5107_Y_1680 0 8.4856e-18
C_MG1_X_5107_Y_1881 MG1_X_5107_Y_1881 0 8.8392e-18
C_MG1_X_5107_Y_2240 MG1_X_5107_Y_2240 0 8.4856e-18
C_MG1_X_5107_Y_2419 MG1_X_5107_Y_2419 0 8.8392e-18
C_MG1_X_5107_Y_268 MG1_X_5107_Y_268 0 8.8392e-18
C_MG1_X_5107_Y_2800 MG1_X_5107_Y_2800 0 8.4856e-18
C_MG1_X_5107_Y_2956 MG1_X_5107_Y_2956 0 8.8392e-18
C_MG1_X_5107_Y_3360 MG1_X_5107_Y_3360 0 8.4856e-18
C_MG1_X_5107_Y_3494 MG1_X_5107_Y_3494 0 8.8392e-18
C_MG1_X_5107_Y_3920 MG1_X_5107_Y_3920 0 8.4856e-18
C_MG1_X_5107_Y_4032 MG1_X_5107_Y_4032 0 8.8392e-18
C_MG1_X_5107_Y_4480 MG1_X_5107_Y_4480 0 8.4856e-18
C_MG1_X_5107_Y_4569 MG1_X_5107_Y_4569 0 8.8392e-18
C_MG1_X_5107_Y_5040 MG1_X_5107_Y_5040 0 8.4856e-18
C_MG1_X_5107_Y_5107 MG1_X_5107_Y_5107 0 8.8392e-18
C_MG1_X_5107_Y_560 MG1_X_5107_Y_560 0 8.4856e-18
C_MG1_X_5107_Y_5600 MG1_X_5107_Y_5600 0 8.4856e-18
C_MG1_X_5107_Y_5644 MG1_X_5107_Y_5644 0 8.8392e-18
C_MG1_X_5107_Y_6160 MG1_X_5107_Y_6160 0 8.4856e-18
C_MG1_X_5107_Y_6182 MG1_X_5107_Y_6182 0 8.8392e-18
C_MG1_X_5107_Y_6720 MG1_X_5107_Y_6720 0 1.6971e-17
C_MG1_X_5107_Y_7257 MG1_X_5107_Y_7257 0 8.8392e-18
C_MG1_X_5107_Y_7280 MG1_X_5107_Y_7280 0 8.4856e-18
C_MG1_X_5107_Y_7795 MG1_X_5107_Y_7795 0 8.8392e-18
C_MG1_X_5107_Y_7840 MG1_X_5107_Y_7840 0 8.4856e-18
C_MG1_X_5107_Y_806 MG1_X_5107_Y_806 0 8.8392e-18
C_MG1_X_5107_Y_8332 MG1_X_5107_Y_8332 0 8.8392e-18
C_MG1_X_5107_Y_8400 MG1_X_5107_Y_8400 0 8.4856e-18
C_MG1_X_5107_Y_8870 MG1_X_5107_Y_8870 0 8.8392e-18
C_MG1_X_5107_Y_8960 MG1_X_5107_Y_8960 0 8.4856e-18
C_MG1_X_5107_Y_9408 MG1_X_5107_Y_9408 0 8.8392e-18
C_MG1_X_5107_Y_9520 MG1_X_5107_Y_9520 0 8.4856e-18
C_MG1_X_5107_Y_9945 MG1_X_5107_Y_9945 0 7.5764e-18
C_MG1_X_5376_Y_0 MG1_X_5376_Y_0 0 8.4856e-18
C_MG1_X_5376_Y_10000 MG1_X_5376_Y_10000 0 5.1015e-18
C_MG1_X_5376_Y_1075 MG1_X_5376_Y_1075 0 8.8392e-18
C_MG1_X_5376_Y_1120 MG1_X_5376_Y_1120 0 8.4856e-18
C_MG1_X_5376_Y_1612 MG1_X_5376_Y_1612 0 8.8392e-18
C_MG1_X_5376_Y_1680 MG1_X_5376_Y_1680 0 8.4856e-18
C_MG1_X_5376_Y_2150 MG1_X_5376_Y_2150 0 8.8392e-18
C_MG1_X_5376_Y_2240 MG1_X_5376_Y_2240 0 8.4856e-18
C_MG1_X_5376_Y_2688 MG1_X_5376_Y_2688 0 8.8392e-18
C_MG1_X_5376_Y_2800 MG1_X_5376_Y_2800 0 8.4856e-18
C_MG1_X_5376_Y_3225 MG1_X_5376_Y_3225 0 8.8392e-18
C_MG1_X_5376_Y_3360 MG1_X_5376_Y_3360 0 8.4856e-18
C_MG1_X_5376_Y_3763 MG1_X_5376_Y_3763 0 8.8392e-18
C_MG1_X_5376_Y_3920 MG1_X_5376_Y_3920 0 8.4856e-18
C_MG1_X_5376_Y_4300 MG1_X_5376_Y_4300 0 8.8392e-18
C_MG1_X_5376_Y_4480 MG1_X_5376_Y_4480 0 8.4856e-18
C_MG1_X_5376_Y_4838 MG1_X_5376_Y_4838 0 8.8392e-18
C_MG1_X_5376_Y_5040 MG1_X_5376_Y_5040 0 8.4856e-18
C_MG1_X_5376_Y_537 MG1_X_5376_Y_537 0 8.8392e-18
C_MG1_X_5376_Y_5376 MG1_X_5376_Y_5376 0 8.8392e-18
C_MG1_X_5376_Y_560 MG1_X_5376_Y_560 0 8.4856e-18
C_MG1_X_5376_Y_5600 MG1_X_5376_Y_5600 0 8.4856e-18
C_MG1_X_5376_Y_5913 MG1_X_5376_Y_5913 0 8.8392e-18
C_MG1_X_5376_Y_6160 MG1_X_5376_Y_6160 0 8.4856e-18
C_MG1_X_5376_Y_6451 MG1_X_5376_Y_6451 0 8.8392e-18
C_MG1_X_5376_Y_6720 MG1_X_5376_Y_6720 0 8.4856e-18
C_MG1_X_5376_Y_6988 MG1_X_5376_Y_6988 0 8.8392e-18
C_MG1_X_5376_Y_7280 MG1_X_5376_Y_7280 0 8.4856e-18
C_MG1_X_5376_Y_7526 MG1_X_5376_Y_7526 0 8.8392e-18
C_MG1_X_5376_Y_7840 MG1_X_5376_Y_7840 0 8.4856e-18
C_MG1_X_5376_Y_8064 MG1_X_5376_Y_8064 0 8.8392e-18
C_MG1_X_5376_Y_8400 MG1_X_5376_Y_8400 0 8.4856e-18
C_MG1_X_5376_Y_8601 MG1_X_5376_Y_8601 0 8.8392e-18
C_MG1_X_5376_Y_8960 MG1_X_5376_Y_8960 0 8.4856e-18
C_MG1_X_5376_Y_9139 MG1_X_5376_Y_9139 0 8.8392e-18
C_MG1_X_5376_Y_9520 MG1_X_5376_Y_9520 0 8.4856e-18
C_MG1_X_5376_Y_9676 MG1_X_5376_Y_9676 0 7.5764e-18
C_MG1_X_537_Y_0 MG1_X_537_Y_0 0 8.4856e-18
C_MG1_X_537_Y_10000 MG1_X_537_Y_10000 0 5.1015e-18
C_MG1_X_537_Y_1075 MG1_X_537_Y_1075 0 8.8392e-18
C_MG1_X_537_Y_1120 MG1_X_537_Y_1120 0 8.4856e-18
C_MG1_X_537_Y_1612 MG1_X_537_Y_1612 0 8.8392e-18
C_MG1_X_537_Y_1680 MG1_X_537_Y_1680 0 8.4856e-18
C_MG1_X_537_Y_2150 MG1_X_537_Y_2150 0 8.8392e-18
C_MG1_X_537_Y_2240 MG1_X_537_Y_2240 0 8.4856e-18
C_MG1_X_537_Y_2688 MG1_X_537_Y_2688 0 8.8392e-18
C_MG1_X_537_Y_2800 MG1_X_537_Y_2800 0 8.4856e-18
C_MG1_X_537_Y_3225 MG1_X_537_Y_3225 0 8.8392e-18
C_MG1_X_537_Y_3360 MG1_X_537_Y_3360 0 8.4856e-18
C_MG1_X_537_Y_3763 MG1_X_537_Y_3763 0 8.8392e-18
C_MG1_X_537_Y_3920 MG1_X_537_Y_3920 0 8.4856e-18
C_MG1_X_537_Y_4300 MG1_X_537_Y_4300 0 8.8392e-18
C_MG1_X_537_Y_4480 MG1_X_537_Y_4480 0 8.4856e-18
C_MG1_X_537_Y_4838 MG1_X_537_Y_4838 0 8.8392e-18
C_MG1_X_537_Y_5040 MG1_X_537_Y_5040 0 8.4856e-18
C_MG1_X_537_Y_537 MG1_X_537_Y_537 0 8.8392e-18
C_MG1_X_537_Y_5376 MG1_X_537_Y_5376 0 8.8392e-18
C_MG1_X_537_Y_560 MG1_X_537_Y_560 0 8.4856e-18
C_MG1_X_537_Y_5600 MG1_X_537_Y_5600 0 8.4856e-18
C_MG1_X_537_Y_5913 MG1_X_537_Y_5913 0 8.8392e-18
C_MG1_X_537_Y_6160 MG1_X_537_Y_6160 0 8.4856e-18
C_MG1_X_537_Y_6451 MG1_X_537_Y_6451 0 8.8392e-18
C_MG1_X_537_Y_6720 MG1_X_537_Y_6720 0 8.4856e-18
C_MG1_X_537_Y_6988 MG1_X_537_Y_6988 0 8.8392e-18
C_MG1_X_537_Y_7280 MG1_X_537_Y_7280 0 8.4856e-18
C_MG1_X_537_Y_7526 MG1_X_537_Y_7526 0 8.8392e-18
C_MG1_X_537_Y_7840 MG1_X_537_Y_7840 0 8.4856e-18
C_MG1_X_537_Y_8064 MG1_X_537_Y_8064 0 8.8392e-18
C_MG1_X_537_Y_8400 MG1_X_537_Y_8400 0 8.4856e-18
C_MG1_X_537_Y_8601 MG1_X_537_Y_8601 0 8.8392e-18
C_MG1_X_537_Y_8960 MG1_X_537_Y_8960 0 8.4856e-18
C_MG1_X_537_Y_9139 MG1_X_537_Y_9139 0 8.8392e-18
C_MG1_X_537_Y_9520 MG1_X_537_Y_9520 0 8.4856e-18
C_MG1_X_537_Y_9676 MG1_X_537_Y_9676 0 7.5764e-18
C_MG1_X_5644_Y_0 MG1_X_5644_Y_0 0 4.2428e-18
C_MG1_X_5644_Y_10000 MG1_X_5644_Y_10000 0 8.5866e-19
C_MG1_X_5644_Y_1120 MG1_X_5644_Y_1120 0 8.4856e-18
C_MG1_X_5644_Y_1344 MG1_X_5644_Y_1344 0 8.8392e-18
C_MG1_X_5644_Y_1680 MG1_X_5644_Y_1680 0 8.4856e-18
C_MG1_X_5644_Y_1881 MG1_X_5644_Y_1881 0 8.8392e-18
C_MG1_X_5644_Y_2240 MG1_X_5644_Y_2240 0 8.4856e-18
C_MG1_X_5644_Y_2419 MG1_X_5644_Y_2419 0 8.8392e-18
C_MG1_X_5644_Y_268 MG1_X_5644_Y_268 0 8.8392e-18
C_MG1_X_5644_Y_2800 MG1_X_5644_Y_2800 0 8.4856e-18
C_MG1_X_5644_Y_2956 MG1_X_5644_Y_2956 0 8.8392e-18
C_MG1_X_5644_Y_3360 MG1_X_5644_Y_3360 0 8.4856e-18
C_MG1_X_5644_Y_3494 MG1_X_5644_Y_3494 0 8.8392e-18
C_MG1_X_5644_Y_3920 MG1_X_5644_Y_3920 0 8.4856e-18
C_MG1_X_5644_Y_4032 MG1_X_5644_Y_4032 0 8.8392e-18
C_MG1_X_5644_Y_4480 MG1_X_5644_Y_4480 0 8.4856e-18
C_MG1_X_5644_Y_4569 MG1_X_5644_Y_4569 0 8.8392e-18
C_MG1_X_5644_Y_5040 MG1_X_5644_Y_5040 0 8.4856e-18
C_MG1_X_5644_Y_5107 MG1_X_5644_Y_5107 0 8.8392e-18
C_MG1_X_5644_Y_560 MG1_X_5644_Y_560 0 8.4856e-18
C_MG1_X_5644_Y_5600 MG1_X_5644_Y_5600 0 8.4856e-18
C_MG1_X_5644_Y_5644 MG1_X_5644_Y_5644 0 8.8392e-18
C_MG1_X_5644_Y_6160 MG1_X_5644_Y_6160 0 8.4856e-18
C_MG1_X_5644_Y_6182 MG1_X_5644_Y_6182 0 8.8392e-18
C_MG1_X_5644_Y_6720 MG1_X_5644_Y_6720 0 1.6971e-17
C_MG1_X_5644_Y_7257 MG1_X_5644_Y_7257 0 8.8392e-18
C_MG1_X_5644_Y_7280 MG1_X_5644_Y_7280 0 8.4856e-18
C_MG1_X_5644_Y_7795 MG1_X_5644_Y_7795 0 8.8392e-18
C_MG1_X_5644_Y_7840 MG1_X_5644_Y_7840 0 8.4856e-18
C_MG1_X_5644_Y_806 MG1_X_5644_Y_806 0 8.8392e-18
C_MG1_X_5644_Y_8332 MG1_X_5644_Y_8332 0 8.8392e-18
C_MG1_X_5644_Y_8400 MG1_X_5644_Y_8400 0 8.4856e-18
C_MG1_X_5644_Y_8870 MG1_X_5644_Y_8870 0 8.8392e-18
C_MG1_X_5644_Y_8960 MG1_X_5644_Y_8960 0 8.4856e-18
C_MG1_X_5644_Y_9408 MG1_X_5644_Y_9408 0 8.8392e-18
C_MG1_X_5644_Y_9520 MG1_X_5644_Y_9520 0 8.4856e-18
C_MG1_X_5644_Y_9945 MG1_X_5644_Y_9945 0 7.5764e-18
C_MG1_X_5913_Y_0 MG1_X_5913_Y_0 0 8.4856e-18
C_MG1_X_5913_Y_10000 MG1_X_5913_Y_10000 0 5.1015e-18
C_MG1_X_5913_Y_1075 MG1_X_5913_Y_1075 0 8.8392e-18
C_MG1_X_5913_Y_1120 MG1_X_5913_Y_1120 0 8.4856e-18
C_MG1_X_5913_Y_1612 MG1_X_5913_Y_1612 0 8.8392e-18
C_MG1_X_5913_Y_1680 MG1_X_5913_Y_1680 0 8.4856e-18
C_MG1_X_5913_Y_2150 MG1_X_5913_Y_2150 0 8.8392e-18
C_MG1_X_5913_Y_2240 MG1_X_5913_Y_2240 0 8.4856e-18
C_MG1_X_5913_Y_2688 MG1_X_5913_Y_2688 0 8.8392e-18
C_MG1_X_5913_Y_2800 MG1_X_5913_Y_2800 0 8.4856e-18
C_MG1_X_5913_Y_3225 MG1_X_5913_Y_3225 0 8.8392e-18
C_MG1_X_5913_Y_3360 MG1_X_5913_Y_3360 0 8.4856e-18
C_MG1_X_5913_Y_3763 MG1_X_5913_Y_3763 0 8.8392e-18
C_MG1_X_5913_Y_3920 MG1_X_5913_Y_3920 0 8.4856e-18
C_MG1_X_5913_Y_4300 MG1_X_5913_Y_4300 0 8.8392e-18
C_MG1_X_5913_Y_4480 MG1_X_5913_Y_4480 0 8.4856e-18
C_MG1_X_5913_Y_4838 MG1_X_5913_Y_4838 0 8.8392e-18
C_MG1_X_5913_Y_5040 MG1_X_5913_Y_5040 0 8.4856e-18
C_MG1_X_5913_Y_537 MG1_X_5913_Y_537 0 8.8392e-18
C_MG1_X_5913_Y_5376 MG1_X_5913_Y_5376 0 8.8392e-18
C_MG1_X_5913_Y_560 MG1_X_5913_Y_560 0 8.4856e-18
C_MG1_X_5913_Y_5600 MG1_X_5913_Y_5600 0 8.4856e-18
C_MG1_X_5913_Y_5913 MG1_X_5913_Y_5913 0 8.8392e-18
C_MG1_X_5913_Y_6160 MG1_X_5913_Y_6160 0 8.4856e-18
C_MG1_X_5913_Y_6451 MG1_X_5913_Y_6451 0 8.8392e-18
C_MG1_X_5913_Y_6720 MG1_X_5913_Y_6720 0 8.4856e-18
C_MG1_X_5913_Y_6988 MG1_X_5913_Y_6988 0 8.8392e-18
C_MG1_X_5913_Y_7280 MG1_X_5913_Y_7280 0 8.4856e-18
C_MG1_X_5913_Y_7526 MG1_X_5913_Y_7526 0 8.8392e-18
C_MG1_X_5913_Y_7840 MG1_X_5913_Y_7840 0 8.4856e-18
C_MG1_X_5913_Y_8064 MG1_X_5913_Y_8064 0 8.8392e-18
C_MG1_X_5913_Y_8400 MG1_X_5913_Y_8400 0 8.4856e-18
C_MG1_X_5913_Y_8601 MG1_X_5913_Y_8601 0 8.8392e-18
C_MG1_X_5913_Y_8960 MG1_X_5913_Y_8960 0 8.4856e-18
C_MG1_X_5913_Y_9139 MG1_X_5913_Y_9139 0 8.8392e-18
C_MG1_X_5913_Y_9520 MG1_X_5913_Y_9520 0 8.4856e-18
C_MG1_X_5913_Y_9676 MG1_X_5913_Y_9676 0 7.5764e-18
C_MG1_X_6182_Y_0 MG1_X_6182_Y_0 0 4.2428e-18
C_MG1_X_6182_Y_10000 MG1_X_6182_Y_10000 0 8.5866e-19
C_MG1_X_6182_Y_1120 MG1_X_6182_Y_1120 0 8.4856e-18
C_MG1_X_6182_Y_1344 MG1_X_6182_Y_1344 0 8.8392e-18
C_MG1_X_6182_Y_1680 MG1_X_6182_Y_1680 0 8.4856e-18
C_MG1_X_6182_Y_1881 MG1_X_6182_Y_1881 0 8.8392e-18
C_MG1_X_6182_Y_2240 MG1_X_6182_Y_2240 0 8.4856e-18
C_MG1_X_6182_Y_2419 MG1_X_6182_Y_2419 0 8.8392e-18
C_MG1_X_6182_Y_268 MG1_X_6182_Y_268 0 8.8392e-18
C_MG1_X_6182_Y_2800 MG1_X_6182_Y_2800 0 8.4856e-18
C_MG1_X_6182_Y_2956 MG1_X_6182_Y_2956 0 8.8392e-18
C_MG1_X_6182_Y_3360 MG1_X_6182_Y_3360 0 8.4856e-18
C_MG1_X_6182_Y_3494 MG1_X_6182_Y_3494 0 8.8392e-18
C_MG1_X_6182_Y_3920 MG1_X_6182_Y_3920 0 8.4856e-18
C_MG1_X_6182_Y_4032 MG1_X_6182_Y_4032 0 8.8392e-18
C_MG1_X_6182_Y_4480 MG1_X_6182_Y_4480 0 8.4856e-18
C_MG1_X_6182_Y_4569 MG1_X_6182_Y_4569 0 8.8392e-18
C_MG1_X_6182_Y_5040 MG1_X_6182_Y_5040 0 8.4856e-18
C_MG1_X_6182_Y_5107 MG1_X_6182_Y_5107 0 8.8392e-18
C_MG1_X_6182_Y_560 MG1_X_6182_Y_560 0 8.4856e-18
C_MG1_X_6182_Y_5600 MG1_X_6182_Y_5600 0 8.4856e-18
C_MG1_X_6182_Y_5644 MG1_X_6182_Y_5644 0 8.8392e-18
C_MG1_X_6182_Y_6160 MG1_X_6182_Y_6160 0 8.4856e-18
C_MG1_X_6182_Y_6182 MG1_X_6182_Y_6182 0 8.8392e-18
C_MG1_X_6182_Y_6720 MG1_X_6182_Y_6720 0 1.6971e-17
C_MG1_X_6182_Y_7257 MG1_X_6182_Y_7257 0 8.8392e-18
C_MG1_X_6182_Y_7280 MG1_X_6182_Y_7280 0 8.4856e-18
C_MG1_X_6182_Y_7795 MG1_X_6182_Y_7795 0 8.8392e-18
C_MG1_X_6182_Y_7840 MG1_X_6182_Y_7840 0 8.4856e-18
C_MG1_X_6182_Y_806 MG1_X_6182_Y_806 0 8.8392e-18
C_MG1_X_6182_Y_8332 MG1_X_6182_Y_8332 0 8.8392e-18
C_MG1_X_6182_Y_8400 MG1_X_6182_Y_8400 0 8.4856e-18
C_MG1_X_6182_Y_8870 MG1_X_6182_Y_8870 0 8.8392e-18
C_MG1_X_6182_Y_8960 MG1_X_6182_Y_8960 0 8.4856e-18
C_MG1_X_6182_Y_9408 MG1_X_6182_Y_9408 0 8.8392e-18
C_MG1_X_6182_Y_9520 MG1_X_6182_Y_9520 0 8.4856e-18
C_MG1_X_6182_Y_9945 MG1_X_6182_Y_9945 0 7.5764e-18
C_MG1_X_6451_Y_0 MG1_X_6451_Y_0 0 8.4856e-18
C_MG1_X_6451_Y_10000 MG1_X_6451_Y_10000 0 5.1015e-18
C_MG1_X_6451_Y_1075 MG1_X_6451_Y_1075 0 8.8392e-18
C_MG1_X_6451_Y_1120 MG1_X_6451_Y_1120 0 8.4856e-18
C_MG1_X_6451_Y_1612 MG1_X_6451_Y_1612 0 8.8392e-18
C_MG1_X_6451_Y_1680 MG1_X_6451_Y_1680 0 8.4856e-18
C_MG1_X_6451_Y_2150 MG1_X_6451_Y_2150 0 8.8392e-18
C_MG1_X_6451_Y_2240 MG1_X_6451_Y_2240 0 8.4856e-18
C_MG1_X_6451_Y_2688 MG1_X_6451_Y_2688 0 8.8392e-18
C_MG1_X_6451_Y_2800 MG1_X_6451_Y_2800 0 8.4856e-18
C_MG1_X_6451_Y_3225 MG1_X_6451_Y_3225 0 8.8392e-18
C_MG1_X_6451_Y_3360 MG1_X_6451_Y_3360 0 8.4856e-18
C_MG1_X_6451_Y_3763 MG1_X_6451_Y_3763 0 8.8392e-18
C_MG1_X_6451_Y_3920 MG1_X_6451_Y_3920 0 8.4856e-18
C_MG1_X_6451_Y_4300 MG1_X_6451_Y_4300 0 8.8392e-18
C_MG1_X_6451_Y_4480 MG1_X_6451_Y_4480 0 8.4856e-18
C_MG1_X_6451_Y_4838 MG1_X_6451_Y_4838 0 8.8392e-18
C_MG1_X_6451_Y_5040 MG1_X_6451_Y_5040 0 8.4856e-18
C_MG1_X_6451_Y_537 MG1_X_6451_Y_537 0 8.8392e-18
C_MG1_X_6451_Y_5376 MG1_X_6451_Y_5376 0 8.8392e-18
C_MG1_X_6451_Y_560 MG1_X_6451_Y_560 0 8.4856e-18
C_MG1_X_6451_Y_5600 MG1_X_6451_Y_5600 0 8.4856e-18
C_MG1_X_6451_Y_5913 MG1_X_6451_Y_5913 0 8.8392e-18
C_MG1_X_6451_Y_6160 MG1_X_6451_Y_6160 0 8.4856e-18
C_MG1_X_6451_Y_6451 MG1_X_6451_Y_6451 0 8.8392e-18
C_MG1_X_6451_Y_6720 MG1_X_6451_Y_6720 0 8.4856e-18
C_MG1_X_6451_Y_6988 MG1_X_6451_Y_6988 0 8.8392e-18
C_MG1_X_6451_Y_7280 MG1_X_6451_Y_7280 0 8.4856e-18
C_MG1_X_6451_Y_7526 MG1_X_6451_Y_7526 0 8.8392e-18
C_MG1_X_6451_Y_7840 MG1_X_6451_Y_7840 0 8.4856e-18
C_MG1_X_6451_Y_8064 MG1_X_6451_Y_8064 0 8.8392e-18
C_MG1_X_6451_Y_8400 MG1_X_6451_Y_8400 0 8.4856e-18
C_MG1_X_6451_Y_8601 MG1_X_6451_Y_8601 0 8.8392e-18
C_MG1_X_6451_Y_8960 MG1_X_6451_Y_8960 0 8.4856e-18
C_MG1_X_6451_Y_9139 MG1_X_6451_Y_9139 0 8.8392e-18
C_MG1_X_6451_Y_9520 MG1_X_6451_Y_9520 0 8.4856e-18
C_MG1_X_6451_Y_9676 MG1_X_6451_Y_9676 0 7.5764e-18
C_MG1_X_6720_Y_0 MG1_X_6720_Y_0 0 4.2428e-18
C_MG1_X_6720_Y_10000 MG1_X_6720_Y_10000 0 8.5866e-19
C_MG1_X_6720_Y_1120 MG1_X_6720_Y_1120 0 8.4856e-18
C_MG1_X_6720_Y_1344 MG1_X_6720_Y_1344 0 8.8392e-18
C_MG1_X_6720_Y_1680 MG1_X_6720_Y_1680 0 8.4856e-18
C_MG1_X_6720_Y_1881 MG1_X_6720_Y_1881 0 8.8392e-18
C_MG1_X_6720_Y_2240 MG1_X_6720_Y_2240 0 8.4856e-18
C_MG1_X_6720_Y_2419 MG1_X_6720_Y_2419 0 8.8392e-18
C_MG1_X_6720_Y_268 MG1_X_6720_Y_268 0 8.8392e-18
C_MG1_X_6720_Y_2800 MG1_X_6720_Y_2800 0 8.4856e-18
C_MG1_X_6720_Y_2956 MG1_X_6720_Y_2956 0 8.8392e-18
C_MG1_X_6720_Y_3360 MG1_X_6720_Y_3360 0 8.4856e-18
C_MG1_X_6720_Y_3494 MG1_X_6720_Y_3494 0 8.8392e-18
C_MG1_X_6720_Y_3920 MG1_X_6720_Y_3920 0 8.4856e-18
C_MG1_X_6720_Y_4032 MG1_X_6720_Y_4032 0 8.8392e-18
C_MG1_X_6720_Y_4480 MG1_X_6720_Y_4480 0 8.4856e-18
C_MG1_X_6720_Y_4569 MG1_X_6720_Y_4569 0 8.8392e-18
C_MG1_X_6720_Y_5040 MG1_X_6720_Y_5040 0 8.4856e-18
C_MG1_X_6720_Y_5107 MG1_X_6720_Y_5107 0 8.8392e-18
C_MG1_X_6720_Y_560 MG1_X_6720_Y_560 0 8.4856e-18
C_MG1_X_6720_Y_5600 MG1_X_6720_Y_5600 0 8.4856e-18
C_MG1_X_6720_Y_5644 MG1_X_6720_Y_5644 0 8.8392e-18
C_MG1_X_6720_Y_6160 MG1_X_6720_Y_6160 0 8.4856e-18
C_MG1_X_6720_Y_6182 MG1_X_6720_Y_6182 0 8.8392e-18
C_MG1_X_6720_Y_6720 MG1_X_6720_Y_6720 0 1.6971e-17
C_MG1_X_6720_Y_7257 MG1_X_6720_Y_7257 0 8.8392e-18
C_MG1_X_6720_Y_7280 MG1_X_6720_Y_7280 0 8.4856e-18
C_MG1_X_6720_Y_7795 MG1_X_6720_Y_7795 0 8.8392e-18
C_MG1_X_6720_Y_7840 MG1_X_6720_Y_7840 0 8.4856e-18
C_MG1_X_6720_Y_806 MG1_X_6720_Y_806 0 8.8392e-18
C_MG1_X_6720_Y_8332 MG1_X_6720_Y_8332 0 8.8392e-18
C_MG1_X_6720_Y_8400 MG1_X_6720_Y_8400 0 8.4856e-18
C_MG1_X_6720_Y_8870 MG1_X_6720_Y_8870 0 8.8392e-18
C_MG1_X_6720_Y_8960 MG1_X_6720_Y_8960 0 8.4856e-18
C_MG1_X_6720_Y_9408 MG1_X_6720_Y_9408 0 8.8392e-18
C_MG1_X_6720_Y_9520 MG1_X_6720_Y_9520 0 8.4856e-18
C_MG1_X_6720_Y_9945 MG1_X_6720_Y_9945 0 7.5764e-18
C_MG1_X_6988_Y_0 MG1_X_6988_Y_0 0 8.4856e-18
C_MG1_X_6988_Y_10000 MG1_X_6988_Y_10000 0 5.1015e-18
C_MG1_X_6988_Y_1075 MG1_X_6988_Y_1075 0 8.8392e-18
C_MG1_X_6988_Y_1120 MG1_X_6988_Y_1120 0 8.4856e-18
C_MG1_X_6988_Y_1612 MG1_X_6988_Y_1612 0 8.8392e-18
C_MG1_X_6988_Y_1680 MG1_X_6988_Y_1680 0 8.4856e-18
C_MG1_X_6988_Y_2150 MG1_X_6988_Y_2150 0 8.8392e-18
C_MG1_X_6988_Y_2240 MG1_X_6988_Y_2240 0 8.4856e-18
C_MG1_X_6988_Y_2688 MG1_X_6988_Y_2688 0 8.8392e-18
C_MG1_X_6988_Y_2800 MG1_X_6988_Y_2800 0 8.4856e-18
C_MG1_X_6988_Y_3225 MG1_X_6988_Y_3225 0 8.8392e-18
C_MG1_X_6988_Y_3360 MG1_X_6988_Y_3360 0 8.4856e-18
C_MG1_X_6988_Y_3763 MG1_X_6988_Y_3763 0 8.8392e-18
C_MG1_X_6988_Y_3920 MG1_X_6988_Y_3920 0 8.4856e-18
C_MG1_X_6988_Y_4300 MG1_X_6988_Y_4300 0 8.8392e-18
C_MG1_X_6988_Y_4480 MG1_X_6988_Y_4480 0 8.4856e-18
C_MG1_X_6988_Y_4838 MG1_X_6988_Y_4838 0 8.8392e-18
C_MG1_X_6988_Y_5040 MG1_X_6988_Y_5040 0 8.4856e-18
C_MG1_X_6988_Y_537 MG1_X_6988_Y_537 0 8.8392e-18
C_MG1_X_6988_Y_5376 MG1_X_6988_Y_5376 0 8.8392e-18
C_MG1_X_6988_Y_560 MG1_X_6988_Y_560 0 8.4856e-18
C_MG1_X_6988_Y_5600 MG1_X_6988_Y_5600 0 8.4856e-18
C_MG1_X_6988_Y_5913 MG1_X_6988_Y_5913 0 8.8392e-18
C_MG1_X_6988_Y_6160 MG1_X_6988_Y_6160 0 8.4856e-18
C_MG1_X_6988_Y_6451 MG1_X_6988_Y_6451 0 8.8392e-18
C_MG1_X_6988_Y_6720 MG1_X_6988_Y_6720 0 8.4856e-18
C_MG1_X_6988_Y_6988 MG1_X_6988_Y_6988 0 8.8392e-18
C_MG1_X_6988_Y_7280 MG1_X_6988_Y_7280 0 8.4856e-18
C_MG1_X_6988_Y_7526 MG1_X_6988_Y_7526 0 8.8392e-18
C_MG1_X_6988_Y_7840 MG1_X_6988_Y_7840 0 8.4856e-18
C_MG1_X_6988_Y_8064 MG1_X_6988_Y_8064 0 8.8392e-18
C_MG1_X_6988_Y_8400 MG1_X_6988_Y_8400 0 8.4856e-18
C_MG1_X_6988_Y_8601 MG1_X_6988_Y_8601 0 8.8392e-18
C_MG1_X_6988_Y_8960 MG1_X_6988_Y_8960 0 8.4856e-18
C_MG1_X_6988_Y_9139 MG1_X_6988_Y_9139 0 8.8392e-18
C_MG1_X_6988_Y_9520 MG1_X_6988_Y_9520 0 8.4856e-18
C_MG1_X_6988_Y_9676 MG1_X_6988_Y_9676 0 7.5764e-18
C_MG1_X_7257_Y_0 MG1_X_7257_Y_0 0 4.2428e-18
C_MG1_X_7257_Y_10000 MG1_X_7257_Y_10000 0 8.5866e-19
C_MG1_X_7257_Y_1120 MG1_X_7257_Y_1120 0 8.4856e-18
C_MG1_X_7257_Y_1344 MG1_X_7257_Y_1344 0 8.8392e-18
C_MG1_X_7257_Y_1680 MG1_X_7257_Y_1680 0 8.4856e-18
C_MG1_X_7257_Y_1881 MG1_X_7257_Y_1881 0 8.8392e-18
C_MG1_X_7257_Y_2240 MG1_X_7257_Y_2240 0 8.4856e-18
C_MG1_X_7257_Y_2419 MG1_X_7257_Y_2419 0 8.8392e-18
C_MG1_X_7257_Y_268 MG1_X_7257_Y_268 0 8.8392e-18
C_MG1_X_7257_Y_2800 MG1_X_7257_Y_2800 0 8.4856e-18
C_MG1_X_7257_Y_2956 MG1_X_7257_Y_2956 0 8.8392e-18
C_MG1_X_7257_Y_3360 MG1_X_7257_Y_3360 0 8.4856e-18
C_MG1_X_7257_Y_3494 MG1_X_7257_Y_3494 0 8.8392e-18
C_MG1_X_7257_Y_3920 MG1_X_7257_Y_3920 0 8.4856e-18
C_MG1_X_7257_Y_4032 MG1_X_7257_Y_4032 0 8.8392e-18
C_MG1_X_7257_Y_4480 MG1_X_7257_Y_4480 0 8.4856e-18
C_MG1_X_7257_Y_4569 MG1_X_7257_Y_4569 0 8.8392e-18
C_MG1_X_7257_Y_5040 MG1_X_7257_Y_5040 0 8.4856e-18
C_MG1_X_7257_Y_5107 MG1_X_7257_Y_5107 0 8.8392e-18
C_MG1_X_7257_Y_560 MG1_X_7257_Y_560 0 8.4856e-18
C_MG1_X_7257_Y_5600 MG1_X_7257_Y_5600 0 8.4856e-18
C_MG1_X_7257_Y_5644 MG1_X_7257_Y_5644 0 8.8392e-18
C_MG1_X_7257_Y_6160 MG1_X_7257_Y_6160 0 8.4856e-18
C_MG1_X_7257_Y_6182 MG1_X_7257_Y_6182 0 8.8392e-18
C_MG1_X_7257_Y_6720 MG1_X_7257_Y_6720 0 1.6971e-17
C_MG1_X_7257_Y_7257 MG1_X_7257_Y_7257 0 8.8392e-18
C_MG1_X_7257_Y_7280 MG1_X_7257_Y_7280 0 8.4856e-18
C_MG1_X_7257_Y_7795 MG1_X_7257_Y_7795 0 8.8392e-18
C_MG1_X_7257_Y_7840 MG1_X_7257_Y_7840 0 8.4856e-18
C_MG1_X_7257_Y_806 MG1_X_7257_Y_806 0 8.8392e-18
C_MG1_X_7257_Y_8332 MG1_X_7257_Y_8332 0 8.8392e-18
C_MG1_X_7257_Y_8400 MG1_X_7257_Y_8400 0 8.4856e-18
C_MG1_X_7257_Y_8870 MG1_X_7257_Y_8870 0 8.8392e-18
C_MG1_X_7257_Y_8960 MG1_X_7257_Y_8960 0 8.4856e-18
C_MG1_X_7257_Y_9408 MG1_X_7257_Y_9408 0 8.8392e-18
C_MG1_X_7257_Y_9520 MG1_X_7257_Y_9520 0 8.4856e-18
C_MG1_X_7257_Y_9945 MG1_X_7257_Y_9945 0 7.5764e-18
C_MG1_X_7526_Y_0 MG1_X_7526_Y_0 0 8.4856e-18
C_MG1_X_7526_Y_10000 MG1_X_7526_Y_10000 0 5.1015e-18
C_MG1_X_7526_Y_1075 MG1_X_7526_Y_1075 0 8.8392e-18
C_MG1_X_7526_Y_1120 MG1_X_7526_Y_1120 0 8.4856e-18
C_MG1_X_7526_Y_1612 MG1_X_7526_Y_1612 0 8.8392e-18
C_MG1_X_7526_Y_1680 MG1_X_7526_Y_1680 0 8.4856e-18
C_MG1_X_7526_Y_2150 MG1_X_7526_Y_2150 0 8.8392e-18
C_MG1_X_7526_Y_2240 MG1_X_7526_Y_2240 0 8.4856e-18
C_MG1_X_7526_Y_2688 MG1_X_7526_Y_2688 0 8.8392e-18
C_MG1_X_7526_Y_2800 MG1_X_7526_Y_2800 0 8.4856e-18
C_MG1_X_7526_Y_3225 MG1_X_7526_Y_3225 0 8.8392e-18
C_MG1_X_7526_Y_3360 MG1_X_7526_Y_3360 0 8.4856e-18
C_MG1_X_7526_Y_3763 MG1_X_7526_Y_3763 0 8.8392e-18
C_MG1_X_7526_Y_3920 MG1_X_7526_Y_3920 0 8.4856e-18
C_MG1_X_7526_Y_4300 MG1_X_7526_Y_4300 0 8.8392e-18
C_MG1_X_7526_Y_4480 MG1_X_7526_Y_4480 0 8.4856e-18
C_MG1_X_7526_Y_4838 MG1_X_7526_Y_4838 0 8.8392e-18
C_MG1_X_7526_Y_5040 MG1_X_7526_Y_5040 0 8.4856e-18
C_MG1_X_7526_Y_537 MG1_X_7526_Y_537 0 8.8392e-18
C_MG1_X_7526_Y_5376 MG1_X_7526_Y_5376 0 8.8392e-18
C_MG1_X_7526_Y_560 MG1_X_7526_Y_560 0 8.4856e-18
C_MG1_X_7526_Y_5600 MG1_X_7526_Y_5600 0 8.4856e-18
C_MG1_X_7526_Y_5913 MG1_X_7526_Y_5913 0 8.8392e-18
C_MG1_X_7526_Y_6160 MG1_X_7526_Y_6160 0 8.4856e-18
C_MG1_X_7526_Y_6451 MG1_X_7526_Y_6451 0 8.8392e-18
C_MG1_X_7526_Y_6720 MG1_X_7526_Y_6720 0 8.4856e-18
C_MG1_X_7526_Y_6988 MG1_X_7526_Y_6988 0 8.8392e-18
C_MG1_X_7526_Y_7280 MG1_X_7526_Y_7280 0 8.4856e-18
C_MG1_X_7526_Y_7526 MG1_X_7526_Y_7526 0 8.8392e-18
C_MG1_X_7526_Y_7840 MG1_X_7526_Y_7840 0 8.4856e-18
C_MG1_X_7526_Y_8064 MG1_X_7526_Y_8064 0 8.8392e-18
C_MG1_X_7526_Y_8400 MG1_X_7526_Y_8400 0 8.4856e-18
C_MG1_X_7526_Y_8601 MG1_X_7526_Y_8601 0 8.8392e-18
C_MG1_X_7526_Y_8960 MG1_X_7526_Y_8960 0 8.4856e-18
C_MG1_X_7526_Y_9139 MG1_X_7526_Y_9139 0 8.8392e-18
C_MG1_X_7526_Y_9520 MG1_X_7526_Y_9520 0 8.4856e-18
C_MG1_X_7526_Y_9676 MG1_X_7526_Y_9676 0 7.5764e-18
C_MG1_X_7795_Y_0 MG1_X_7795_Y_0 0 4.2428e-18
C_MG1_X_7795_Y_10000 MG1_X_7795_Y_10000 0 8.5866e-19
C_MG1_X_7795_Y_1120 MG1_X_7795_Y_1120 0 8.4856e-18
C_MG1_X_7795_Y_1344 MG1_X_7795_Y_1344 0 8.8392e-18
C_MG1_X_7795_Y_1680 MG1_X_7795_Y_1680 0 8.4856e-18
C_MG1_X_7795_Y_1881 MG1_X_7795_Y_1881 0 8.8392e-18
C_MG1_X_7795_Y_2240 MG1_X_7795_Y_2240 0 8.4856e-18
C_MG1_X_7795_Y_2419 MG1_X_7795_Y_2419 0 8.8392e-18
C_MG1_X_7795_Y_268 MG1_X_7795_Y_268 0 8.8392e-18
C_MG1_X_7795_Y_2800 MG1_X_7795_Y_2800 0 8.4856e-18
C_MG1_X_7795_Y_2956 MG1_X_7795_Y_2956 0 8.8392e-18
C_MG1_X_7795_Y_3360 MG1_X_7795_Y_3360 0 8.4856e-18
C_MG1_X_7795_Y_3494 MG1_X_7795_Y_3494 0 8.8392e-18
C_MG1_X_7795_Y_3920 MG1_X_7795_Y_3920 0 8.4856e-18
C_MG1_X_7795_Y_4032 MG1_X_7795_Y_4032 0 8.8392e-18
C_MG1_X_7795_Y_4480 MG1_X_7795_Y_4480 0 8.4856e-18
C_MG1_X_7795_Y_4569 MG1_X_7795_Y_4569 0 8.8392e-18
C_MG1_X_7795_Y_5040 MG1_X_7795_Y_5040 0 8.4856e-18
C_MG1_X_7795_Y_5107 MG1_X_7795_Y_5107 0 8.8392e-18
C_MG1_X_7795_Y_560 MG1_X_7795_Y_560 0 8.4856e-18
C_MG1_X_7795_Y_5600 MG1_X_7795_Y_5600 0 8.4856e-18
C_MG1_X_7795_Y_5644 MG1_X_7795_Y_5644 0 8.8392e-18
C_MG1_X_7795_Y_6160 MG1_X_7795_Y_6160 0 8.4856e-18
C_MG1_X_7795_Y_6182 MG1_X_7795_Y_6182 0 8.8392e-18
C_MG1_X_7795_Y_6720 MG1_X_7795_Y_6720 0 1.6971e-17
C_MG1_X_7795_Y_7257 MG1_X_7795_Y_7257 0 8.8392e-18
C_MG1_X_7795_Y_7280 MG1_X_7795_Y_7280 0 8.4856e-18
C_MG1_X_7795_Y_7795 MG1_X_7795_Y_7795 0 8.8392e-18
C_MG1_X_7795_Y_7840 MG1_X_7795_Y_7840 0 8.4856e-18
C_MG1_X_7795_Y_806 MG1_X_7795_Y_806 0 8.8392e-18
C_MG1_X_7795_Y_8332 MG1_X_7795_Y_8332 0 8.8392e-18
C_MG1_X_7795_Y_8400 MG1_X_7795_Y_8400 0 8.4856e-18
C_MG1_X_7795_Y_8870 MG1_X_7795_Y_8870 0 8.8392e-18
C_MG1_X_7795_Y_8960 MG1_X_7795_Y_8960 0 8.4856e-18
C_MG1_X_7795_Y_9408 MG1_X_7795_Y_9408 0 8.8392e-18
C_MG1_X_7795_Y_9520 MG1_X_7795_Y_9520 0 8.4856e-18
C_MG1_X_7795_Y_9945 MG1_X_7795_Y_9945 0 7.5764e-18
C_MG1_X_8064_Y_0 MG1_X_8064_Y_0 0 8.4856e-18
C_MG1_X_8064_Y_10000 MG1_X_8064_Y_10000 0 5.1015e-18
C_MG1_X_8064_Y_1075 MG1_X_8064_Y_1075 0 8.8392e-18
C_MG1_X_8064_Y_1120 MG1_X_8064_Y_1120 0 8.4856e-18
C_MG1_X_8064_Y_1612 MG1_X_8064_Y_1612 0 8.8392e-18
C_MG1_X_8064_Y_1680 MG1_X_8064_Y_1680 0 8.4856e-18
C_MG1_X_8064_Y_2150 MG1_X_8064_Y_2150 0 8.8392e-18
C_MG1_X_8064_Y_2240 MG1_X_8064_Y_2240 0 8.4856e-18
C_MG1_X_8064_Y_2688 MG1_X_8064_Y_2688 0 8.8392e-18
C_MG1_X_8064_Y_2800 MG1_X_8064_Y_2800 0 8.4856e-18
C_MG1_X_8064_Y_3225 MG1_X_8064_Y_3225 0 8.8392e-18
C_MG1_X_8064_Y_3360 MG1_X_8064_Y_3360 0 8.4856e-18
C_MG1_X_8064_Y_3763 MG1_X_8064_Y_3763 0 8.8392e-18
C_MG1_X_8064_Y_3920 MG1_X_8064_Y_3920 0 8.4856e-18
C_MG1_X_8064_Y_4300 MG1_X_8064_Y_4300 0 8.8392e-18
C_MG1_X_8064_Y_4480 MG1_X_8064_Y_4480 0 8.4856e-18
C_MG1_X_8064_Y_4838 MG1_X_8064_Y_4838 0 8.8392e-18
C_MG1_X_8064_Y_5040 MG1_X_8064_Y_5040 0 8.4856e-18
C_MG1_X_8064_Y_537 MG1_X_8064_Y_537 0 8.8392e-18
C_MG1_X_8064_Y_5376 MG1_X_8064_Y_5376 0 8.8392e-18
C_MG1_X_8064_Y_560 MG1_X_8064_Y_560 0 8.4856e-18
C_MG1_X_8064_Y_5600 MG1_X_8064_Y_5600 0 8.4856e-18
C_MG1_X_8064_Y_5913 MG1_X_8064_Y_5913 0 8.8392e-18
C_MG1_X_8064_Y_6160 MG1_X_8064_Y_6160 0 8.4856e-18
C_MG1_X_8064_Y_6451 MG1_X_8064_Y_6451 0 8.8392e-18
C_MG1_X_8064_Y_6720 MG1_X_8064_Y_6720 0 8.4856e-18
C_MG1_X_8064_Y_6988 MG1_X_8064_Y_6988 0 8.8392e-18
C_MG1_X_8064_Y_7280 MG1_X_8064_Y_7280 0 8.4856e-18
C_MG1_X_8064_Y_7526 MG1_X_8064_Y_7526 0 8.8392e-18
C_MG1_X_8064_Y_7840 MG1_X_8064_Y_7840 0 8.4856e-18
C_MG1_X_8064_Y_8064 MG1_X_8064_Y_8064 0 8.8392e-18
C_MG1_X_8064_Y_8400 MG1_X_8064_Y_8400 0 8.4856e-18
C_MG1_X_8064_Y_8601 MG1_X_8064_Y_8601 0 8.8392e-18
C_MG1_X_8064_Y_8960 MG1_X_8064_Y_8960 0 8.4856e-18
C_MG1_X_8064_Y_9139 MG1_X_8064_Y_9139 0 8.8392e-18
C_MG1_X_8064_Y_9520 MG1_X_8064_Y_9520 0 8.4856e-18
C_MG1_X_8064_Y_9676 MG1_X_8064_Y_9676 0 7.5764e-18
C_MG1_X_806_Y_0 MG1_X_806_Y_0 0 4.2428e-18
C_MG1_X_806_Y_10000 MG1_X_806_Y_10000 0 8.5866e-19
C_MG1_X_806_Y_1120 MG1_X_806_Y_1120 0 8.4856e-18
C_MG1_X_806_Y_1344 MG1_X_806_Y_1344 0 8.8392e-18
C_MG1_X_806_Y_1680 MG1_X_806_Y_1680 0 8.4856e-18
C_MG1_X_806_Y_1881 MG1_X_806_Y_1881 0 8.8392e-18
C_MG1_X_806_Y_2240 MG1_X_806_Y_2240 0 8.4856e-18
C_MG1_X_806_Y_2419 MG1_X_806_Y_2419 0 8.8392e-18
C_MG1_X_806_Y_268 MG1_X_806_Y_268 0 8.8392e-18
C_MG1_X_806_Y_2800 MG1_X_806_Y_2800 0 8.4856e-18
C_MG1_X_806_Y_2956 MG1_X_806_Y_2956 0 8.8392e-18
C_MG1_X_806_Y_3360 MG1_X_806_Y_3360 0 8.4856e-18
C_MG1_X_806_Y_3494 MG1_X_806_Y_3494 0 8.8392e-18
C_MG1_X_806_Y_3920 MG1_X_806_Y_3920 0 8.4856e-18
C_MG1_X_806_Y_4032 MG1_X_806_Y_4032 0 8.8392e-18
C_MG1_X_806_Y_4480 MG1_X_806_Y_4480 0 8.4856e-18
C_MG1_X_806_Y_4569 MG1_X_806_Y_4569 0 8.8392e-18
C_MG1_X_806_Y_5040 MG1_X_806_Y_5040 0 8.4856e-18
C_MG1_X_806_Y_5107 MG1_X_806_Y_5107 0 8.8392e-18
C_MG1_X_806_Y_560 MG1_X_806_Y_560 0 8.4856e-18
C_MG1_X_806_Y_5600 MG1_X_806_Y_5600 0 8.4856e-18
C_MG1_X_806_Y_5644 MG1_X_806_Y_5644 0 8.8392e-18
C_MG1_X_806_Y_6160 MG1_X_806_Y_6160 0 8.4856e-18
C_MG1_X_806_Y_6182 MG1_X_806_Y_6182 0 8.8392e-18
C_MG1_X_806_Y_6720 MG1_X_806_Y_6720 0 1.6971e-17
C_MG1_X_806_Y_7257 MG1_X_806_Y_7257 0 8.8392e-18
C_MG1_X_806_Y_7280 MG1_X_806_Y_7280 0 8.4856e-18
C_MG1_X_806_Y_7795 MG1_X_806_Y_7795 0 8.8392e-18
C_MG1_X_806_Y_7840 MG1_X_806_Y_7840 0 8.4856e-18
C_MG1_X_806_Y_806 MG1_X_806_Y_806 0 8.8392e-18
C_MG1_X_806_Y_8332 MG1_X_806_Y_8332 0 8.8392e-18
C_MG1_X_806_Y_8400 MG1_X_806_Y_8400 0 8.4856e-18
C_MG1_X_806_Y_8870 MG1_X_806_Y_8870 0 8.8392e-18
C_MG1_X_806_Y_8960 MG1_X_806_Y_8960 0 8.4856e-18
C_MG1_X_806_Y_9408 MG1_X_806_Y_9408 0 8.8392e-18
C_MG1_X_806_Y_9520 MG1_X_806_Y_9520 0 8.4856e-18
C_MG1_X_806_Y_9945 MG1_X_806_Y_9945 0 7.5764e-18
C_MG1_X_8332_Y_0 MG1_X_8332_Y_0 0 4.2428e-18
C_MG1_X_8332_Y_10000 MG1_X_8332_Y_10000 0 8.5866e-19
C_MG1_X_8332_Y_1120 MG1_X_8332_Y_1120 0 8.4856e-18
C_MG1_X_8332_Y_1344 MG1_X_8332_Y_1344 0 8.8392e-18
C_MG1_X_8332_Y_1680 MG1_X_8332_Y_1680 0 8.4856e-18
C_MG1_X_8332_Y_1881 MG1_X_8332_Y_1881 0 8.8392e-18
C_MG1_X_8332_Y_2240 MG1_X_8332_Y_2240 0 8.4856e-18
C_MG1_X_8332_Y_2419 MG1_X_8332_Y_2419 0 8.8392e-18
C_MG1_X_8332_Y_268 MG1_X_8332_Y_268 0 8.8392e-18
C_MG1_X_8332_Y_2800 MG1_X_8332_Y_2800 0 8.4856e-18
C_MG1_X_8332_Y_2956 MG1_X_8332_Y_2956 0 8.8392e-18
C_MG1_X_8332_Y_3360 MG1_X_8332_Y_3360 0 8.4856e-18
C_MG1_X_8332_Y_3494 MG1_X_8332_Y_3494 0 8.8392e-18
C_MG1_X_8332_Y_3920 MG1_X_8332_Y_3920 0 8.4856e-18
C_MG1_X_8332_Y_4032 MG1_X_8332_Y_4032 0 8.8392e-18
C_MG1_X_8332_Y_4480 MG1_X_8332_Y_4480 0 8.4856e-18
C_MG1_X_8332_Y_4569 MG1_X_8332_Y_4569 0 8.8392e-18
C_MG1_X_8332_Y_5040 MG1_X_8332_Y_5040 0 8.4856e-18
C_MG1_X_8332_Y_5107 MG1_X_8332_Y_5107 0 8.8392e-18
C_MG1_X_8332_Y_560 MG1_X_8332_Y_560 0 8.4856e-18
C_MG1_X_8332_Y_5600 MG1_X_8332_Y_5600 0 8.4856e-18
C_MG1_X_8332_Y_5644 MG1_X_8332_Y_5644 0 8.8392e-18
C_MG1_X_8332_Y_6160 MG1_X_8332_Y_6160 0 8.4856e-18
C_MG1_X_8332_Y_6182 MG1_X_8332_Y_6182 0 8.8392e-18
C_MG1_X_8332_Y_6720 MG1_X_8332_Y_6720 0 1.6971e-17
C_MG1_X_8332_Y_7257 MG1_X_8332_Y_7257 0 8.8392e-18
C_MG1_X_8332_Y_7280 MG1_X_8332_Y_7280 0 8.4856e-18
C_MG1_X_8332_Y_7795 MG1_X_8332_Y_7795 0 8.8392e-18
C_MG1_X_8332_Y_7840 MG1_X_8332_Y_7840 0 8.4856e-18
C_MG1_X_8332_Y_806 MG1_X_8332_Y_806 0 8.8392e-18
C_MG1_X_8332_Y_8332 MG1_X_8332_Y_8332 0 8.8392e-18
C_MG1_X_8332_Y_8400 MG1_X_8332_Y_8400 0 8.4856e-18
C_MG1_X_8332_Y_8870 MG1_X_8332_Y_8870 0 8.8392e-18
C_MG1_X_8332_Y_8960 MG1_X_8332_Y_8960 0 8.4856e-18
C_MG1_X_8332_Y_9408 MG1_X_8332_Y_9408 0 8.8392e-18
C_MG1_X_8332_Y_9520 MG1_X_8332_Y_9520 0 8.4856e-18
C_MG1_X_8332_Y_9945 MG1_X_8332_Y_9945 0 7.5764e-18
C_MG1_X_8601_Y_0 MG1_X_8601_Y_0 0 8.4856e-18
C_MG1_X_8601_Y_10000 MG1_X_8601_Y_10000 0 5.1015e-18
C_MG1_X_8601_Y_1075 MG1_X_8601_Y_1075 0 8.8392e-18
C_MG1_X_8601_Y_1120 MG1_X_8601_Y_1120 0 8.4856e-18
C_MG1_X_8601_Y_1612 MG1_X_8601_Y_1612 0 8.8392e-18
C_MG1_X_8601_Y_1680 MG1_X_8601_Y_1680 0 8.4856e-18
C_MG1_X_8601_Y_2150 MG1_X_8601_Y_2150 0 8.8392e-18
C_MG1_X_8601_Y_2240 MG1_X_8601_Y_2240 0 8.4856e-18
C_MG1_X_8601_Y_2688 MG1_X_8601_Y_2688 0 8.8392e-18
C_MG1_X_8601_Y_2800 MG1_X_8601_Y_2800 0 8.4856e-18
C_MG1_X_8601_Y_3225 MG1_X_8601_Y_3225 0 8.8392e-18
C_MG1_X_8601_Y_3360 MG1_X_8601_Y_3360 0 8.4856e-18
C_MG1_X_8601_Y_3763 MG1_X_8601_Y_3763 0 8.8392e-18
C_MG1_X_8601_Y_3920 MG1_X_8601_Y_3920 0 8.4856e-18
C_MG1_X_8601_Y_4300 MG1_X_8601_Y_4300 0 8.8392e-18
C_MG1_X_8601_Y_4480 MG1_X_8601_Y_4480 0 8.4856e-18
C_MG1_X_8601_Y_4838 MG1_X_8601_Y_4838 0 8.8392e-18
C_MG1_X_8601_Y_5040 MG1_X_8601_Y_5040 0 8.4856e-18
C_MG1_X_8601_Y_537 MG1_X_8601_Y_537 0 8.8392e-18
C_MG1_X_8601_Y_5376 MG1_X_8601_Y_5376 0 8.8392e-18
C_MG1_X_8601_Y_560 MG1_X_8601_Y_560 0 8.4856e-18
C_MG1_X_8601_Y_5600 MG1_X_8601_Y_5600 0 8.4856e-18
C_MG1_X_8601_Y_5913 MG1_X_8601_Y_5913 0 8.8392e-18
C_MG1_X_8601_Y_6160 MG1_X_8601_Y_6160 0 8.4856e-18
C_MG1_X_8601_Y_6451 MG1_X_8601_Y_6451 0 8.8392e-18
C_MG1_X_8601_Y_6720 MG1_X_8601_Y_6720 0 8.4856e-18
C_MG1_X_8601_Y_6988 MG1_X_8601_Y_6988 0 8.8392e-18
C_MG1_X_8601_Y_7280 MG1_X_8601_Y_7280 0 8.4856e-18
C_MG1_X_8601_Y_7526 MG1_X_8601_Y_7526 0 8.8392e-18
C_MG1_X_8601_Y_7840 MG1_X_8601_Y_7840 0 8.4856e-18
C_MG1_X_8601_Y_8064 MG1_X_8601_Y_8064 0 8.8392e-18
C_MG1_X_8601_Y_8400 MG1_X_8601_Y_8400 0 8.4856e-18
C_MG1_X_8601_Y_8601 MG1_X_8601_Y_8601 0 8.8392e-18
C_MG1_X_8601_Y_8960 MG1_X_8601_Y_8960 0 8.4856e-18
C_MG1_X_8601_Y_9139 MG1_X_8601_Y_9139 0 8.8392e-18
C_MG1_X_8601_Y_9520 MG1_X_8601_Y_9520 0 8.4856e-18
C_MG1_X_8601_Y_9676 MG1_X_8601_Y_9676 0 7.5764e-18
C_MG1_X_8870_Y_0 MG1_X_8870_Y_0 0 4.2428e-18
C_MG1_X_8870_Y_10000 MG1_X_8870_Y_10000 0 8.5866e-19
C_MG1_X_8870_Y_1120 MG1_X_8870_Y_1120 0 8.4856e-18
C_MG1_X_8870_Y_1344 MG1_X_8870_Y_1344 0 8.8392e-18
C_MG1_X_8870_Y_1680 MG1_X_8870_Y_1680 0 8.4856e-18
C_MG1_X_8870_Y_1881 MG1_X_8870_Y_1881 0 8.8392e-18
C_MG1_X_8870_Y_2240 MG1_X_8870_Y_2240 0 8.4856e-18
C_MG1_X_8870_Y_2419 MG1_X_8870_Y_2419 0 8.8392e-18
C_MG1_X_8870_Y_268 MG1_X_8870_Y_268 0 8.8392e-18
C_MG1_X_8870_Y_2800 MG1_X_8870_Y_2800 0 8.4856e-18
C_MG1_X_8870_Y_2956 MG1_X_8870_Y_2956 0 8.8392e-18
C_MG1_X_8870_Y_3360 MG1_X_8870_Y_3360 0 8.4856e-18
C_MG1_X_8870_Y_3494 MG1_X_8870_Y_3494 0 8.8392e-18
C_MG1_X_8870_Y_3920 MG1_X_8870_Y_3920 0 8.4856e-18
C_MG1_X_8870_Y_4032 MG1_X_8870_Y_4032 0 8.8392e-18
C_MG1_X_8870_Y_4480 MG1_X_8870_Y_4480 0 8.4856e-18
C_MG1_X_8870_Y_4569 MG1_X_8870_Y_4569 0 8.8392e-18
C_MG1_X_8870_Y_5040 MG1_X_8870_Y_5040 0 8.4856e-18
C_MG1_X_8870_Y_5107 MG1_X_8870_Y_5107 0 8.8392e-18
C_MG1_X_8870_Y_560 MG1_X_8870_Y_560 0 8.4856e-18
C_MG1_X_8870_Y_5600 MG1_X_8870_Y_5600 0 8.4856e-18
C_MG1_X_8870_Y_5644 MG1_X_8870_Y_5644 0 8.8392e-18
C_MG1_X_8870_Y_6160 MG1_X_8870_Y_6160 0 8.4856e-18
C_MG1_X_8870_Y_6182 MG1_X_8870_Y_6182 0 8.8392e-18
C_MG1_X_8870_Y_6720 MG1_X_8870_Y_6720 0 1.6971e-17
C_MG1_X_8870_Y_7257 MG1_X_8870_Y_7257 0 8.8392e-18
C_MG1_X_8870_Y_7280 MG1_X_8870_Y_7280 0 8.4856e-18
C_MG1_X_8870_Y_7795 MG1_X_8870_Y_7795 0 8.8392e-18
C_MG1_X_8870_Y_7840 MG1_X_8870_Y_7840 0 8.4856e-18
C_MG1_X_8870_Y_806 MG1_X_8870_Y_806 0 8.8392e-18
C_MG1_X_8870_Y_8332 MG1_X_8870_Y_8332 0 8.8392e-18
C_MG1_X_8870_Y_8400 MG1_X_8870_Y_8400 0 8.4856e-18
C_MG1_X_8870_Y_8870 MG1_X_8870_Y_8870 0 8.8392e-18
C_MG1_X_8870_Y_8960 MG1_X_8870_Y_8960 0 8.4856e-18
C_MG1_X_8870_Y_9408 MG1_X_8870_Y_9408 0 8.8392e-18
C_MG1_X_8870_Y_9520 MG1_X_8870_Y_9520 0 8.4856e-18
C_MG1_X_8870_Y_9945 MG1_X_8870_Y_9945 0 7.5764e-18
C_MG1_X_9139_Y_0 MG1_X_9139_Y_0 0 8.4856e-18
C_MG1_X_9139_Y_10000 MG1_X_9139_Y_10000 0 5.1015e-18
C_MG1_X_9139_Y_1075 MG1_X_9139_Y_1075 0 8.8392e-18
C_MG1_X_9139_Y_1120 MG1_X_9139_Y_1120 0 8.4856e-18
C_MG1_X_9139_Y_1612 MG1_X_9139_Y_1612 0 8.8392e-18
C_MG1_X_9139_Y_1680 MG1_X_9139_Y_1680 0 8.4856e-18
C_MG1_X_9139_Y_2150 MG1_X_9139_Y_2150 0 8.8392e-18
C_MG1_X_9139_Y_2240 MG1_X_9139_Y_2240 0 8.4856e-18
C_MG1_X_9139_Y_2688 MG1_X_9139_Y_2688 0 8.8392e-18
C_MG1_X_9139_Y_2800 MG1_X_9139_Y_2800 0 8.4856e-18
C_MG1_X_9139_Y_3225 MG1_X_9139_Y_3225 0 8.8392e-18
C_MG1_X_9139_Y_3360 MG1_X_9139_Y_3360 0 8.4856e-18
C_MG1_X_9139_Y_3763 MG1_X_9139_Y_3763 0 8.8392e-18
C_MG1_X_9139_Y_3920 MG1_X_9139_Y_3920 0 8.4856e-18
C_MG1_X_9139_Y_4300 MG1_X_9139_Y_4300 0 8.8392e-18
C_MG1_X_9139_Y_4480 MG1_X_9139_Y_4480 0 8.4856e-18
C_MG1_X_9139_Y_4838 MG1_X_9139_Y_4838 0 8.8392e-18
C_MG1_X_9139_Y_5040 MG1_X_9139_Y_5040 0 8.4856e-18
C_MG1_X_9139_Y_537 MG1_X_9139_Y_537 0 8.8392e-18
C_MG1_X_9139_Y_5376 MG1_X_9139_Y_5376 0 8.8392e-18
C_MG1_X_9139_Y_560 MG1_X_9139_Y_560 0 8.4856e-18
C_MG1_X_9139_Y_5600 MG1_X_9139_Y_5600 0 8.4856e-18
C_MG1_X_9139_Y_5913 MG1_X_9139_Y_5913 0 8.8392e-18
C_MG1_X_9139_Y_6160 MG1_X_9139_Y_6160 0 8.4856e-18
C_MG1_X_9139_Y_6451 MG1_X_9139_Y_6451 0 8.8392e-18
C_MG1_X_9139_Y_6720 MG1_X_9139_Y_6720 0 8.4856e-18
C_MG1_X_9139_Y_6988 MG1_X_9139_Y_6988 0 8.8392e-18
C_MG1_X_9139_Y_7280 MG1_X_9139_Y_7280 0 8.4856e-18
C_MG1_X_9139_Y_7526 MG1_X_9139_Y_7526 0 8.8392e-18
C_MG1_X_9139_Y_7840 MG1_X_9139_Y_7840 0 8.4856e-18
C_MG1_X_9139_Y_8064 MG1_X_9139_Y_8064 0 8.8392e-18
C_MG1_X_9139_Y_8400 MG1_X_9139_Y_8400 0 8.4856e-18
C_MG1_X_9139_Y_8601 MG1_X_9139_Y_8601 0 8.8392e-18
C_MG1_X_9139_Y_8960 MG1_X_9139_Y_8960 0 8.4856e-18
C_MG1_X_9139_Y_9139 MG1_X_9139_Y_9139 0 8.8392e-18
C_MG1_X_9139_Y_9520 MG1_X_9139_Y_9520 0 8.4856e-18
C_MG1_X_9139_Y_9676 MG1_X_9139_Y_9676 0 7.5764e-18
C_MG1_X_9408_Y_0 MG1_X_9408_Y_0 0 4.2428e-18
C_MG1_X_9408_Y_10000 MG1_X_9408_Y_10000 0 8.5866e-19
C_MG1_X_9408_Y_1120 MG1_X_9408_Y_1120 0 8.4856e-18
C_MG1_X_9408_Y_1344 MG1_X_9408_Y_1344 0 8.8392e-18
C_MG1_X_9408_Y_1680 MG1_X_9408_Y_1680 0 8.4856e-18
C_MG1_X_9408_Y_1881 MG1_X_9408_Y_1881 0 8.8392e-18
C_MG1_X_9408_Y_2240 MG1_X_9408_Y_2240 0 8.4856e-18
C_MG1_X_9408_Y_2419 MG1_X_9408_Y_2419 0 8.8392e-18
C_MG1_X_9408_Y_268 MG1_X_9408_Y_268 0 8.8392e-18
C_MG1_X_9408_Y_2800 MG1_X_9408_Y_2800 0 8.4856e-18
C_MG1_X_9408_Y_2956 MG1_X_9408_Y_2956 0 8.8392e-18
C_MG1_X_9408_Y_3360 MG1_X_9408_Y_3360 0 8.4856e-18
C_MG1_X_9408_Y_3494 MG1_X_9408_Y_3494 0 8.8392e-18
C_MG1_X_9408_Y_3920 MG1_X_9408_Y_3920 0 8.4856e-18
C_MG1_X_9408_Y_4032 MG1_X_9408_Y_4032 0 8.8392e-18
C_MG1_X_9408_Y_4480 MG1_X_9408_Y_4480 0 8.4856e-18
C_MG1_X_9408_Y_4569 MG1_X_9408_Y_4569 0 8.8392e-18
C_MG1_X_9408_Y_5040 MG1_X_9408_Y_5040 0 8.4856e-18
C_MG1_X_9408_Y_5107 MG1_X_9408_Y_5107 0 8.8392e-18
C_MG1_X_9408_Y_560 MG1_X_9408_Y_560 0 8.4856e-18
C_MG1_X_9408_Y_5600 MG1_X_9408_Y_5600 0 8.4856e-18
C_MG1_X_9408_Y_5644 MG1_X_9408_Y_5644 0 8.8392e-18
C_MG1_X_9408_Y_6160 MG1_X_9408_Y_6160 0 8.4856e-18
C_MG1_X_9408_Y_6182 MG1_X_9408_Y_6182 0 8.8392e-18
C_MG1_X_9408_Y_6720 MG1_X_9408_Y_6720 0 1.6971e-17
C_MG1_X_9408_Y_7257 MG1_X_9408_Y_7257 0 8.8392e-18
C_MG1_X_9408_Y_7280 MG1_X_9408_Y_7280 0 8.4856e-18
C_MG1_X_9408_Y_7795 MG1_X_9408_Y_7795 0 8.8392e-18
C_MG1_X_9408_Y_7840 MG1_X_9408_Y_7840 0 8.4856e-18
C_MG1_X_9408_Y_806 MG1_X_9408_Y_806 0 8.8392e-18
C_MG1_X_9408_Y_8332 MG1_X_9408_Y_8332 0 8.8392e-18
C_MG1_X_9408_Y_8400 MG1_X_9408_Y_8400 0 8.4856e-18
C_MG1_X_9408_Y_8870 MG1_X_9408_Y_8870 0 8.8392e-18
C_MG1_X_9408_Y_8960 MG1_X_9408_Y_8960 0 8.4856e-18
C_MG1_X_9408_Y_9408 MG1_X_9408_Y_9408 0 8.8392e-18
C_MG1_X_9408_Y_9520 MG1_X_9408_Y_9520 0 8.4856e-18
C_MG1_X_9408_Y_9945 MG1_X_9408_Y_9945 0 7.5764e-18
C_MG1_X_9676_Y_0 MG1_X_9676_Y_0 0 8.4856e-18
C_MG1_X_9676_Y_10000 MG1_X_9676_Y_10000 0 5.1015e-18
C_MG1_X_9676_Y_1075 MG1_X_9676_Y_1075 0 8.8392e-18
C_MG1_X_9676_Y_1120 MG1_X_9676_Y_1120 0 8.4856e-18
C_MG1_X_9676_Y_1612 MG1_X_9676_Y_1612 0 8.8392e-18
C_MG1_X_9676_Y_1680 MG1_X_9676_Y_1680 0 8.4856e-18
C_MG1_X_9676_Y_2150 MG1_X_9676_Y_2150 0 8.8392e-18
C_MG1_X_9676_Y_2240 MG1_X_9676_Y_2240 0 8.4856e-18
C_MG1_X_9676_Y_2688 MG1_X_9676_Y_2688 0 8.8392e-18
C_MG1_X_9676_Y_2800 MG1_X_9676_Y_2800 0 8.4856e-18
C_MG1_X_9676_Y_3225 MG1_X_9676_Y_3225 0 8.8392e-18
C_MG1_X_9676_Y_3360 MG1_X_9676_Y_3360 0 8.4856e-18
C_MG1_X_9676_Y_3763 MG1_X_9676_Y_3763 0 8.8392e-18
C_MG1_X_9676_Y_3920 MG1_X_9676_Y_3920 0 8.4856e-18
C_MG1_X_9676_Y_4300 MG1_X_9676_Y_4300 0 8.8392e-18
C_MG1_X_9676_Y_4480 MG1_X_9676_Y_4480 0 8.4856e-18
C_MG1_X_9676_Y_4838 MG1_X_9676_Y_4838 0 8.8392e-18
C_MG1_X_9676_Y_5040 MG1_X_9676_Y_5040 0 8.4856e-18
C_MG1_X_9676_Y_537 MG1_X_9676_Y_537 0 8.8392e-18
C_MG1_X_9676_Y_5376 MG1_X_9676_Y_5376 0 8.8392e-18
C_MG1_X_9676_Y_560 MG1_X_9676_Y_560 0 8.4856e-18
C_MG1_X_9676_Y_5600 MG1_X_9676_Y_5600 0 8.4856e-18
C_MG1_X_9676_Y_5913 MG1_X_9676_Y_5913 0 8.8392e-18
C_MG1_X_9676_Y_6160 MG1_X_9676_Y_6160 0 8.4856e-18
C_MG1_X_9676_Y_6451 MG1_X_9676_Y_6451 0 8.8392e-18
C_MG1_X_9676_Y_6720 MG1_X_9676_Y_6720 0 8.4856e-18
C_MG1_X_9676_Y_6988 MG1_X_9676_Y_6988 0 8.8392e-18
C_MG1_X_9676_Y_7280 MG1_X_9676_Y_7280 0 8.4856e-18
C_MG1_X_9676_Y_7526 MG1_X_9676_Y_7526 0 8.8392e-18
C_MG1_X_9676_Y_7840 MG1_X_9676_Y_7840 0 8.4856e-18
C_MG1_X_9676_Y_8064 MG1_X_9676_Y_8064 0 8.8392e-18
C_MG1_X_9676_Y_8400 MG1_X_9676_Y_8400 0 8.4856e-18
C_MG1_X_9676_Y_8601 MG1_X_9676_Y_8601 0 8.8392e-18
C_MG1_X_9676_Y_8960 MG1_X_9676_Y_8960 0 8.4856e-18
C_MG1_X_9676_Y_9139 MG1_X_9676_Y_9139 0 8.8392e-18
C_MG1_X_9676_Y_9520 MG1_X_9676_Y_9520 0 8.4856e-18
C_MG1_X_9676_Y_9676 MG1_X_9676_Y_9676 0 7.5764e-18
C_MG1_X_9945_Y_0 MG1_X_9945_Y_0 0 4.2428e-18
C_MG1_X_9945_Y_10000 MG1_X_9945_Y_10000 0 8.5866e-19
C_MG1_X_9945_Y_1120 MG1_X_9945_Y_1120 0 8.4856e-18
C_MG1_X_9945_Y_1344 MG1_X_9945_Y_1344 0 8.8392e-18
C_MG1_X_9945_Y_1680 MG1_X_9945_Y_1680 0 8.4856e-18
C_MG1_X_9945_Y_1881 MG1_X_9945_Y_1881 0 8.8392e-18
C_MG1_X_9945_Y_2240 MG1_X_9945_Y_2240 0 8.4856e-18
C_MG1_X_9945_Y_2419 MG1_X_9945_Y_2419 0 8.8392e-18
C_MG1_X_9945_Y_268 MG1_X_9945_Y_268 0 8.8392e-18
C_MG1_X_9945_Y_2800 MG1_X_9945_Y_2800 0 8.4856e-18
C_MG1_X_9945_Y_2956 MG1_X_9945_Y_2956 0 8.8392e-18
C_MG1_X_9945_Y_3360 MG1_X_9945_Y_3360 0 8.4856e-18
C_MG1_X_9945_Y_3494 MG1_X_9945_Y_3494 0 8.8392e-18
C_MG1_X_9945_Y_3920 MG1_X_9945_Y_3920 0 8.4856e-18
C_MG1_X_9945_Y_4032 MG1_X_9945_Y_4032 0 8.8392e-18
C_MG1_X_9945_Y_4480 MG1_X_9945_Y_4480 0 8.4856e-18
C_MG1_X_9945_Y_4569 MG1_X_9945_Y_4569 0 8.8392e-18
C_MG1_X_9945_Y_5040 MG1_X_9945_Y_5040 0 8.4856e-18
C_MG1_X_9945_Y_5107 MG1_X_9945_Y_5107 0 8.8392e-18
C_MG1_X_9945_Y_560 MG1_X_9945_Y_560 0 8.4856e-18
C_MG1_X_9945_Y_5600 MG1_X_9945_Y_5600 0 8.4856e-18
C_MG1_X_9945_Y_5644 MG1_X_9945_Y_5644 0 8.8392e-18
C_MG1_X_9945_Y_6160 MG1_X_9945_Y_6160 0 8.4856e-18
C_MG1_X_9945_Y_6182 MG1_X_9945_Y_6182 0 8.8392e-18
C_MG1_X_9945_Y_6720 MG1_X_9945_Y_6720 0 1.6971e-17
C_MG1_X_9945_Y_7257 MG1_X_9945_Y_7257 0 8.8392e-18
C_MG1_X_9945_Y_7280 MG1_X_9945_Y_7280 0 8.4856e-18
C_MG1_X_9945_Y_7795 MG1_X_9945_Y_7795 0 8.8392e-18
C_MG1_X_9945_Y_7840 MG1_X_9945_Y_7840 0 8.4856e-18
C_MG1_X_9945_Y_806 MG1_X_9945_Y_806 0 8.8392e-18
C_MG1_X_9945_Y_8332 MG1_X_9945_Y_8332 0 8.8392e-18
C_MG1_X_9945_Y_8400 MG1_X_9945_Y_8400 0 8.4856e-18
C_MG1_X_9945_Y_8870 MG1_X_9945_Y_8870 0 8.8392e-18
C_MG1_X_9945_Y_8960 MG1_X_9945_Y_8960 0 8.4856e-18
C_MG1_X_9945_Y_9408 MG1_X_9945_Y_9408 0 8.8392e-18
C_MG1_X_9945_Y_9520 MG1_X_9945_Y_9520 0 8.4856e-18
C_MG1_X_9945_Y_9945 MG1_X_9945_Y_9945 0 7.5764e-18
C_MG2_X_0_Y_0 MG2_X_0_Y_0 0 7.7376e-18
C_MG2_X_0_Y_1075 MG2_X_0_Y_1075 0 7.7376e-18
C_MG2_X_0_Y_1344 MG2_X_0_Y_1344 0 3.8688e-18
C_MG2_X_0_Y_1612 MG2_X_0_Y_1612 0 7.7376e-18
C_MG2_X_0_Y_1881 MG2_X_0_Y_1881 0 3.8688e-18
C_MG2_X_0_Y_2150 MG2_X_0_Y_2150 0 7.7376e-18
C_MG2_X_0_Y_2419 MG2_X_0_Y_2419 0 3.8688e-18
C_MG2_X_0_Y_268 MG2_X_0_Y_268 0 3.8688e-18
C_MG2_X_0_Y_2688 MG2_X_0_Y_2688 0 7.7376e-18
C_MG2_X_0_Y_2956 MG2_X_0_Y_2956 0 3.8688e-18
C_MG2_X_0_Y_3225 MG2_X_0_Y_3225 0 7.7376e-18
C_MG2_X_0_Y_3494 MG2_X_0_Y_3494 0 3.8688e-18
C_MG2_X_0_Y_3763 MG2_X_0_Y_3763 0 7.7376e-18
C_MG2_X_0_Y_4032 MG2_X_0_Y_4032 0 3.8688e-18
C_MG2_X_0_Y_4300 MG2_X_0_Y_4300 0 7.7376e-18
C_MG2_X_0_Y_4569 MG2_X_0_Y_4569 0 3.8688e-18
C_MG2_X_0_Y_4838 MG2_X_0_Y_4838 0 7.7376e-18
C_MG2_X_0_Y_5107 MG2_X_0_Y_5107 0 3.8688e-18
C_MG2_X_0_Y_537 MG2_X_0_Y_537 0 7.7376e-18
C_MG2_X_0_Y_5376 MG2_X_0_Y_5376 0 7.7376e-18
C_MG2_X_0_Y_5644 MG2_X_0_Y_5644 0 3.8688e-18
C_MG2_X_0_Y_5913 MG2_X_0_Y_5913 0 7.7376e-18
C_MG2_X_0_Y_6182 MG2_X_0_Y_6182 0 3.8688e-18
C_MG2_X_0_Y_6451 MG2_X_0_Y_6451 0 7.7376e-18
C_MG2_X_0_Y_6720 MG2_X_0_Y_6720 0 3.8688e-18
C_MG2_X_0_Y_6988 MG2_X_0_Y_6988 0 7.7376e-18
C_MG2_X_0_Y_7257 MG2_X_0_Y_7257 0 3.8688e-18
C_MG2_X_0_Y_7526 MG2_X_0_Y_7526 0 7.7376e-18
C_MG2_X_0_Y_7795 MG2_X_0_Y_7795 0 3.8688e-18
C_MG2_X_0_Y_806 MG2_X_0_Y_806 0 3.8688e-18
C_MG2_X_0_Y_8064 MG2_X_0_Y_8064 0 7.7376e-18
C_MG2_X_0_Y_8332 MG2_X_0_Y_8332 0 3.8688e-18
C_MG2_X_0_Y_8601 MG2_X_0_Y_8601 0 7.7376e-18
C_MG2_X_0_Y_8870 MG2_X_0_Y_8870 0 3.8688e-18
C_MG2_X_0_Y_9139 MG2_X_0_Y_9139 0 7.7376e-18
C_MG2_X_0_Y_9408 MG2_X_0_Y_9408 0 3.8688e-18
C_MG2_X_0_Y_9676 MG2_X_0_Y_9676 0 7.7376e-18
C_MG2_X_0_Y_9945 MG2_X_0_Y_9945 0 3.8688e-18
C_MG2_X_10000_Y_0 MG2_X_10000_Y_0 0 4.6517e-18
C_MG2_X_10000_Y_1075 MG2_X_10000_Y_1075 0 4.6517e-18
C_MG2_X_10000_Y_1344 MG2_X_10000_Y_1344 0 7.8297e-19
C_MG2_X_10000_Y_1612 MG2_X_10000_Y_1612 0 4.6517e-18
C_MG2_X_10000_Y_1881 MG2_X_10000_Y_1881 0 7.8297e-19
C_MG2_X_10000_Y_2150 MG2_X_10000_Y_2150 0 4.6517e-18
C_MG2_X_10000_Y_2419 MG2_X_10000_Y_2419 0 7.8297e-19
C_MG2_X_10000_Y_268 MG2_X_10000_Y_268 0 7.8297e-19
C_MG2_X_10000_Y_2688 MG2_X_10000_Y_2688 0 4.6517e-18
C_MG2_X_10000_Y_2956 MG2_X_10000_Y_2956 0 7.8297e-19
C_MG2_X_10000_Y_3225 MG2_X_10000_Y_3225 0 4.6517e-18
C_MG2_X_10000_Y_3494 MG2_X_10000_Y_3494 0 7.8297e-19
C_MG2_X_10000_Y_3763 MG2_X_10000_Y_3763 0 4.6517e-18
C_MG2_X_10000_Y_4032 MG2_X_10000_Y_4032 0 7.8297e-19
C_MG2_X_10000_Y_4300 MG2_X_10000_Y_4300 0 4.6517e-18
C_MG2_X_10000_Y_4569 MG2_X_10000_Y_4569 0 7.8297e-19
C_MG2_X_10000_Y_4838 MG2_X_10000_Y_4838 0 4.6517e-18
C_MG2_X_10000_Y_5107 MG2_X_10000_Y_5107 0 7.8297e-19
C_MG2_X_10000_Y_537 MG2_X_10000_Y_537 0 4.6517e-18
C_MG2_X_10000_Y_5376 MG2_X_10000_Y_5376 0 4.6517e-18
C_MG2_X_10000_Y_5644 MG2_X_10000_Y_5644 0 7.8297e-19
C_MG2_X_10000_Y_5913 MG2_X_10000_Y_5913 0 4.6517e-18
C_MG2_X_10000_Y_6182 MG2_X_10000_Y_6182 0 7.8297e-19
C_MG2_X_10000_Y_6451 MG2_X_10000_Y_6451 0 4.6517e-18
C_MG2_X_10000_Y_6720 MG2_X_10000_Y_6720 0 7.8297e-19
C_MG2_X_10000_Y_6988 MG2_X_10000_Y_6988 0 4.6517e-18
C_MG2_X_10000_Y_7257 MG2_X_10000_Y_7257 0 7.8297e-19
C_MG2_X_10000_Y_7526 MG2_X_10000_Y_7526 0 4.6517e-18
C_MG2_X_10000_Y_7795 MG2_X_10000_Y_7795 0 7.8297e-19
C_MG2_X_10000_Y_806 MG2_X_10000_Y_806 0 7.8297e-19
C_MG2_X_10000_Y_8064 MG2_X_10000_Y_8064 0 4.6517e-18
C_MG2_X_10000_Y_8332 MG2_X_10000_Y_8332 0 7.8297e-19
C_MG2_X_10000_Y_8601 MG2_X_10000_Y_8601 0 4.6517e-18
C_MG2_X_10000_Y_8870 MG2_X_10000_Y_8870 0 7.8297e-19
C_MG2_X_10000_Y_9139 MG2_X_10000_Y_9139 0 4.6517e-18
C_MG2_X_10000_Y_9408 MG2_X_10000_Y_9408 0 7.8297e-19
C_MG2_X_10000_Y_9676 MG2_X_10000_Y_9676 0 4.6517e-18
C_MG2_X_10000_Y_9945 MG2_X_10000_Y_9945 0 7.8297e-19
C_MG2_X_1075_Y_0 MG2_X_1075_Y_0 0 1.5475e-17
C_MG2_X_1075_Y_1075 MG2_X_1075_Y_1075 0 1.5475e-17
C_MG2_X_1075_Y_1612 MG2_X_1075_Y_1612 0 1.5475e-17
C_MG2_X_1075_Y_2150 MG2_X_1075_Y_2150 0 1.5475e-17
C_MG2_X_1075_Y_2688 MG2_X_1075_Y_2688 0 1.5475e-17
C_MG2_X_1075_Y_3225 MG2_X_1075_Y_3225 0 1.5475e-17
C_MG2_X_1075_Y_3763 MG2_X_1075_Y_3763 0 1.5475e-17
C_MG2_X_1075_Y_4300 MG2_X_1075_Y_4300 0 1.5475e-17
C_MG2_X_1075_Y_4838 MG2_X_1075_Y_4838 0 1.5475e-17
C_MG2_X_1075_Y_537 MG2_X_1075_Y_537 0 1.5475e-17
C_MG2_X_1075_Y_5376 MG2_X_1075_Y_5376 0 1.5475e-17
C_MG2_X_1075_Y_5913 MG2_X_1075_Y_5913 0 1.5475e-17
C_MG2_X_1075_Y_6451 MG2_X_1075_Y_6451 0 1.5475e-17
C_MG2_X_1075_Y_6988 MG2_X_1075_Y_6988 0 1.5475e-17
C_MG2_X_1075_Y_7526 MG2_X_1075_Y_7526 0 1.5475e-17
C_MG2_X_1075_Y_8064 MG2_X_1075_Y_8064 0 1.5475e-17
C_MG2_X_1075_Y_8601 MG2_X_1075_Y_8601 0 1.5475e-17
C_MG2_X_1075_Y_9139 MG2_X_1075_Y_9139 0 1.5475e-17
C_MG2_X_1075_Y_9676 MG2_X_1075_Y_9676 0 1.5475e-17
C_MG2_X_1344_Y_1344 MG2_X_1344_Y_1344 0 1.5475e-17
C_MG2_X_1344_Y_1881 MG2_X_1344_Y_1881 0 1.5475e-17
C_MG2_X_1344_Y_2419 MG2_X_1344_Y_2419 0 1.5475e-17
C_MG2_X_1344_Y_268 MG2_X_1344_Y_268 0 1.5475e-17
C_MG2_X_1344_Y_2956 MG2_X_1344_Y_2956 0 1.5475e-17
C_MG2_X_1344_Y_3494 MG2_X_1344_Y_3494 0 1.5475e-17
C_MG2_X_1344_Y_4032 MG2_X_1344_Y_4032 0 1.5475e-17
C_MG2_X_1344_Y_4569 MG2_X_1344_Y_4569 0 1.5475e-17
C_MG2_X_1344_Y_5107 MG2_X_1344_Y_5107 0 1.5475e-17
C_MG2_X_1344_Y_5644 MG2_X_1344_Y_5644 0 1.5475e-17
C_MG2_X_1344_Y_6182 MG2_X_1344_Y_6182 0 1.5475e-17
C_MG2_X_1344_Y_6720 MG2_X_1344_Y_6720 0 1.5475e-17
C_MG2_X_1344_Y_7257 MG2_X_1344_Y_7257 0 1.5475e-17
C_MG2_X_1344_Y_7795 MG2_X_1344_Y_7795 0 1.5475e-17
C_MG2_X_1344_Y_806 MG2_X_1344_Y_806 0 1.5475e-17
C_MG2_X_1344_Y_8332 MG2_X_1344_Y_8332 0 1.5475e-17
C_MG2_X_1344_Y_8870 MG2_X_1344_Y_8870 0 1.5475e-17
C_MG2_X_1344_Y_9408 MG2_X_1344_Y_9408 0 1.5475e-17
C_MG2_X_1344_Y_9945 MG2_X_1344_Y_9945 0 1.5475e-17
C_MG2_X_1612_Y_0 MG2_X_1612_Y_0 0 1.5475e-17
C_MG2_X_1612_Y_1075 MG2_X_1612_Y_1075 0 1.5475e-17
C_MG2_X_1612_Y_1612 MG2_X_1612_Y_1612 0 1.5475e-17
C_MG2_X_1612_Y_2150 MG2_X_1612_Y_2150 0 1.5475e-17
C_MG2_X_1612_Y_2688 MG2_X_1612_Y_2688 0 1.5475e-17
C_MG2_X_1612_Y_3225 MG2_X_1612_Y_3225 0 1.5475e-17
C_MG2_X_1612_Y_3763 MG2_X_1612_Y_3763 0 1.5475e-17
C_MG2_X_1612_Y_4300 MG2_X_1612_Y_4300 0 1.5475e-17
C_MG2_X_1612_Y_4838 MG2_X_1612_Y_4838 0 1.5475e-17
C_MG2_X_1612_Y_537 MG2_X_1612_Y_537 0 1.5475e-17
C_MG2_X_1612_Y_5376 MG2_X_1612_Y_5376 0 1.5475e-17
C_MG2_X_1612_Y_5913 MG2_X_1612_Y_5913 0 1.5475e-17
C_MG2_X_1612_Y_6451 MG2_X_1612_Y_6451 0 1.5475e-17
C_MG2_X_1612_Y_6988 MG2_X_1612_Y_6988 0 1.5475e-17
C_MG2_X_1612_Y_7526 MG2_X_1612_Y_7526 0 1.5475e-17
C_MG2_X_1612_Y_8064 MG2_X_1612_Y_8064 0 1.5475e-17
C_MG2_X_1612_Y_8601 MG2_X_1612_Y_8601 0 1.5475e-17
C_MG2_X_1612_Y_9139 MG2_X_1612_Y_9139 0 1.5475e-17
C_MG2_X_1612_Y_9676 MG2_X_1612_Y_9676 0 1.5475e-17
C_MG2_X_1881_Y_1344 MG2_X_1881_Y_1344 0 1.5475e-17
C_MG2_X_1881_Y_1881 MG2_X_1881_Y_1881 0 1.5475e-17
C_MG2_X_1881_Y_2419 MG2_X_1881_Y_2419 0 1.5475e-17
C_MG2_X_1881_Y_268 MG2_X_1881_Y_268 0 1.5475e-17
C_MG2_X_1881_Y_2956 MG2_X_1881_Y_2956 0 1.5475e-17
C_MG2_X_1881_Y_3494 MG2_X_1881_Y_3494 0 1.5475e-17
C_MG2_X_1881_Y_4032 MG2_X_1881_Y_4032 0 1.5475e-17
C_MG2_X_1881_Y_4569 MG2_X_1881_Y_4569 0 1.5475e-17
C_MG2_X_1881_Y_5107 MG2_X_1881_Y_5107 0 1.5475e-17
C_MG2_X_1881_Y_5644 MG2_X_1881_Y_5644 0 1.5475e-17
C_MG2_X_1881_Y_6182 MG2_X_1881_Y_6182 0 1.5475e-17
C_MG2_X_1881_Y_6720 MG2_X_1881_Y_6720 0 1.5475e-17
C_MG2_X_1881_Y_7257 MG2_X_1881_Y_7257 0 1.5475e-17
C_MG2_X_1881_Y_7795 MG2_X_1881_Y_7795 0 1.5475e-17
C_MG2_X_1881_Y_806 MG2_X_1881_Y_806 0 1.5475e-17
C_MG2_X_1881_Y_8332 MG2_X_1881_Y_8332 0 1.5475e-17
C_MG2_X_1881_Y_8870 MG2_X_1881_Y_8870 0 1.5475e-17
C_MG2_X_1881_Y_9408 MG2_X_1881_Y_9408 0 1.5475e-17
C_MG2_X_1881_Y_9945 MG2_X_1881_Y_9945 0 1.5475e-17
C_MG2_X_2150_Y_0 MG2_X_2150_Y_0 0 1.5475e-17
C_MG2_X_2150_Y_1075 MG2_X_2150_Y_1075 0 1.5475e-17
C_MG2_X_2150_Y_1612 MG2_X_2150_Y_1612 0 1.5475e-17
C_MG2_X_2150_Y_2150 MG2_X_2150_Y_2150 0 1.5475e-17
C_MG2_X_2150_Y_2688 MG2_X_2150_Y_2688 0 1.5475e-17
C_MG2_X_2150_Y_3225 MG2_X_2150_Y_3225 0 1.5475e-17
C_MG2_X_2150_Y_3763 MG2_X_2150_Y_3763 0 1.5475e-17
C_MG2_X_2150_Y_4300 MG2_X_2150_Y_4300 0 1.5475e-17
C_MG2_X_2150_Y_4838 MG2_X_2150_Y_4838 0 1.5475e-17
C_MG2_X_2150_Y_537 MG2_X_2150_Y_537 0 1.5475e-17
C_MG2_X_2150_Y_5376 MG2_X_2150_Y_5376 0 1.5475e-17
C_MG2_X_2150_Y_5913 MG2_X_2150_Y_5913 0 1.5475e-17
C_MG2_X_2150_Y_6451 MG2_X_2150_Y_6451 0 1.5475e-17
C_MG2_X_2150_Y_6988 MG2_X_2150_Y_6988 0 1.5475e-17
C_MG2_X_2150_Y_7526 MG2_X_2150_Y_7526 0 1.5475e-17
C_MG2_X_2150_Y_8064 MG2_X_2150_Y_8064 0 1.5475e-17
C_MG2_X_2150_Y_8601 MG2_X_2150_Y_8601 0 1.5475e-17
C_MG2_X_2150_Y_9139 MG2_X_2150_Y_9139 0 1.5475e-17
C_MG2_X_2150_Y_9676 MG2_X_2150_Y_9676 0 1.5475e-17
C_MG2_X_2419_Y_1344 MG2_X_2419_Y_1344 0 1.5475e-17
C_MG2_X_2419_Y_1881 MG2_X_2419_Y_1881 0 1.5475e-17
C_MG2_X_2419_Y_2419 MG2_X_2419_Y_2419 0 1.5475e-17
C_MG2_X_2419_Y_268 MG2_X_2419_Y_268 0 1.5475e-17
C_MG2_X_2419_Y_2956 MG2_X_2419_Y_2956 0 1.5475e-17
C_MG2_X_2419_Y_3494 MG2_X_2419_Y_3494 0 1.5475e-17
C_MG2_X_2419_Y_4032 MG2_X_2419_Y_4032 0 1.5475e-17
C_MG2_X_2419_Y_4569 MG2_X_2419_Y_4569 0 1.5475e-17
C_MG2_X_2419_Y_5107 MG2_X_2419_Y_5107 0 1.5475e-17
C_MG2_X_2419_Y_5644 MG2_X_2419_Y_5644 0 1.5475e-17
C_MG2_X_2419_Y_6182 MG2_X_2419_Y_6182 0 1.5475e-17
C_MG2_X_2419_Y_6720 MG2_X_2419_Y_6720 0 1.5475e-17
C_MG2_X_2419_Y_7257 MG2_X_2419_Y_7257 0 1.5475e-17
C_MG2_X_2419_Y_7795 MG2_X_2419_Y_7795 0 1.5475e-17
C_MG2_X_2419_Y_806 MG2_X_2419_Y_806 0 1.5475e-17
C_MG2_X_2419_Y_8332 MG2_X_2419_Y_8332 0 1.5475e-17
C_MG2_X_2419_Y_8870 MG2_X_2419_Y_8870 0 1.5475e-17
C_MG2_X_2419_Y_9408 MG2_X_2419_Y_9408 0 1.5475e-17
C_MG2_X_2419_Y_9945 MG2_X_2419_Y_9945 0 1.5475e-17
C_MG2_X_2688_Y_0 MG2_X_2688_Y_0 0 1.5475e-17
C_MG2_X_2688_Y_1075 MG2_X_2688_Y_1075 0 1.5475e-17
C_MG2_X_2688_Y_1612 MG2_X_2688_Y_1612 0 1.5475e-17
C_MG2_X_2688_Y_2150 MG2_X_2688_Y_2150 0 1.5475e-17
C_MG2_X_2688_Y_2688 MG2_X_2688_Y_2688 0 1.5475e-17
C_MG2_X_2688_Y_3225 MG2_X_2688_Y_3225 0 1.5475e-17
C_MG2_X_2688_Y_3763 MG2_X_2688_Y_3763 0 1.5475e-17
C_MG2_X_2688_Y_4300 MG2_X_2688_Y_4300 0 1.5475e-17
C_MG2_X_2688_Y_4838 MG2_X_2688_Y_4838 0 1.5475e-17
C_MG2_X_2688_Y_537 MG2_X_2688_Y_537 0 1.5475e-17
C_MG2_X_2688_Y_5376 MG2_X_2688_Y_5376 0 1.5475e-17
C_MG2_X_2688_Y_5913 MG2_X_2688_Y_5913 0 1.5475e-17
C_MG2_X_2688_Y_6451 MG2_X_2688_Y_6451 0 1.5475e-17
C_MG2_X_2688_Y_6988 MG2_X_2688_Y_6988 0 1.5475e-17
C_MG2_X_2688_Y_7526 MG2_X_2688_Y_7526 0 1.5475e-17
C_MG2_X_2688_Y_8064 MG2_X_2688_Y_8064 0 1.5475e-17
C_MG2_X_2688_Y_8601 MG2_X_2688_Y_8601 0 1.5475e-17
C_MG2_X_2688_Y_9139 MG2_X_2688_Y_9139 0 1.5475e-17
C_MG2_X_2688_Y_9676 MG2_X_2688_Y_9676 0 1.5475e-17
C_MG2_X_268_Y_1344 MG2_X_268_Y_1344 0 1.1606e-17
C_MG2_X_268_Y_1881 MG2_X_268_Y_1881 0 1.1606e-17
C_MG2_X_268_Y_2419 MG2_X_268_Y_2419 0 1.1606e-17
C_MG2_X_268_Y_268 MG2_X_268_Y_268 0 1.1606e-17
C_MG2_X_268_Y_2956 MG2_X_268_Y_2956 0 1.1606e-17
C_MG2_X_268_Y_3494 MG2_X_268_Y_3494 0 1.1606e-17
C_MG2_X_268_Y_4032 MG2_X_268_Y_4032 0 1.1606e-17
C_MG2_X_268_Y_4569 MG2_X_268_Y_4569 0 1.1606e-17
C_MG2_X_268_Y_5107 MG2_X_268_Y_5107 0 1.1606e-17
C_MG2_X_268_Y_5644 MG2_X_268_Y_5644 0 1.1606e-17
C_MG2_X_268_Y_6182 MG2_X_268_Y_6182 0 1.1606e-17
C_MG2_X_268_Y_6720 MG2_X_268_Y_6720 0 1.1606e-17
C_MG2_X_268_Y_7257 MG2_X_268_Y_7257 0 1.1606e-17
C_MG2_X_268_Y_7795 MG2_X_268_Y_7795 0 1.1606e-17
C_MG2_X_268_Y_806 MG2_X_268_Y_806 0 1.1606e-17
C_MG2_X_268_Y_8332 MG2_X_268_Y_8332 0 1.1606e-17
C_MG2_X_268_Y_8870 MG2_X_268_Y_8870 0 1.1606e-17
C_MG2_X_268_Y_9408 MG2_X_268_Y_9408 0 1.1606e-17
C_MG2_X_268_Y_9945 MG2_X_268_Y_9945 0 1.1606e-17
C_MG2_X_2956_Y_1344 MG2_X_2956_Y_1344 0 1.5475e-17
C_MG2_X_2956_Y_1881 MG2_X_2956_Y_1881 0 1.5475e-17
C_MG2_X_2956_Y_2419 MG2_X_2956_Y_2419 0 1.5475e-17
C_MG2_X_2956_Y_268 MG2_X_2956_Y_268 0 1.5475e-17
C_MG2_X_2956_Y_2956 MG2_X_2956_Y_2956 0 1.5475e-17
C_MG2_X_2956_Y_3494 MG2_X_2956_Y_3494 0 1.5475e-17
C_MG2_X_2956_Y_4032 MG2_X_2956_Y_4032 0 1.5475e-17
C_MG2_X_2956_Y_4569 MG2_X_2956_Y_4569 0 1.5475e-17
C_MG2_X_2956_Y_5107 MG2_X_2956_Y_5107 0 1.5475e-17
C_MG2_X_2956_Y_5644 MG2_X_2956_Y_5644 0 1.5475e-17
C_MG2_X_2956_Y_6182 MG2_X_2956_Y_6182 0 1.5475e-17
C_MG2_X_2956_Y_6720 MG2_X_2956_Y_6720 0 1.5475e-17
C_MG2_X_2956_Y_7257 MG2_X_2956_Y_7257 0 1.5475e-17
C_MG2_X_2956_Y_7795 MG2_X_2956_Y_7795 0 1.5475e-17
C_MG2_X_2956_Y_806 MG2_X_2956_Y_806 0 1.5475e-17
C_MG2_X_2956_Y_8332 MG2_X_2956_Y_8332 0 1.5475e-17
C_MG2_X_2956_Y_8870 MG2_X_2956_Y_8870 0 1.5475e-17
C_MG2_X_2956_Y_9408 MG2_X_2956_Y_9408 0 1.5475e-17
C_MG2_X_2956_Y_9945 MG2_X_2956_Y_9945 0 1.5475e-17
C_MG2_X_3225_Y_0 MG2_X_3225_Y_0 0 1.5475e-17
C_MG2_X_3225_Y_1075 MG2_X_3225_Y_1075 0 1.5475e-17
C_MG2_X_3225_Y_1612 MG2_X_3225_Y_1612 0 1.5475e-17
C_MG2_X_3225_Y_2150 MG2_X_3225_Y_2150 0 1.5475e-17
C_MG2_X_3225_Y_2688 MG2_X_3225_Y_2688 0 1.5475e-17
C_MG2_X_3225_Y_3225 MG2_X_3225_Y_3225 0 1.5475e-17
C_MG2_X_3225_Y_3763 MG2_X_3225_Y_3763 0 1.5475e-17
C_MG2_X_3225_Y_4300 MG2_X_3225_Y_4300 0 1.5475e-17
C_MG2_X_3225_Y_4838 MG2_X_3225_Y_4838 0 1.5475e-17
C_MG2_X_3225_Y_537 MG2_X_3225_Y_537 0 1.5475e-17
C_MG2_X_3225_Y_5376 MG2_X_3225_Y_5376 0 1.5475e-17
C_MG2_X_3225_Y_5913 MG2_X_3225_Y_5913 0 1.5475e-17
C_MG2_X_3225_Y_6451 MG2_X_3225_Y_6451 0 1.5475e-17
C_MG2_X_3225_Y_6988 MG2_X_3225_Y_6988 0 1.5475e-17
C_MG2_X_3225_Y_7526 MG2_X_3225_Y_7526 0 1.5475e-17
C_MG2_X_3225_Y_8064 MG2_X_3225_Y_8064 0 1.5475e-17
C_MG2_X_3225_Y_8601 MG2_X_3225_Y_8601 0 1.5475e-17
C_MG2_X_3225_Y_9139 MG2_X_3225_Y_9139 0 1.5475e-17
C_MG2_X_3225_Y_9676 MG2_X_3225_Y_9676 0 1.5475e-17
C_MG2_X_3494_Y_1344 MG2_X_3494_Y_1344 0 1.5475e-17
C_MG2_X_3494_Y_1881 MG2_X_3494_Y_1881 0 1.5475e-17
C_MG2_X_3494_Y_2419 MG2_X_3494_Y_2419 0 1.5475e-17
C_MG2_X_3494_Y_268 MG2_X_3494_Y_268 0 1.5475e-17
C_MG2_X_3494_Y_2956 MG2_X_3494_Y_2956 0 1.5475e-17
C_MG2_X_3494_Y_3494 MG2_X_3494_Y_3494 0 1.5475e-17
C_MG2_X_3494_Y_4032 MG2_X_3494_Y_4032 0 1.5475e-17
C_MG2_X_3494_Y_4569 MG2_X_3494_Y_4569 0 1.5475e-17
C_MG2_X_3494_Y_5107 MG2_X_3494_Y_5107 0 1.5475e-17
C_MG2_X_3494_Y_5644 MG2_X_3494_Y_5644 0 1.5475e-17
C_MG2_X_3494_Y_6182 MG2_X_3494_Y_6182 0 1.5475e-17
C_MG2_X_3494_Y_6720 MG2_X_3494_Y_6720 0 1.5475e-17
C_MG2_X_3494_Y_7257 MG2_X_3494_Y_7257 0 1.5475e-17
C_MG2_X_3494_Y_7795 MG2_X_3494_Y_7795 0 1.5475e-17
C_MG2_X_3494_Y_806 MG2_X_3494_Y_806 0 1.5475e-17
C_MG2_X_3494_Y_8332 MG2_X_3494_Y_8332 0 1.5475e-17
C_MG2_X_3494_Y_8870 MG2_X_3494_Y_8870 0 1.5475e-17
C_MG2_X_3494_Y_9408 MG2_X_3494_Y_9408 0 1.5475e-17
C_MG2_X_3494_Y_9945 MG2_X_3494_Y_9945 0 1.5475e-17
C_MG2_X_3763_Y_0 MG2_X_3763_Y_0 0 1.5475e-17
C_MG2_X_3763_Y_1075 MG2_X_3763_Y_1075 0 1.5475e-17
C_MG2_X_3763_Y_1612 MG2_X_3763_Y_1612 0 1.5475e-17
C_MG2_X_3763_Y_2150 MG2_X_3763_Y_2150 0 1.5475e-17
C_MG2_X_3763_Y_2688 MG2_X_3763_Y_2688 0 1.5475e-17
C_MG2_X_3763_Y_3225 MG2_X_3763_Y_3225 0 1.5475e-17
C_MG2_X_3763_Y_3763 MG2_X_3763_Y_3763 0 1.5475e-17
C_MG2_X_3763_Y_4300 MG2_X_3763_Y_4300 0 1.5475e-17
C_MG2_X_3763_Y_4838 MG2_X_3763_Y_4838 0 1.5475e-17
C_MG2_X_3763_Y_537 MG2_X_3763_Y_537 0 1.5475e-17
C_MG2_X_3763_Y_5376 MG2_X_3763_Y_5376 0 1.5475e-17
C_MG2_X_3763_Y_5913 MG2_X_3763_Y_5913 0 1.5475e-17
C_MG2_X_3763_Y_6451 MG2_X_3763_Y_6451 0 1.5475e-17
C_MG2_X_3763_Y_6988 MG2_X_3763_Y_6988 0 1.5475e-17
C_MG2_X_3763_Y_7526 MG2_X_3763_Y_7526 0 1.5475e-17
C_MG2_X_3763_Y_8064 MG2_X_3763_Y_8064 0 1.5475e-17
C_MG2_X_3763_Y_8601 MG2_X_3763_Y_8601 0 1.5475e-17
C_MG2_X_3763_Y_9139 MG2_X_3763_Y_9139 0 1.5475e-17
C_MG2_X_3763_Y_9676 MG2_X_3763_Y_9676 0 1.5475e-17
C_MG2_X_4032_Y_1344 MG2_X_4032_Y_1344 0 1.5475e-17
C_MG2_X_4032_Y_1881 MG2_X_4032_Y_1881 0 1.5475e-17
C_MG2_X_4032_Y_2419 MG2_X_4032_Y_2419 0 1.5475e-17
C_MG2_X_4032_Y_268 MG2_X_4032_Y_268 0 1.5475e-17
C_MG2_X_4032_Y_2956 MG2_X_4032_Y_2956 0 1.5475e-17
C_MG2_X_4032_Y_3494 MG2_X_4032_Y_3494 0 1.5475e-17
C_MG2_X_4032_Y_4032 MG2_X_4032_Y_4032 0 1.5475e-17
C_MG2_X_4032_Y_4569 MG2_X_4032_Y_4569 0 1.5475e-17
C_MG2_X_4032_Y_5107 MG2_X_4032_Y_5107 0 1.5475e-17
C_MG2_X_4032_Y_5644 MG2_X_4032_Y_5644 0 1.5475e-17
C_MG2_X_4032_Y_6182 MG2_X_4032_Y_6182 0 1.5475e-17
C_MG2_X_4032_Y_6720 MG2_X_4032_Y_6720 0 1.5475e-17
C_MG2_X_4032_Y_7257 MG2_X_4032_Y_7257 0 1.5475e-17
C_MG2_X_4032_Y_7795 MG2_X_4032_Y_7795 0 1.5475e-17
C_MG2_X_4032_Y_806 MG2_X_4032_Y_806 0 1.5475e-17
C_MG2_X_4032_Y_8332 MG2_X_4032_Y_8332 0 1.5475e-17
C_MG2_X_4032_Y_8870 MG2_X_4032_Y_8870 0 1.5475e-17
C_MG2_X_4032_Y_9408 MG2_X_4032_Y_9408 0 1.5475e-17
C_MG2_X_4032_Y_9945 MG2_X_4032_Y_9945 0 1.5475e-17
C_MG2_X_4300_Y_0 MG2_X_4300_Y_0 0 1.5475e-17
C_MG2_X_4300_Y_1075 MG2_X_4300_Y_1075 0 1.5475e-17
C_MG2_X_4300_Y_1612 MG2_X_4300_Y_1612 0 1.5475e-17
C_MG2_X_4300_Y_2150 MG2_X_4300_Y_2150 0 1.5475e-17
C_MG2_X_4300_Y_2688 MG2_X_4300_Y_2688 0 1.5475e-17
C_MG2_X_4300_Y_3225 MG2_X_4300_Y_3225 0 1.5475e-17
C_MG2_X_4300_Y_3763 MG2_X_4300_Y_3763 0 1.5475e-17
C_MG2_X_4300_Y_4300 MG2_X_4300_Y_4300 0 1.5475e-17
C_MG2_X_4300_Y_4838 MG2_X_4300_Y_4838 0 1.5475e-17
C_MG2_X_4300_Y_537 MG2_X_4300_Y_537 0 1.5475e-17
C_MG2_X_4300_Y_5376 MG2_X_4300_Y_5376 0 1.5475e-17
C_MG2_X_4300_Y_5913 MG2_X_4300_Y_5913 0 1.5475e-17
C_MG2_X_4300_Y_6451 MG2_X_4300_Y_6451 0 1.5475e-17
C_MG2_X_4300_Y_6988 MG2_X_4300_Y_6988 0 1.5475e-17
C_MG2_X_4300_Y_7526 MG2_X_4300_Y_7526 0 1.5475e-17
C_MG2_X_4300_Y_8064 MG2_X_4300_Y_8064 0 1.5475e-17
C_MG2_X_4300_Y_8601 MG2_X_4300_Y_8601 0 1.5475e-17
C_MG2_X_4300_Y_9139 MG2_X_4300_Y_9139 0 1.5475e-17
C_MG2_X_4300_Y_9676 MG2_X_4300_Y_9676 0 1.5475e-17
C_MG2_X_4569_Y_1344 MG2_X_4569_Y_1344 0 1.5475e-17
C_MG2_X_4569_Y_1881 MG2_X_4569_Y_1881 0 1.5475e-17
C_MG2_X_4569_Y_2419 MG2_X_4569_Y_2419 0 1.5475e-17
C_MG2_X_4569_Y_268 MG2_X_4569_Y_268 0 1.5475e-17
C_MG2_X_4569_Y_2956 MG2_X_4569_Y_2956 0 1.5475e-17
C_MG2_X_4569_Y_3494 MG2_X_4569_Y_3494 0 1.5475e-17
C_MG2_X_4569_Y_4032 MG2_X_4569_Y_4032 0 1.5475e-17
C_MG2_X_4569_Y_4569 MG2_X_4569_Y_4569 0 1.5475e-17
C_MG2_X_4569_Y_5107 MG2_X_4569_Y_5107 0 1.5475e-17
C_MG2_X_4569_Y_5644 MG2_X_4569_Y_5644 0 1.5475e-17
C_MG2_X_4569_Y_6182 MG2_X_4569_Y_6182 0 1.5475e-17
C_MG2_X_4569_Y_6720 MG2_X_4569_Y_6720 0 1.5475e-17
C_MG2_X_4569_Y_7257 MG2_X_4569_Y_7257 0 1.5475e-17
C_MG2_X_4569_Y_7795 MG2_X_4569_Y_7795 0 1.5475e-17
C_MG2_X_4569_Y_806 MG2_X_4569_Y_806 0 1.5475e-17
C_MG2_X_4569_Y_8332 MG2_X_4569_Y_8332 0 1.5475e-17
C_MG2_X_4569_Y_8870 MG2_X_4569_Y_8870 0 1.5475e-17
C_MG2_X_4569_Y_9408 MG2_X_4569_Y_9408 0 1.5475e-17
C_MG2_X_4569_Y_9945 MG2_X_4569_Y_9945 0 1.5475e-17
C_MG2_X_4838_Y_0 MG2_X_4838_Y_0 0 1.5475e-17
C_MG2_X_4838_Y_1075 MG2_X_4838_Y_1075 0 1.5475e-17
C_MG2_X_4838_Y_1612 MG2_X_4838_Y_1612 0 1.5475e-17
C_MG2_X_4838_Y_2150 MG2_X_4838_Y_2150 0 1.5475e-17
C_MG2_X_4838_Y_2688 MG2_X_4838_Y_2688 0 1.5475e-17
C_MG2_X_4838_Y_3225 MG2_X_4838_Y_3225 0 1.5475e-17
C_MG2_X_4838_Y_3763 MG2_X_4838_Y_3763 0 1.5475e-17
C_MG2_X_4838_Y_4300 MG2_X_4838_Y_4300 0 1.5475e-17
C_MG2_X_4838_Y_4838 MG2_X_4838_Y_4838 0 1.5475e-17
C_MG2_X_4838_Y_537 MG2_X_4838_Y_537 0 1.5475e-17
C_MG2_X_4838_Y_5376 MG2_X_4838_Y_5376 0 1.5475e-17
C_MG2_X_4838_Y_5913 MG2_X_4838_Y_5913 0 1.5475e-17
C_MG2_X_4838_Y_6451 MG2_X_4838_Y_6451 0 1.5475e-17
C_MG2_X_4838_Y_6988 MG2_X_4838_Y_6988 0 1.5475e-17
C_MG2_X_4838_Y_7526 MG2_X_4838_Y_7526 0 1.5475e-17
C_MG2_X_4838_Y_8064 MG2_X_4838_Y_8064 0 1.5475e-17
C_MG2_X_4838_Y_8601 MG2_X_4838_Y_8601 0 1.5475e-17
C_MG2_X_4838_Y_9139 MG2_X_4838_Y_9139 0 1.5475e-17
C_MG2_X_4838_Y_9676 MG2_X_4838_Y_9676 0 1.5475e-17
C_MG2_X_5107_Y_1344 MG2_X_5107_Y_1344 0 1.5475e-17
C_MG2_X_5107_Y_1881 MG2_X_5107_Y_1881 0 1.5475e-17
C_MG2_X_5107_Y_2419 MG2_X_5107_Y_2419 0 1.5475e-17
C_MG2_X_5107_Y_268 MG2_X_5107_Y_268 0 1.5475e-17
C_MG2_X_5107_Y_2956 MG2_X_5107_Y_2956 0 1.5475e-17
C_MG2_X_5107_Y_3494 MG2_X_5107_Y_3494 0 1.5475e-17
C_MG2_X_5107_Y_4032 MG2_X_5107_Y_4032 0 1.5475e-17
C_MG2_X_5107_Y_4569 MG2_X_5107_Y_4569 0 1.5475e-17
C_MG2_X_5107_Y_5107 MG2_X_5107_Y_5107 0 1.5475e-17
C_MG2_X_5107_Y_5644 MG2_X_5107_Y_5644 0 1.5475e-17
C_MG2_X_5107_Y_6182 MG2_X_5107_Y_6182 0 1.5475e-17
C_MG2_X_5107_Y_6720 MG2_X_5107_Y_6720 0 1.5475e-17
C_MG2_X_5107_Y_7257 MG2_X_5107_Y_7257 0 1.5475e-17
C_MG2_X_5107_Y_7795 MG2_X_5107_Y_7795 0 1.5475e-17
C_MG2_X_5107_Y_806 MG2_X_5107_Y_806 0 1.5475e-17
C_MG2_X_5107_Y_8332 MG2_X_5107_Y_8332 0 1.5475e-17
C_MG2_X_5107_Y_8870 MG2_X_5107_Y_8870 0 1.5475e-17
C_MG2_X_5107_Y_9408 MG2_X_5107_Y_9408 0 1.5475e-17
C_MG2_X_5107_Y_9945 MG2_X_5107_Y_9945 0 1.5475e-17
C_MG2_X_5376_Y_0 MG2_X_5376_Y_0 0 1.5475e-17
C_MG2_X_5376_Y_1075 MG2_X_5376_Y_1075 0 1.5475e-17
C_MG2_X_5376_Y_1612 MG2_X_5376_Y_1612 0 1.5475e-17
C_MG2_X_5376_Y_2150 MG2_X_5376_Y_2150 0 1.5475e-17
C_MG2_X_5376_Y_2688 MG2_X_5376_Y_2688 0 1.5475e-17
C_MG2_X_5376_Y_3225 MG2_X_5376_Y_3225 0 1.5475e-17
C_MG2_X_5376_Y_3763 MG2_X_5376_Y_3763 0 1.5475e-17
C_MG2_X_5376_Y_4300 MG2_X_5376_Y_4300 0 1.5475e-17
C_MG2_X_5376_Y_4838 MG2_X_5376_Y_4838 0 1.5475e-17
C_MG2_X_5376_Y_537 MG2_X_5376_Y_537 0 1.5475e-17
C_MG2_X_5376_Y_5376 MG2_X_5376_Y_5376 0 1.5475e-17
C_MG2_X_5376_Y_5913 MG2_X_5376_Y_5913 0 1.5475e-17
C_MG2_X_5376_Y_6451 MG2_X_5376_Y_6451 0 1.5475e-17
C_MG2_X_5376_Y_6988 MG2_X_5376_Y_6988 0 1.5475e-17
C_MG2_X_5376_Y_7526 MG2_X_5376_Y_7526 0 1.5475e-17
C_MG2_X_5376_Y_8064 MG2_X_5376_Y_8064 0 1.5475e-17
C_MG2_X_5376_Y_8601 MG2_X_5376_Y_8601 0 1.5475e-17
C_MG2_X_5376_Y_9139 MG2_X_5376_Y_9139 0 1.5475e-17
C_MG2_X_5376_Y_9676 MG2_X_5376_Y_9676 0 1.5475e-17
C_MG2_X_537_Y_0 MG2_X_537_Y_0 0 1.5475e-17
C_MG2_X_537_Y_1075 MG2_X_537_Y_1075 0 1.5475e-17
C_MG2_X_537_Y_1612 MG2_X_537_Y_1612 0 1.5475e-17
C_MG2_X_537_Y_2150 MG2_X_537_Y_2150 0 1.5475e-17
C_MG2_X_537_Y_2688 MG2_X_537_Y_2688 0 1.5475e-17
C_MG2_X_537_Y_3225 MG2_X_537_Y_3225 0 1.5475e-17
C_MG2_X_537_Y_3763 MG2_X_537_Y_3763 0 1.5475e-17
C_MG2_X_537_Y_4300 MG2_X_537_Y_4300 0 1.5475e-17
C_MG2_X_537_Y_4838 MG2_X_537_Y_4838 0 1.5475e-17
C_MG2_X_537_Y_537 MG2_X_537_Y_537 0 1.5475e-17
C_MG2_X_537_Y_5376 MG2_X_537_Y_5376 0 1.5475e-17
C_MG2_X_537_Y_5913 MG2_X_537_Y_5913 0 1.5475e-17
C_MG2_X_537_Y_6451 MG2_X_537_Y_6451 0 1.5475e-17
C_MG2_X_537_Y_6988 MG2_X_537_Y_6988 0 1.5475e-17
C_MG2_X_537_Y_7526 MG2_X_537_Y_7526 0 1.5475e-17
C_MG2_X_537_Y_8064 MG2_X_537_Y_8064 0 1.5475e-17
C_MG2_X_537_Y_8601 MG2_X_537_Y_8601 0 1.5475e-17
C_MG2_X_537_Y_9139 MG2_X_537_Y_9139 0 1.5475e-17
C_MG2_X_537_Y_9676 MG2_X_537_Y_9676 0 1.5475e-17
C_MG2_X_5644_Y_1344 MG2_X_5644_Y_1344 0 1.5475e-17
C_MG2_X_5644_Y_1881 MG2_X_5644_Y_1881 0 1.5475e-17
C_MG2_X_5644_Y_2419 MG2_X_5644_Y_2419 0 1.5475e-17
C_MG2_X_5644_Y_268 MG2_X_5644_Y_268 0 1.5475e-17
C_MG2_X_5644_Y_2956 MG2_X_5644_Y_2956 0 1.5475e-17
C_MG2_X_5644_Y_3494 MG2_X_5644_Y_3494 0 1.5475e-17
C_MG2_X_5644_Y_4032 MG2_X_5644_Y_4032 0 1.5475e-17
C_MG2_X_5644_Y_4569 MG2_X_5644_Y_4569 0 1.5475e-17
C_MG2_X_5644_Y_5107 MG2_X_5644_Y_5107 0 1.5475e-17
C_MG2_X_5644_Y_5644 MG2_X_5644_Y_5644 0 1.5475e-17
C_MG2_X_5644_Y_6182 MG2_X_5644_Y_6182 0 1.5475e-17
C_MG2_X_5644_Y_6720 MG2_X_5644_Y_6720 0 1.5475e-17
C_MG2_X_5644_Y_7257 MG2_X_5644_Y_7257 0 1.5475e-17
C_MG2_X_5644_Y_7795 MG2_X_5644_Y_7795 0 1.5475e-17
C_MG2_X_5644_Y_806 MG2_X_5644_Y_806 0 1.5475e-17
C_MG2_X_5644_Y_8332 MG2_X_5644_Y_8332 0 1.5475e-17
C_MG2_X_5644_Y_8870 MG2_X_5644_Y_8870 0 1.5475e-17
C_MG2_X_5644_Y_9408 MG2_X_5644_Y_9408 0 1.5475e-17
C_MG2_X_5644_Y_9945 MG2_X_5644_Y_9945 0 1.5475e-17
C_MG2_X_5913_Y_0 MG2_X_5913_Y_0 0 1.5475e-17
C_MG2_X_5913_Y_1075 MG2_X_5913_Y_1075 0 1.5475e-17
C_MG2_X_5913_Y_1612 MG2_X_5913_Y_1612 0 1.5475e-17
C_MG2_X_5913_Y_2150 MG2_X_5913_Y_2150 0 1.5475e-17
C_MG2_X_5913_Y_2688 MG2_X_5913_Y_2688 0 1.5475e-17
C_MG2_X_5913_Y_3225 MG2_X_5913_Y_3225 0 1.5475e-17
C_MG2_X_5913_Y_3763 MG2_X_5913_Y_3763 0 1.5475e-17
C_MG2_X_5913_Y_4300 MG2_X_5913_Y_4300 0 1.5475e-17
C_MG2_X_5913_Y_4838 MG2_X_5913_Y_4838 0 1.5475e-17
C_MG2_X_5913_Y_537 MG2_X_5913_Y_537 0 1.5475e-17
C_MG2_X_5913_Y_5376 MG2_X_5913_Y_5376 0 1.5475e-17
C_MG2_X_5913_Y_5913 MG2_X_5913_Y_5913 0 1.5475e-17
C_MG2_X_5913_Y_6451 MG2_X_5913_Y_6451 0 1.5475e-17
C_MG2_X_5913_Y_6988 MG2_X_5913_Y_6988 0 1.5475e-17
C_MG2_X_5913_Y_7526 MG2_X_5913_Y_7526 0 1.5475e-17
C_MG2_X_5913_Y_8064 MG2_X_5913_Y_8064 0 1.5475e-17
C_MG2_X_5913_Y_8601 MG2_X_5913_Y_8601 0 1.5475e-17
C_MG2_X_5913_Y_9139 MG2_X_5913_Y_9139 0 1.5475e-17
C_MG2_X_5913_Y_9676 MG2_X_5913_Y_9676 0 1.5475e-17
C_MG2_X_6182_Y_1344 MG2_X_6182_Y_1344 0 1.5475e-17
C_MG2_X_6182_Y_1881 MG2_X_6182_Y_1881 0 1.5475e-17
C_MG2_X_6182_Y_2419 MG2_X_6182_Y_2419 0 1.5475e-17
C_MG2_X_6182_Y_268 MG2_X_6182_Y_268 0 1.5475e-17
C_MG2_X_6182_Y_2956 MG2_X_6182_Y_2956 0 1.5475e-17
C_MG2_X_6182_Y_3494 MG2_X_6182_Y_3494 0 1.5475e-17
C_MG2_X_6182_Y_4032 MG2_X_6182_Y_4032 0 1.5475e-17
C_MG2_X_6182_Y_4569 MG2_X_6182_Y_4569 0 1.5475e-17
C_MG2_X_6182_Y_5107 MG2_X_6182_Y_5107 0 1.5475e-17
C_MG2_X_6182_Y_5644 MG2_X_6182_Y_5644 0 1.5475e-17
C_MG2_X_6182_Y_6182 MG2_X_6182_Y_6182 0 1.5475e-17
C_MG2_X_6182_Y_6720 MG2_X_6182_Y_6720 0 1.5475e-17
C_MG2_X_6182_Y_7257 MG2_X_6182_Y_7257 0 1.5475e-17
C_MG2_X_6182_Y_7795 MG2_X_6182_Y_7795 0 1.5475e-17
C_MG2_X_6182_Y_806 MG2_X_6182_Y_806 0 1.5475e-17
C_MG2_X_6182_Y_8332 MG2_X_6182_Y_8332 0 1.5475e-17
C_MG2_X_6182_Y_8870 MG2_X_6182_Y_8870 0 1.5475e-17
C_MG2_X_6182_Y_9408 MG2_X_6182_Y_9408 0 1.5475e-17
C_MG2_X_6182_Y_9945 MG2_X_6182_Y_9945 0 1.5475e-17
C_MG2_X_6451_Y_0 MG2_X_6451_Y_0 0 1.5475e-17
C_MG2_X_6451_Y_1075 MG2_X_6451_Y_1075 0 1.5475e-17
C_MG2_X_6451_Y_1612 MG2_X_6451_Y_1612 0 1.5475e-17
C_MG2_X_6451_Y_2150 MG2_X_6451_Y_2150 0 1.5475e-17
C_MG2_X_6451_Y_2688 MG2_X_6451_Y_2688 0 1.5475e-17
C_MG2_X_6451_Y_3225 MG2_X_6451_Y_3225 0 1.5475e-17
C_MG2_X_6451_Y_3763 MG2_X_6451_Y_3763 0 1.5475e-17
C_MG2_X_6451_Y_4300 MG2_X_6451_Y_4300 0 1.5475e-17
C_MG2_X_6451_Y_4838 MG2_X_6451_Y_4838 0 1.5475e-17
C_MG2_X_6451_Y_537 MG2_X_6451_Y_537 0 1.5475e-17
C_MG2_X_6451_Y_5376 MG2_X_6451_Y_5376 0 1.5475e-17
C_MG2_X_6451_Y_5913 MG2_X_6451_Y_5913 0 1.5475e-17
C_MG2_X_6451_Y_6451 MG2_X_6451_Y_6451 0 1.5475e-17
C_MG2_X_6451_Y_6988 MG2_X_6451_Y_6988 0 1.5475e-17
C_MG2_X_6451_Y_7526 MG2_X_6451_Y_7526 0 1.5475e-17
C_MG2_X_6451_Y_8064 MG2_X_6451_Y_8064 0 1.5475e-17
C_MG2_X_6451_Y_8601 MG2_X_6451_Y_8601 0 1.5475e-17
C_MG2_X_6451_Y_9139 MG2_X_6451_Y_9139 0 1.5475e-17
C_MG2_X_6451_Y_9676 MG2_X_6451_Y_9676 0 1.5475e-17
C_MG2_X_6720_Y_1344 MG2_X_6720_Y_1344 0 1.5475e-17
C_MG2_X_6720_Y_1881 MG2_X_6720_Y_1881 0 1.5475e-17
C_MG2_X_6720_Y_2419 MG2_X_6720_Y_2419 0 1.5475e-17
C_MG2_X_6720_Y_268 MG2_X_6720_Y_268 0 1.5475e-17
C_MG2_X_6720_Y_2956 MG2_X_6720_Y_2956 0 1.5475e-17
C_MG2_X_6720_Y_3494 MG2_X_6720_Y_3494 0 1.5475e-17
C_MG2_X_6720_Y_4032 MG2_X_6720_Y_4032 0 1.5475e-17
C_MG2_X_6720_Y_4569 MG2_X_6720_Y_4569 0 1.5475e-17
C_MG2_X_6720_Y_5107 MG2_X_6720_Y_5107 0 1.5475e-17
C_MG2_X_6720_Y_5644 MG2_X_6720_Y_5644 0 1.5475e-17
C_MG2_X_6720_Y_6182 MG2_X_6720_Y_6182 0 1.5475e-17
C_MG2_X_6720_Y_6720 MG2_X_6720_Y_6720 0 1.5475e-17
C_MG2_X_6720_Y_7257 MG2_X_6720_Y_7257 0 1.5475e-17
C_MG2_X_6720_Y_7795 MG2_X_6720_Y_7795 0 1.5475e-17
C_MG2_X_6720_Y_806 MG2_X_6720_Y_806 0 1.5475e-17
C_MG2_X_6720_Y_8332 MG2_X_6720_Y_8332 0 1.5475e-17
C_MG2_X_6720_Y_8870 MG2_X_6720_Y_8870 0 1.5475e-17
C_MG2_X_6720_Y_9408 MG2_X_6720_Y_9408 0 1.5475e-17
C_MG2_X_6720_Y_9945 MG2_X_6720_Y_9945 0 1.5475e-17
C_MG2_X_6988_Y_0 MG2_X_6988_Y_0 0 1.5475e-17
C_MG2_X_6988_Y_1075 MG2_X_6988_Y_1075 0 1.5475e-17
C_MG2_X_6988_Y_1612 MG2_X_6988_Y_1612 0 1.5475e-17
C_MG2_X_6988_Y_2150 MG2_X_6988_Y_2150 0 1.5475e-17
C_MG2_X_6988_Y_2688 MG2_X_6988_Y_2688 0 1.5475e-17
C_MG2_X_6988_Y_3225 MG2_X_6988_Y_3225 0 1.5475e-17
C_MG2_X_6988_Y_3763 MG2_X_6988_Y_3763 0 1.5475e-17
C_MG2_X_6988_Y_4300 MG2_X_6988_Y_4300 0 1.5475e-17
C_MG2_X_6988_Y_4838 MG2_X_6988_Y_4838 0 1.5475e-17
C_MG2_X_6988_Y_537 MG2_X_6988_Y_537 0 1.5475e-17
C_MG2_X_6988_Y_5376 MG2_X_6988_Y_5376 0 1.5475e-17
C_MG2_X_6988_Y_5913 MG2_X_6988_Y_5913 0 1.5475e-17
C_MG2_X_6988_Y_6451 MG2_X_6988_Y_6451 0 1.5475e-17
C_MG2_X_6988_Y_6988 MG2_X_6988_Y_6988 0 1.5475e-17
C_MG2_X_6988_Y_7526 MG2_X_6988_Y_7526 0 1.5475e-17
C_MG2_X_6988_Y_8064 MG2_X_6988_Y_8064 0 1.5475e-17
C_MG2_X_6988_Y_8601 MG2_X_6988_Y_8601 0 1.5475e-17
C_MG2_X_6988_Y_9139 MG2_X_6988_Y_9139 0 1.5475e-17
C_MG2_X_6988_Y_9676 MG2_X_6988_Y_9676 0 1.5475e-17
C_MG2_X_7257_Y_1344 MG2_X_7257_Y_1344 0 1.5475e-17
C_MG2_X_7257_Y_1881 MG2_X_7257_Y_1881 0 1.5475e-17
C_MG2_X_7257_Y_2419 MG2_X_7257_Y_2419 0 1.5475e-17
C_MG2_X_7257_Y_268 MG2_X_7257_Y_268 0 1.5475e-17
C_MG2_X_7257_Y_2956 MG2_X_7257_Y_2956 0 1.5475e-17
C_MG2_X_7257_Y_3494 MG2_X_7257_Y_3494 0 1.5475e-17
C_MG2_X_7257_Y_4032 MG2_X_7257_Y_4032 0 1.5475e-17
C_MG2_X_7257_Y_4569 MG2_X_7257_Y_4569 0 1.5475e-17
C_MG2_X_7257_Y_5107 MG2_X_7257_Y_5107 0 1.5475e-17
C_MG2_X_7257_Y_5644 MG2_X_7257_Y_5644 0 1.5475e-17
C_MG2_X_7257_Y_6182 MG2_X_7257_Y_6182 0 1.5475e-17
C_MG2_X_7257_Y_6720 MG2_X_7257_Y_6720 0 1.5475e-17
C_MG2_X_7257_Y_7257 MG2_X_7257_Y_7257 0 1.5475e-17
C_MG2_X_7257_Y_7795 MG2_X_7257_Y_7795 0 1.5475e-17
C_MG2_X_7257_Y_806 MG2_X_7257_Y_806 0 1.5475e-17
C_MG2_X_7257_Y_8332 MG2_X_7257_Y_8332 0 1.5475e-17
C_MG2_X_7257_Y_8870 MG2_X_7257_Y_8870 0 1.5475e-17
C_MG2_X_7257_Y_9408 MG2_X_7257_Y_9408 0 1.5475e-17
C_MG2_X_7257_Y_9945 MG2_X_7257_Y_9945 0 1.5475e-17
C_MG2_X_7526_Y_0 MG2_X_7526_Y_0 0 1.5475e-17
C_MG2_X_7526_Y_1075 MG2_X_7526_Y_1075 0 1.5475e-17
C_MG2_X_7526_Y_1612 MG2_X_7526_Y_1612 0 1.5475e-17
C_MG2_X_7526_Y_2150 MG2_X_7526_Y_2150 0 1.5475e-17
C_MG2_X_7526_Y_2688 MG2_X_7526_Y_2688 0 1.5475e-17
C_MG2_X_7526_Y_3225 MG2_X_7526_Y_3225 0 1.5475e-17
C_MG2_X_7526_Y_3763 MG2_X_7526_Y_3763 0 1.5475e-17
C_MG2_X_7526_Y_4300 MG2_X_7526_Y_4300 0 1.5475e-17
C_MG2_X_7526_Y_4838 MG2_X_7526_Y_4838 0 1.5475e-17
C_MG2_X_7526_Y_537 MG2_X_7526_Y_537 0 1.5475e-17
C_MG2_X_7526_Y_5376 MG2_X_7526_Y_5376 0 1.5475e-17
C_MG2_X_7526_Y_5913 MG2_X_7526_Y_5913 0 1.5475e-17
C_MG2_X_7526_Y_6451 MG2_X_7526_Y_6451 0 1.5475e-17
C_MG2_X_7526_Y_6988 MG2_X_7526_Y_6988 0 1.5475e-17
C_MG2_X_7526_Y_7526 MG2_X_7526_Y_7526 0 1.5475e-17
C_MG2_X_7526_Y_8064 MG2_X_7526_Y_8064 0 1.5475e-17
C_MG2_X_7526_Y_8601 MG2_X_7526_Y_8601 0 1.5475e-17
C_MG2_X_7526_Y_9139 MG2_X_7526_Y_9139 0 1.5475e-17
C_MG2_X_7526_Y_9676 MG2_X_7526_Y_9676 0 1.5475e-17
C_MG2_X_7795_Y_1344 MG2_X_7795_Y_1344 0 1.5475e-17
C_MG2_X_7795_Y_1881 MG2_X_7795_Y_1881 0 1.5475e-17
C_MG2_X_7795_Y_2419 MG2_X_7795_Y_2419 0 1.5475e-17
C_MG2_X_7795_Y_268 MG2_X_7795_Y_268 0 1.5475e-17
C_MG2_X_7795_Y_2956 MG2_X_7795_Y_2956 0 1.5475e-17
C_MG2_X_7795_Y_3494 MG2_X_7795_Y_3494 0 1.5475e-17
C_MG2_X_7795_Y_4032 MG2_X_7795_Y_4032 0 1.5475e-17
C_MG2_X_7795_Y_4569 MG2_X_7795_Y_4569 0 1.5475e-17
C_MG2_X_7795_Y_5107 MG2_X_7795_Y_5107 0 1.5475e-17
C_MG2_X_7795_Y_5644 MG2_X_7795_Y_5644 0 1.5475e-17
C_MG2_X_7795_Y_6182 MG2_X_7795_Y_6182 0 1.5475e-17
C_MG2_X_7795_Y_6720 MG2_X_7795_Y_6720 0 1.5475e-17
C_MG2_X_7795_Y_7257 MG2_X_7795_Y_7257 0 1.5475e-17
C_MG2_X_7795_Y_7795 MG2_X_7795_Y_7795 0 1.5475e-17
C_MG2_X_7795_Y_806 MG2_X_7795_Y_806 0 1.5475e-17
C_MG2_X_7795_Y_8332 MG2_X_7795_Y_8332 0 1.5475e-17
C_MG2_X_7795_Y_8870 MG2_X_7795_Y_8870 0 1.5475e-17
C_MG2_X_7795_Y_9408 MG2_X_7795_Y_9408 0 1.5475e-17
C_MG2_X_7795_Y_9945 MG2_X_7795_Y_9945 0 1.5475e-17
C_MG2_X_8064_Y_0 MG2_X_8064_Y_0 0 1.5475e-17
C_MG2_X_8064_Y_1075 MG2_X_8064_Y_1075 0 1.5475e-17
C_MG2_X_8064_Y_1612 MG2_X_8064_Y_1612 0 1.5475e-17
C_MG2_X_8064_Y_2150 MG2_X_8064_Y_2150 0 1.5475e-17
C_MG2_X_8064_Y_2688 MG2_X_8064_Y_2688 0 1.5475e-17
C_MG2_X_8064_Y_3225 MG2_X_8064_Y_3225 0 1.5475e-17
C_MG2_X_8064_Y_3763 MG2_X_8064_Y_3763 0 1.5475e-17
C_MG2_X_8064_Y_4300 MG2_X_8064_Y_4300 0 1.5475e-17
C_MG2_X_8064_Y_4838 MG2_X_8064_Y_4838 0 1.5475e-17
C_MG2_X_8064_Y_537 MG2_X_8064_Y_537 0 1.5475e-17
C_MG2_X_8064_Y_5376 MG2_X_8064_Y_5376 0 1.5475e-17
C_MG2_X_8064_Y_5913 MG2_X_8064_Y_5913 0 1.5475e-17
C_MG2_X_8064_Y_6451 MG2_X_8064_Y_6451 0 1.5475e-17
C_MG2_X_8064_Y_6988 MG2_X_8064_Y_6988 0 1.5475e-17
C_MG2_X_8064_Y_7526 MG2_X_8064_Y_7526 0 1.5475e-17
C_MG2_X_8064_Y_8064 MG2_X_8064_Y_8064 0 1.5475e-17
C_MG2_X_8064_Y_8601 MG2_X_8064_Y_8601 0 1.5475e-17
C_MG2_X_8064_Y_9139 MG2_X_8064_Y_9139 0 1.5475e-17
C_MG2_X_8064_Y_9676 MG2_X_8064_Y_9676 0 1.5475e-17
C_MG2_X_806_Y_1344 MG2_X_806_Y_1344 0 1.5475e-17
C_MG2_X_806_Y_1881 MG2_X_806_Y_1881 0 1.5475e-17
C_MG2_X_806_Y_2419 MG2_X_806_Y_2419 0 1.5475e-17
C_MG2_X_806_Y_268 MG2_X_806_Y_268 0 1.5475e-17
C_MG2_X_806_Y_2956 MG2_X_806_Y_2956 0 1.5475e-17
C_MG2_X_806_Y_3494 MG2_X_806_Y_3494 0 1.5475e-17
C_MG2_X_806_Y_4032 MG2_X_806_Y_4032 0 1.5475e-17
C_MG2_X_806_Y_4569 MG2_X_806_Y_4569 0 1.5475e-17
C_MG2_X_806_Y_5107 MG2_X_806_Y_5107 0 1.5475e-17
C_MG2_X_806_Y_5644 MG2_X_806_Y_5644 0 1.5475e-17
C_MG2_X_806_Y_6182 MG2_X_806_Y_6182 0 1.5475e-17
C_MG2_X_806_Y_6720 MG2_X_806_Y_6720 0 1.5475e-17
C_MG2_X_806_Y_7257 MG2_X_806_Y_7257 0 1.5475e-17
C_MG2_X_806_Y_7795 MG2_X_806_Y_7795 0 1.5475e-17
C_MG2_X_806_Y_806 MG2_X_806_Y_806 0 1.5475e-17
C_MG2_X_806_Y_8332 MG2_X_806_Y_8332 0 1.5475e-17
C_MG2_X_806_Y_8870 MG2_X_806_Y_8870 0 1.5475e-17
C_MG2_X_806_Y_9408 MG2_X_806_Y_9408 0 1.5475e-17
C_MG2_X_806_Y_9945 MG2_X_806_Y_9945 0 1.5475e-17
C_MG2_X_8332_Y_1344 MG2_X_8332_Y_1344 0 1.5475e-17
C_MG2_X_8332_Y_1881 MG2_X_8332_Y_1881 0 1.5475e-17
C_MG2_X_8332_Y_2419 MG2_X_8332_Y_2419 0 1.5475e-17
C_MG2_X_8332_Y_268 MG2_X_8332_Y_268 0 1.5475e-17
C_MG2_X_8332_Y_2956 MG2_X_8332_Y_2956 0 1.5475e-17
C_MG2_X_8332_Y_3494 MG2_X_8332_Y_3494 0 1.5475e-17
C_MG2_X_8332_Y_4032 MG2_X_8332_Y_4032 0 1.5475e-17
C_MG2_X_8332_Y_4569 MG2_X_8332_Y_4569 0 1.5475e-17
C_MG2_X_8332_Y_5107 MG2_X_8332_Y_5107 0 1.5475e-17
C_MG2_X_8332_Y_5644 MG2_X_8332_Y_5644 0 1.5475e-17
C_MG2_X_8332_Y_6182 MG2_X_8332_Y_6182 0 1.5475e-17
C_MG2_X_8332_Y_6720 MG2_X_8332_Y_6720 0 1.5475e-17
C_MG2_X_8332_Y_7257 MG2_X_8332_Y_7257 0 1.5475e-17
C_MG2_X_8332_Y_7795 MG2_X_8332_Y_7795 0 1.5475e-17
C_MG2_X_8332_Y_806 MG2_X_8332_Y_806 0 1.5475e-17
C_MG2_X_8332_Y_8332 MG2_X_8332_Y_8332 0 1.5475e-17
C_MG2_X_8332_Y_8870 MG2_X_8332_Y_8870 0 1.5475e-17
C_MG2_X_8332_Y_9408 MG2_X_8332_Y_9408 0 1.5475e-17
C_MG2_X_8332_Y_9945 MG2_X_8332_Y_9945 0 1.5475e-17
C_MG2_X_8601_Y_0 MG2_X_8601_Y_0 0 1.5475e-17
C_MG2_X_8601_Y_1075 MG2_X_8601_Y_1075 0 1.5475e-17
C_MG2_X_8601_Y_1612 MG2_X_8601_Y_1612 0 1.5475e-17
C_MG2_X_8601_Y_2150 MG2_X_8601_Y_2150 0 1.5475e-17
C_MG2_X_8601_Y_2688 MG2_X_8601_Y_2688 0 1.5475e-17
C_MG2_X_8601_Y_3225 MG2_X_8601_Y_3225 0 1.5475e-17
C_MG2_X_8601_Y_3763 MG2_X_8601_Y_3763 0 1.5475e-17
C_MG2_X_8601_Y_4300 MG2_X_8601_Y_4300 0 1.5475e-17
C_MG2_X_8601_Y_4838 MG2_X_8601_Y_4838 0 1.5475e-17
C_MG2_X_8601_Y_537 MG2_X_8601_Y_537 0 1.5475e-17
C_MG2_X_8601_Y_5376 MG2_X_8601_Y_5376 0 1.5475e-17
C_MG2_X_8601_Y_5913 MG2_X_8601_Y_5913 0 1.5475e-17
C_MG2_X_8601_Y_6451 MG2_X_8601_Y_6451 0 1.5475e-17
C_MG2_X_8601_Y_6988 MG2_X_8601_Y_6988 0 1.5475e-17
C_MG2_X_8601_Y_7526 MG2_X_8601_Y_7526 0 1.5475e-17
C_MG2_X_8601_Y_8064 MG2_X_8601_Y_8064 0 1.5475e-17
C_MG2_X_8601_Y_8601 MG2_X_8601_Y_8601 0 1.5475e-17
C_MG2_X_8601_Y_9139 MG2_X_8601_Y_9139 0 1.5475e-17
C_MG2_X_8601_Y_9676 MG2_X_8601_Y_9676 0 1.5475e-17
C_MG2_X_8870_Y_1344 MG2_X_8870_Y_1344 0 1.5475e-17
C_MG2_X_8870_Y_1881 MG2_X_8870_Y_1881 0 1.5475e-17
C_MG2_X_8870_Y_2419 MG2_X_8870_Y_2419 0 1.5475e-17
C_MG2_X_8870_Y_268 MG2_X_8870_Y_268 0 1.5475e-17
C_MG2_X_8870_Y_2956 MG2_X_8870_Y_2956 0 1.5475e-17
C_MG2_X_8870_Y_3494 MG2_X_8870_Y_3494 0 1.5475e-17
C_MG2_X_8870_Y_4032 MG2_X_8870_Y_4032 0 1.5475e-17
C_MG2_X_8870_Y_4569 MG2_X_8870_Y_4569 0 1.5475e-17
C_MG2_X_8870_Y_5107 MG2_X_8870_Y_5107 0 1.5475e-17
C_MG2_X_8870_Y_5644 MG2_X_8870_Y_5644 0 1.5475e-17
C_MG2_X_8870_Y_6182 MG2_X_8870_Y_6182 0 1.5475e-17
C_MG2_X_8870_Y_6720 MG2_X_8870_Y_6720 0 1.5475e-17
C_MG2_X_8870_Y_7257 MG2_X_8870_Y_7257 0 1.5475e-17
C_MG2_X_8870_Y_7795 MG2_X_8870_Y_7795 0 1.5475e-17
C_MG2_X_8870_Y_806 MG2_X_8870_Y_806 0 1.5475e-17
C_MG2_X_8870_Y_8332 MG2_X_8870_Y_8332 0 1.5475e-17
C_MG2_X_8870_Y_8870 MG2_X_8870_Y_8870 0 1.5475e-17
C_MG2_X_8870_Y_9408 MG2_X_8870_Y_9408 0 1.5475e-17
C_MG2_X_8870_Y_9945 MG2_X_8870_Y_9945 0 1.5475e-17
C_MG2_X_9139_Y_0 MG2_X_9139_Y_0 0 1.5475e-17
C_MG2_X_9139_Y_1075 MG2_X_9139_Y_1075 0 1.5475e-17
C_MG2_X_9139_Y_1612 MG2_X_9139_Y_1612 0 1.5475e-17
C_MG2_X_9139_Y_2150 MG2_X_9139_Y_2150 0 1.5475e-17
C_MG2_X_9139_Y_2688 MG2_X_9139_Y_2688 0 1.5475e-17
C_MG2_X_9139_Y_3225 MG2_X_9139_Y_3225 0 1.5475e-17
C_MG2_X_9139_Y_3763 MG2_X_9139_Y_3763 0 1.5475e-17
C_MG2_X_9139_Y_4300 MG2_X_9139_Y_4300 0 1.5475e-17
C_MG2_X_9139_Y_4838 MG2_X_9139_Y_4838 0 1.5475e-17
C_MG2_X_9139_Y_537 MG2_X_9139_Y_537 0 1.5475e-17
C_MG2_X_9139_Y_5376 MG2_X_9139_Y_5376 0 1.5475e-17
C_MG2_X_9139_Y_5913 MG2_X_9139_Y_5913 0 1.5475e-17
C_MG2_X_9139_Y_6451 MG2_X_9139_Y_6451 0 1.5475e-17
C_MG2_X_9139_Y_6988 MG2_X_9139_Y_6988 0 1.5475e-17
C_MG2_X_9139_Y_7526 MG2_X_9139_Y_7526 0 1.5475e-17
C_MG2_X_9139_Y_8064 MG2_X_9139_Y_8064 0 1.5475e-17
C_MG2_X_9139_Y_8601 MG2_X_9139_Y_8601 0 1.5475e-17
C_MG2_X_9139_Y_9139 MG2_X_9139_Y_9139 0 1.5475e-17
C_MG2_X_9139_Y_9676 MG2_X_9139_Y_9676 0 1.5475e-17
C_MG2_X_9408_Y_1344 MG2_X_9408_Y_1344 0 1.5475e-17
C_MG2_X_9408_Y_1881 MG2_X_9408_Y_1881 0 1.5475e-17
C_MG2_X_9408_Y_2419 MG2_X_9408_Y_2419 0 1.5475e-17
C_MG2_X_9408_Y_268 MG2_X_9408_Y_268 0 1.5475e-17
C_MG2_X_9408_Y_2956 MG2_X_9408_Y_2956 0 1.5475e-17
C_MG2_X_9408_Y_3494 MG2_X_9408_Y_3494 0 1.5475e-17
C_MG2_X_9408_Y_4032 MG2_X_9408_Y_4032 0 1.5475e-17
C_MG2_X_9408_Y_4569 MG2_X_9408_Y_4569 0 1.5475e-17
C_MG2_X_9408_Y_5107 MG2_X_9408_Y_5107 0 1.5475e-17
C_MG2_X_9408_Y_5644 MG2_X_9408_Y_5644 0 1.5475e-17
C_MG2_X_9408_Y_6182 MG2_X_9408_Y_6182 0 1.5475e-17
C_MG2_X_9408_Y_6720 MG2_X_9408_Y_6720 0 1.5475e-17
C_MG2_X_9408_Y_7257 MG2_X_9408_Y_7257 0 1.5475e-17
C_MG2_X_9408_Y_7795 MG2_X_9408_Y_7795 0 1.5475e-17
C_MG2_X_9408_Y_806 MG2_X_9408_Y_806 0 1.5475e-17
C_MG2_X_9408_Y_8332 MG2_X_9408_Y_8332 0 1.5475e-17
C_MG2_X_9408_Y_8870 MG2_X_9408_Y_8870 0 1.5475e-17
C_MG2_X_9408_Y_9408 MG2_X_9408_Y_9408 0 1.5475e-17
C_MG2_X_9408_Y_9945 MG2_X_9408_Y_9945 0 1.5475e-17
C_MG2_X_9676_Y_0 MG2_X_9676_Y_0 0 1.2389e-17
C_MG2_X_9676_Y_1075 MG2_X_9676_Y_1075 0 1.2389e-17
C_MG2_X_9676_Y_1612 MG2_X_9676_Y_1612 0 1.2389e-17
C_MG2_X_9676_Y_2150 MG2_X_9676_Y_2150 0 1.2389e-17
C_MG2_X_9676_Y_2688 MG2_X_9676_Y_2688 0 1.2389e-17
C_MG2_X_9676_Y_3225 MG2_X_9676_Y_3225 0 1.2389e-17
C_MG2_X_9676_Y_3763 MG2_X_9676_Y_3763 0 1.2389e-17
C_MG2_X_9676_Y_4300 MG2_X_9676_Y_4300 0 1.2389e-17
C_MG2_X_9676_Y_4838 MG2_X_9676_Y_4838 0 1.2389e-17
C_MG2_X_9676_Y_537 MG2_X_9676_Y_537 0 1.2389e-17
C_MG2_X_9676_Y_5376 MG2_X_9676_Y_5376 0 1.2389e-17
C_MG2_X_9676_Y_5913 MG2_X_9676_Y_5913 0 1.2389e-17
C_MG2_X_9676_Y_6451 MG2_X_9676_Y_6451 0 1.2389e-17
C_MG2_X_9676_Y_6988 MG2_X_9676_Y_6988 0 1.2389e-17
C_MG2_X_9676_Y_7526 MG2_X_9676_Y_7526 0 1.2389e-17
C_MG2_X_9676_Y_8064 MG2_X_9676_Y_8064 0 1.2389e-17
C_MG2_X_9676_Y_8601 MG2_X_9676_Y_8601 0 1.2389e-17
C_MG2_X_9676_Y_9139 MG2_X_9676_Y_9139 0 1.2389e-17
C_MG2_X_9676_Y_9676 MG2_X_9676_Y_9676 0 1.2389e-17
C_MG2_X_9945_Y_1344 MG2_X_9945_Y_1344 0 8.5205e-18
C_MG2_X_9945_Y_1881 MG2_X_9945_Y_1881 0 8.5205e-18
C_MG2_X_9945_Y_2419 MG2_X_9945_Y_2419 0 8.5205e-18
C_MG2_X_9945_Y_268 MG2_X_9945_Y_268 0 8.5205e-18
C_MG2_X_9945_Y_2956 MG2_X_9945_Y_2956 0 8.5205e-18
C_MG2_X_9945_Y_3494 MG2_X_9945_Y_3494 0 8.5205e-18
C_MG2_X_9945_Y_4032 MG2_X_9945_Y_4032 0 8.5205e-18
C_MG2_X_9945_Y_4569 MG2_X_9945_Y_4569 0 8.5205e-18
C_MG2_X_9945_Y_5107 MG2_X_9945_Y_5107 0 8.5205e-18
C_MG2_X_9945_Y_5644 MG2_X_9945_Y_5644 0 8.5205e-18
C_MG2_X_9945_Y_6182 MG2_X_9945_Y_6182 0 8.5205e-18
C_MG2_X_9945_Y_6720 MG2_X_9945_Y_6720 0 8.5205e-18
C_MG2_X_9945_Y_7257 MG2_X_9945_Y_7257 0 8.5205e-18
C_MG2_X_9945_Y_7795 MG2_X_9945_Y_7795 0 8.5205e-18
C_MG2_X_9945_Y_806 MG2_X_9945_Y_806 0 8.5205e-18
C_MG2_X_9945_Y_8332 MG2_X_9945_Y_8332 0 8.5205e-18
C_MG2_X_9945_Y_8870 MG2_X_9945_Y_8870 0 8.5205e-18
C_MG2_X_9945_Y_9408 MG2_X_9945_Y_9408 0 8.5205e-18
C_MG2_X_9945_Y_9945 MG2_X_9945_Y_9945 0 8.5205e-18
C_MINT1_X_0_Y_0 MINT1_X_0_Y_0 0 6.8527e-18
C_MINT1_X_0_Y_10000 MINT1_X_0_Y_10000 0 1.7132e-18
C_MINT1_X_0_Y_1024 MINT1_X_0_Y_1024 0 6.8527e-18
C_MINT1_X_0_Y_1280 MINT1_X_0_Y_1280 0 1.2335e-17
C_MINT1_X_0_Y_1600 MINT1_X_0_Y_1600 0 1.3705e-17
C_MINT1_X_0_Y_1920 MINT1_X_0_Y_1920 0 9.5937e-18
C_MINT1_X_0_Y_2048 MINT1_X_0_Y_2048 0 6.8527e-18
C_MINT1_X_0_Y_2240 MINT1_X_0_Y_2240 0 1.0964e-17
C_MINT1_X_0_Y_2560 MINT1_X_0_Y_2560 0 1.3705e-17
C_MINT1_X_0_Y_2880 MINT1_X_0_Y_2880 0 1.0964e-17
C_MINT1_X_0_Y_3072 MINT1_X_0_Y_3072 0 6.8527e-18
C_MINT1_X_0_Y_320 MINT1_X_0_Y_320 0 1.3705e-17
C_MINT1_X_0_Y_3200 MINT1_X_0_Y_3200 0 9.5937e-18
C_MINT1_X_0_Y_3520 MINT1_X_0_Y_3520 0 1.3705e-17
C_MINT1_X_0_Y_3840 MINT1_X_0_Y_3840 0 1.2335e-17
C_MINT1_X_0_Y_4096 MINT1_X_0_Y_4096 0 6.8527e-18
C_MINT1_X_0_Y_4160 MINT1_X_0_Y_4160 0 8.2232e-18
C_MINT1_X_0_Y_4480 MINT1_X_0_Y_4480 0 1.3705e-17
C_MINT1_X_0_Y_4800 MINT1_X_0_Y_4800 0 1.3705e-17
C_MINT1_X_0_Y_5120 MINT1_X_0_Y_5120 0 1.3705e-17
C_MINT1_X_0_Y_5440 MINT1_X_0_Y_5440 0 1.3705e-17
C_MINT1_X_0_Y_5760 MINT1_X_0_Y_5760 0 1.3705e-17
C_MINT1_X_0_Y_6080 MINT1_X_0_Y_6080 0 8.2232e-18
C_MINT1_X_0_Y_6144 MINT1_X_0_Y_6144 0 6.8527e-18
C_MINT1_X_0_Y_640 MINT1_X_0_Y_640 0 1.3705e-17
C_MINT1_X_0_Y_6400 MINT1_X_0_Y_6400 0 1.2335e-17
C_MINT1_X_0_Y_6720 MINT1_X_0_Y_6720 0 1.3705e-17
C_MINT1_X_0_Y_7040 MINT1_X_0_Y_7040 0 9.5937e-18
C_MINT1_X_0_Y_7168 MINT1_X_0_Y_7168 0 6.8527e-18
C_MINT1_X_0_Y_7360 MINT1_X_0_Y_7360 0 1.0964e-17
C_MINT1_X_0_Y_7680 MINT1_X_0_Y_7680 0 1.3705e-17
C_MINT1_X_0_Y_8000 MINT1_X_0_Y_8000 0 1.0964e-17
C_MINT1_X_0_Y_8192 MINT1_X_0_Y_8192 0 6.8527e-18
C_MINT1_X_0_Y_8320 MINT1_X_0_Y_8320 0 9.5937e-18
C_MINT1_X_0_Y_8640 MINT1_X_0_Y_8640 0 1.3705e-17
C_MINT1_X_0_Y_8960 MINT1_X_0_Y_8960 0 1.2335e-17
C_MINT1_X_0_Y_9216 MINT1_X_0_Y_9216 0 6.8527e-18
C_MINT1_X_0_Y_9280 MINT1_X_0_Y_9280 0 8.2232e-18
C_MINT1_X_0_Y_960 MINT1_X_0_Y_960 0 8.2232e-18
C_MINT1_X_0_Y_9600 MINT1_X_0_Y_9600 0 1.3705e-17
C_MINT1_X_0_Y_9920 MINT1_X_0_Y_9920 0 8.5658e-18
C_MINT1_X_1280_Y_0 MINT1_X_1280_Y_0 0 6.8527e-18
C_MINT1_X_1280_Y_10000 MINT1_X_1280_Y_10000 0 1.7132e-18
C_MINT1_X_1280_Y_1024 MINT1_X_1280_Y_1024 0 6.8527e-18
C_MINT1_X_1280_Y_1280 MINT1_X_1280_Y_1280 0 1.2335e-17
C_MINT1_X_1280_Y_1600 MINT1_X_1280_Y_1600 0 1.3705e-17
C_MINT1_X_1280_Y_1920 MINT1_X_1280_Y_1920 0 9.5937e-18
C_MINT1_X_1280_Y_2048 MINT1_X_1280_Y_2048 0 6.8527e-18
C_MINT1_X_1280_Y_2240 MINT1_X_1280_Y_2240 0 1.0964e-17
C_MINT1_X_1280_Y_2560 MINT1_X_1280_Y_2560 0 1.3705e-17
C_MINT1_X_1280_Y_2880 MINT1_X_1280_Y_2880 0 1.0964e-17
C_MINT1_X_1280_Y_3072 MINT1_X_1280_Y_3072 0 6.8527e-18
C_MINT1_X_1280_Y_320 MINT1_X_1280_Y_320 0 1.3705e-17
C_MINT1_X_1280_Y_3200 MINT1_X_1280_Y_3200 0 9.5937e-18
C_MINT1_X_1280_Y_3520 MINT1_X_1280_Y_3520 0 1.3705e-17
C_MINT1_X_1280_Y_3840 MINT1_X_1280_Y_3840 0 1.2335e-17
C_MINT1_X_1280_Y_4096 MINT1_X_1280_Y_4096 0 6.8527e-18
C_MINT1_X_1280_Y_4160 MINT1_X_1280_Y_4160 0 8.2232e-18
C_MINT1_X_1280_Y_4480 MINT1_X_1280_Y_4480 0 1.3705e-17
C_MINT1_X_1280_Y_4800 MINT1_X_1280_Y_4800 0 1.3705e-17
C_MINT1_X_1280_Y_5120 MINT1_X_1280_Y_5120 0 1.3705e-17
C_MINT1_X_1280_Y_5440 MINT1_X_1280_Y_5440 0 1.3705e-17
C_MINT1_X_1280_Y_5760 MINT1_X_1280_Y_5760 0 1.3705e-17
C_MINT1_X_1280_Y_6080 MINT1_X_1280_Y_6080 0 8.2232e-18
C_MINT1_X_1280_Y_6144 MINT1_X_1280_Y_6144 0 6.8527e-18
C_MINT1_X_1280_Y_640 MINT1_X_1280_Y_640 0 1.3705e-17
C_MINT1_X_1280_Y_6400 MINT1_X_1280_Y_6400 0 1.2335e-17
C_MINT1_X_1280_Y_6720 MINT1_X_1280_Y_6720 0 1.3705e-17
C_MINT1_X_1280_Y_7040 MINT1_X_1280_Y_7040 0 9.5937e-18
C_MINT1_X_1280_Y_7168 MINT1_X_1280_Y_7168 0 6.8527e-18
C_MINT1_X_1280_Y_7360 MINT1_X_1280_Y_7360 0 1.0964e-17
C_MINT1_X_1280_Y_7680 MINT1_X_1280_Y_7680 0 1.3705e-17
C_MINT1_X_1280_Y_8000 MINT1_X_1280_Y_8000 0 1.0964e-17
C_MINT1_X_1280_Y_8192 MINT1_X_1280_Y_8192 0 6.8527e-18
C_MINT1_X_1280_Y_8320 MINT1_X_1280_Y_8320 0 9.5937e-18
C_MINT1_X_1280_Y_8640 MINT1_X_1280_Y_8640 0 1.3705e-17
C_MINT1_X_1280_Y_8960 MINT1_X_1280_Y_8960 0 1.2335e-17
C_MINT1_X_1280_Y_9216 MINT1_X_1280_Y_9216 0 6.8527e-18
C_MINT1_X_1280_Y_9280 MINT1_X_1280_Y_9280 0 8.2232e-18
C_MINT1_X_1280_Y_960 MINT1_X_1280_Y_960 0 8.2232e-18
C_MINT1_X_1280_Y_9600 MINT1_X_1280_Y_9600 0 1.3705e-17
C_MINT1_X_1280_Y_9920 MINT1_X_1280_Y_9920 0 8.5658e-18
C_MINT1_X_1600_Y_0 MINT1_X_1600_Y_0 0 6.8527e-18
C_MINT1_X_1600_Y_10000 MINT1_X_1600_Y_10000 0 1.7132e-18
C_MINT1_X_1600_Y_1280 MINT1_X_1600_Y_1280 0 1.2335e-17
C_MINT1_X_1600_Y_1536 MINT1_X_1600_Y_1536 0 6.8527e-18
C_MINT1_X_1600_Y_1600 MINT1_X_1600_Y_1600 0 8.2232e-18
C_MINT1_X_1600_Y_1920 MINT1_X_1600_Y_1920 0 1.3705e-17
C_MINT1_X_1600_Y_2240 MINT1_X_1600_Y_2240 0 1.3705e-17
C_MINT1_X_1600_Y_2560 MINT1_X_1600_Y_2560 0 1.3705e-17
C_MINT1_X_1600_Y_2880 MINT1_X_1600_Y_2880 0 1.3705e-17
C_MINT1_X_1600_Y_320 MINT1_X_1600_Y_320 0 1.0964e-17
C_MINT1_X_1600_Y_3200 MINT1_X_1600_Y_3200 0 1.3705e-17
C_MINT1_X_1600_Y_3520 MINT1_X_1600_Y_3520 0 8.2232e-18
C_MINT1_X_1600_Y_3584 MINT1_X_1600_Y_3584 0 6.8527e-18
C_MINT1_X_1600_Y_3840 MINT1_X_1600_Y_3840 0 1.2335e-17
C_MINT1_X_1600_Y_4160 MINT1_X_1600_Y_4160 0 1.3705e-17
C_MINT1_X_1600_Y_4480 MINT1_X_1600_Y_4480 0 9.5937e-18
C_MINT1_X_1600_Y_4608 MINT1_X_1600_Y_4608 0 6.8527e-18
C_MINT1_X_1600_Y_4800 MINT1_X_1600_Y_4800 0 1.0964e-17
C_MINT1_X_1600_Y_512 MINT1_X_1600_Y_512 0 6.8527e-18
C_MINT1_X_1600_Y_5120 MINT1_X_1600_Y_5120 0 1.3705e-17
C_MINT1_X_1600_Y_5440 MINT1_X_1600_Y_5440 0 1.0964e-17
C_MINT1_X_1600_Y_5632 MINT1_X_1600_Y_5632 0 6.8527e-18
C_MINT1_X_1600_Y_5760 MINT1_X_1600_Y_5760 0 9.5937e-18
C_MINT1_X_1600_Y_6080 MINT1_X_1600_Y_6080 0 1.3705e-17
C_MINT1_X_1600_Y_640 MINT1_X_1600_Y_640 0 9.5937e-18
C_MINT1_X_1600_Y_6400 MINT1_X_1600_Y_6400 0 1.2335e-17
C_MINT1_X_1600_Y_6656 MINT1_X_1600_Y_6656 0 6.8527e-18
C_MINT1_X_1600_Y_6720 MINT1_X_1600_Y_6720 0 8.2232e-18
C_MINT1_X_1600_Y_7040 MINT1_X_1600_Y_7040 0 1.3705e-17
C_MINT1_X_1600_Y_7360 MINT1_X_1600_Y_7360 0 1.3705e-17
C_MINT1_X_1600_Y_7680 MINT1_X_1600_Y_7680 0 1.3705e-17
C_MINT1_X_1600_Y_8000 MINT1_X_1600_Y_8000 0 1.3705e-17
C_MINT1_X_1600_Y_8320 MINT1_X_1600_Y_8320 0 1.3705e-17
C_MINT1_X_1600_Y_8640 MINT1_X_1600_Y_8640 0 8.2232e-18
C_MINT1_X_1600_Y_8704 MINT1_X_1600_Y_8704 0 6.8527e-18
C_MINT1_X_1600_Y_8960 MINT1_X_1600_Y_8960 0 1.2335e-17
C_MINT1_X_1600_Y_9280 MINT1_X_1600_Y_9280 0 1.3705e-17
C_MINT1_X_1600_Y_960 MINT1_X_1600_Y_960 0 1.3705e-17
C_MINT1_X_1600_Y_9600 MINT1_X_1600_Y_9600 0 9.5937e-18
C_MINT1_X_1600_Y_9728 MINT1_X_1600_Y_9728 0 6.8527e-18
C_MINT1_X_1600_Y_9920 MINT1_X_1600_Y_9920 0 5.8248e-18
C_MINT1_X_1920_Y_0 MINT1_X_1920_Y_0 0 6.8527e-18
C_MINT1_X_1920_Y_10000 MINT1_X_1920_Y_10000 0 1.7132e-18
C_MINT1_X_1920_Y_1024 MINT1_X_1920_Y_1024 0 6.8527e-18
C_MINT1_X_1920_Y_1280 MINT1_X_1920_Y_1280 0 1.2335e-17
C_MINT1_X_1920_Y_1600 MINT1_X_1920_Y_1600 0 1.3705e-17
C_MINT1_X_1920_Y_1920 MINT1_X_1920_Y_1920 0 9.5937e-18
C_MINT1_X_1920_Y_2048 MINT1_X_1920_Y_2048 0 6.8527e-18
C_MINT1_X_1920_Y_2240 MINT1_X_1920_Y_2240 0 1.0964e-17
C_MINT1_X_1920_Y_2560 MINT1_X_1920_Y_2560 0 1.3705e-17
C_MINT1_X_1920_Y_2880 MINT1_X_1920_Y_2880 0 1.0964e-17
C_MINT1_X_1920_Y_3072 MINT1_X_1920_Y_3072 0 6.8527e-18
C_MINT1_X_1920_Y_320 MINT1_X_1920_Y_320 0 1.3705e-17
C_MINT1_X_1920_Y_3200 MINT1_X_1920_Y_3200 0 9.5937e-18
C_MINT1_X_1920_Y_3520 MINT1_X_1920_Y_3520 0 1.3705e-17
C_MINT1_X_1920_Y_3840 MINT1_X_1920_Y_3840 0 1.2335e-17
C_MINT1_X_1920_Y_4096 MINT1_X_1920_Y_4096 0 6.8527e-18
C_MINT1_X_1920_Y_4160 MINT1_X_1920_Y_4160 0 8.2232e-18
C_MINT1_X_1920_Y_4480 MINT1_X_1920_Y_4480 0 1.3705e-17
C_MINT1_X_1920_Y_4800 MINT1_X_1920_Y_4800 0 1.3705e-17
C_MINT1_X_1920_Y_5120 MINT1_X_1920_Y_5120 0 1.3705e-17
C_MINT1_X_1920_Y_5440 MINT1_X_1920_Y_5440 0 1.3705e-17
C_MINT1_X_1920_Y_5760 MINT1_X_1920_Y_5760 0 1.3705e-17
C_MINT1_X_1920_Y_6080 MINT1_X_1920_Y_6080 0 8.2232e-18
C_MINT1_X_1920_Y_6144 MINT1_X_1920_Y_6144 0 6.8527e-18
C_MINT1_X_1920_Y_640 MINT1_X_1920_Y_640 0 1.3705e-17
C_MINT1_X_1920_Y_6400 MINT1_X_1920_Y_6400 0 1.2335e-17
C_MINT1_X_1920_Y_6720 MINT1_X_1920_Y_6720 0 1.3705e-17
C_MINT1_X_1920_Y_7040 MINT1_X_1920_Y_7040 0 9.5937e-18
C_MINT1_X_1920_Y_7168 MINT1_X_1920_Y_7168 0 6.8527e-18
C_MINT1_X_1920_Y_7360 MINT1_X_1920_Y_7360 0 1.0964e-17
C_MINT1_X_1920_Y_7680 MINT1_X_1920_Y_7680 0 1.3705e-17
C_MINT1_X_1920_Y_8000 MINT1_X_1920_Y_8000 0 1.0964e-17
C_MINT1_X_1920_Y_8192 MINT1_X_1920_Y_8192 0 6.8527e-18
C_MINT1_X_1920_Y_8320 MINT1_X_1920_Y_8320 0 9.5937e-18
C_MINT1_X_1920_Y_8640 MINT1_X_1920_Y_8640 0 1.3705e-17
C_MINT1_X_1920_Y_8960 MINT1_X_1920_Y_8960 0 1.2335e-17
C_MINT1_X_1920_Y_9216 MINT1_X_1920_Y_9216 0 6.8527e-18
C_MINT1_X_1920_Y_9280 MINT1_X_1920_Y_9280 0 8.2232e-18
C_MINT1_X_1920_Y_960 MINT1_X_1920_Y_960 0 8.2232e-18
C_MINT1_X_1920_Y_9600 MINT1_X_1920_Y_9600 0 1.3705e-17
C_MINT1_X_1920_Y_9920 MINT1_X_1920_Y_9920 0 8.5658e-18
C_MINT1_X_2240_Y_0 MINT1_X_2240_Y_0 0 6.8527e-18
C_MINT1_X_2240_Y_10000 MINT1_X_2240_Y_10000 0 1.7132e-18
C_MINT1_X_2240_Y_1280 MINT1_X_2240_Y_1280 0 1.2335e-17
C_MINT1_X_2240_Y_1536 MINT1_X_2240_Y_1536 0 6.8527e-18
C_MINT1_X_2240_Y_1600 MINT1_X_2240_Y_1600 0 8.2232e-18
C_MINT1_X_2240_Y_1920 MINT1_X_2240_Y_1920 0 1.3705e-17
C_MINT1_X_2240_Y_2240 MINT1_X_2240_Y_2240 0 1.3705e-17
C_MINT1_X_2240_Y_2560 MINT1_X_2240_Y_2560 0 1.3705e-17
C_MINT1_X_2240_Y_2880 MINT1_X_2240_Y_2880 0 1.3705e-17
C_MINT1_X_2240_Y_320 MINT1_X_2240_Y_320 0 1.0964e-17
C_MINT1_X_2240_Y_3200 MINT1_X_2240_Y_3200 0 1.3705e-17
C_MINT1_X_2240_Y_3520 MINT1_X_2240_Y_3520 0 8.2232e-18
C_MINT1_X_2240_Y_3584 MINT1_X_2240_Y_3584 0 6.8527e-18
C_MINT1_X_2240_Y_3840 MINT1_X_2240_Y_3840 0 1.2335e-17
C_MINT1_X_2240_Y_4160 MINT1_X_2240_Y_4160 0 1.3705e-17
C_MINT1_X_2240_Y_4480 MINT1_X_2240_Y_4480 0 9.5937e-18
C_MINT1_X_2240_Y_4608 MINT1_X_2240_Y_4608 0 6.8527e-18
C_MINT1_X_2240_Y_4800 MINT1_X_2240_Y_4800 0 1.0964e-17
C_MINT1_X_2240_Y_512 MINT1_X_2240_Y_512 0 6.8527e-18
C_MINT1_X_2240_Y_5120 MINT1_X_2240_Y_5120 0 1.3705e-17
C_MINT1_X_2240_Y_5440 MINT1_X_2240_Y_5440 0 1.0964e-17
C_MINT1_X_2240_Y_5632 MINT1_X_2240_Y_5632 0 6.8527e-18
C_MINT1_X_2240_Y_5760 MINT1_X_2240_Y_5760 0 9.5937e-18
C_MINT1_X_2240_Y_6080 MINT1_X_2240_Y_6080 0 1.3705e-17
C_MINT1_X_2240_Y_640 MINT1_X_2240_Y_640 0 9.5937e-18
C_MINT1_X_2240_Y_6400 MINT1_X_2240_Y_6400 0 1.2335e-17
C_MINT1_X_2240_Y_6656 MINT1_X_2240_Y_6656 0 6.8527e-18
C_MINT1_X_2240_Y_6720 MINT1_X_2240_Y_6720 0 8.2232e-18
C_MINT1_X_2240_Y_7040 MINT1_X_2240_Y_7040 0 1.3705e-17
C_MINT1_X_2240_Y_7360 MINT1_X_2240_Y_7360 0 1.3705e-17
C_MINT1_X_2240_Y_7680 MINT1_X_2240_Y_7680 0 1.3705e-17
C_MINT1_X_2240_Y_8000 MINT1_X_2240_Y_8000 0 1.3705e-17
C_MINT1_X_2240_Y_8320 MINT1_X_2240_Y_8320 0 1.3705e-17
C_MINT1_X_2240_Y_8640 MINT1_X_2240_Y_8640 0 8.2232e-18
C_MINT1_X_2240_Y_8704 MINT1_X_2240_Y_8704 0 6.8527e-18
C_MINT1_X_2240_Y_8960 MINT1_X_2240_Y_8960 0 1.2335e-17
C_MINT1_X_2240_Y_9280 MINT1_X_2240_Y_9280 0 1.3705e-17
C_MINT1_X_2240_Y_960 MINT1_X_2240_Y_960 0 1.3705e-17
C_MINT1_X_2240_Y_9600 MINT1_X_2240_Y_9600 0 9.5937e-18
C_MINT1_X_2240_Y_9728 MINT1_X_2240_Y_9728 0 6.8527e-18
C_MINT1_X_2240_Y_9920 MINT1_X_2240_Y_9920 0 5.8248e-18
C_MINT1_X_2560_Y_0 MINT1_X_2560_Y_0 0 6.8527e-18
C_MINT1_X_2560_Y_10000 MINT1_X_2560_Y_10000 0 1.7132e-18
C_MINT1_X_2560_Y_1024 MINT1_X_2560_Y_1024 0 6.8527e-18
C_MINT1_X_2560_Y_1280 MINT1_X_2560_Y_1280 0 1.2335e-17
C_MINT1_X_2560_Y_1600 MINT1_X_2560_Y_1600 0 1.3705e-17
C_MINT1_X_2560_Y_1920 MINT1_X_2560_Y_1920 0 9.5937e-18
C_MINT1_X_2560_Y_2048 MINT1_X_2560_Y_2048 0 6.8527e-18
C_MINT1_X_2560_Y_2240 MINT1_X_2560_Y_2240 0 1.0964e-17
C_MINT1_X_2560_Y_2560 MINT1_X_2560_Y_2560 0 1.3705e-17
C_MINT1_X_2560_Y_2880 MINT1_X_2560_Y_2880 0 1.0964e-17
C_MINT1_X_2560_Y_3072 MINT1_X_2560_Y_3072 0 6.8527e-18
C_MINT1_X_2560_Y_320 MINT1_X_2560_Y_320 0 1.3705e-17
C_MINT1_X_2560_Y_3200 MINT1_X_2560_Y_3200 0 9.5937e-18
C_MINT1_X_2560_Y_3520 MINT1_X_2560_Y_3520 0 1.3705e-17
C_MINT1_X_2560_Y_3840 MINT1_X_2560_Y_3840 0 1.2335e-17
C_MINT1_X_2560_Y_4096 MINT1_X_2560_Y_4096 0 6.8527e-18
C_MINT1_X_2560_Y_4160 MINT1_X_2560_Y_4160 0 8.2232e-18
C_MINT1_X_2560_Y_4480 MINT1_X_2560_Y_4480 0 1.3705e-17
C_MINT1_X_2560_Y_4800 MINT1_X_2560_Y_4800 0 1.3705e-17
C_MINT1_X_2560_Y_5120 MINT1_X_2560_Y_5120 0 1.3705e-17
C_MINT1_X_2560_Y_5440 MINT1_X_2560_Y_5440 0 1.3705e-17
C_MINT1_X_2560_Y_5760 MINT1_X_2560_Y_5760 0 1.3705e-17
C_MINT1_X_2560_Y_6080 MINT1_X_2560_Y_6080 0 8.2232e-18
C_MINT1_X_2560_Y_6144 MINT1_X_2560_Y_6144 0 6.8527e-18
C_MINT1_X_2560_Y_640 MINT1_X_2560_Y_640 0 1.3705e-17
C_MINT1_X_2560_Y_6400 MINT1_X_2560_Y_6400 0 1.2335e-17
C_MINT1_X_2560_Y_6720 MINT1_X_2560_Y_6720 0 1.3705e-17
C_MINT1_X_2560_Y_7040 MINT1_X_2560_Y_7040 0 9.5937e-18
C_MINT1_X_2560_Y_7168 MINT1_X_2560_Y_7168 0 6.8527e-18
C_MINT1_X_2560_Y_7360 MINT1_X_2560_Y_7360 0 1.0964e-17
C_MINT1_X_2560_Y_7680 MINT1_X_2560_Y_7680 0 1.3705e-17
C_MINT1_X_2560_Y_8000 MINT1_X_2560_Y_8000 0 1.0964e-17
C_MINT1_X_2560_Y_8192 MINT1_X_2560_Y_8192 0 6.8527e-18
C_MINT1_X_2560_Y_8320 MINT1_X_2560_Y_8320 0 9.5937e-18
C_MINT1_X_2560_Y_8640 MINT1_X_2560_Y_8640 0 1.3705e-17
C_MINT1_X_2560_Y_8960 MINT1_X_2560_Y_8960 0 1.2335e-17
C_MINT1_X_2560_Y_9216 MINT1_X_2560_Y_9216 0 6.8527e-18
C_MINT1_X_2560_Y_9280 MINT1_X_2560_Y_9280 0 8.2232e-18
C_MINT1_X_2560_Y_960 MINT1_X_2560_Y_960 0 8.2232e-18
C_MINT1_X_2560_Y_9600 MINT1_X_2560_Y_9600 0 1.3705e-17
C_MINT1_X_2560_Y_9920 MINT1_X_2560_Y_9920 0 8.5658e-18
C_MINT1_X_2880_Y_0 MINT1_X_2880_Y_0 0 6.8527e-18
C_MINT1_X_2880_Y_10000 MINT1_X_2880_Y_10000 0 1.7132e-18
C_MINT1_X_2880_Y_1280 MINT1_X_2880_Y_1280 0 1.2335e-17
C_MINT1_X_2880_Y_1536 MINT1_X_2880_Y_1536 0 6.8527e-18
C_MINT1_X_2880_Y_1600 MINT1_X_2880_Y_1600 0 8.2232e-18
C_MINT1_X_2880_Y_1920 MINT1_X_2880_Y_1920 0 1.3705e-17
C_MINT1_X_2880_Y_2240 MINT1_X_2880_Y_2240 0 1.3705e-17
C_MINT1_X_2880_Y_2560 MINT1_X_2880_Y_2560 0 1.3705e-17
C_MINT1_X_2880_Y_2880 MINT1_X_2880_Y_2880 0 1.3705e-17
C_MINT1_X_2880_Y_320 MINT1_X_2880_Y_320 0 1.0964e-17
C_MINT1_X_2880_Y_3200 MINT1_X_2880_Y_3200 0 1.3705e-17
C_MINT1_X_2880_Y_3520 MINT1_X_2880_Y_3520 0 8.2232e-18
C_MINT1_X_2880_Y_3584 MINT1_X_2880_Y_3584 0 6.8527e-18
C_MINT1_X_2880_Y_3840 MINT1_X_2880_Y_3840 0 1.2335e-17
C_MINT1_X_2880_Y_4160 MINT1_X_2880_Y_4160 0 1.3705e-17
C_MINT1_X_2880_Y_4480 MINT1_X_2880_Y_4480 0 9.5937e-18
C_MINT1_X_2880_Y_4608 MINT1_X_2880_Y_4608 0 6.8527e-18
C_MINT1_X_2880_Y_4800 MINT1_X_2880_Y_4800 0 1.0964e-17
C_MINT1_X_2880_Y_512 MINT1_X_2880_Y_512 0 6.8527e-18
C_MINT1_X_2880_Y_5120 MINT1_X_2880_Y_5120 0 1.3705e-17
C_MINT1_X_2880_Y_5440 MINT1_X_2880_Y_5440 0 1.0964e-17
C_MINT1_X_2880_Y_5632 MINT1_X_2880_Y_5632 0 6.8527e-18
C_MINT1_X_2880_Y_5760 MINT1_X_2880_Y_5760 0 9.5937e-18
C_MINT1_X_2880_Y_6080 MINT1_X_2880_Y_6080 0 1.3705e-17
C_MINT1_X_2880_Y_640 MINT1_X_2880_Y_640 0 9.5937e-18
C_MINT1_X_2880_Y_6400 MINT1_X_2880_Y_6400 0 1.2335e-17
C_MINT1_X_2880_Y_6656 MINT1_X_2880_Y_6656 0 6.8527e-18
C_MINT1_X_2880_Y_6720 MINT1_X_2880_Y_6720 0 8.2232e-18
C_MINT1_X_2880_Y_7040 MINT1_X_2880_Y_7040 0 1.3705e-17
C_MINT1_X_2880_Y_7360 MINT1_X_2880_Y_7360 0 1.3705e-17
C_MINT1_X_2880_Y_7680 MINT1_X_2880_Y_7680 0 1.3705e-17
C_MINT1_X_2880_Y_8000 MINT1_X_2880_Y_8000 0 1.3705e-17
C_MINT1_X_2880_Y_8320 MINT1_X_2880_Y_8320 0 1.3705e-17
C_MINT1_X_2880_Y_8640 MINT1_X_2880_Y_8640 0 8.2232e-18
C_MINT1_X_2880_Y_8704 MINT1_X_2880_Y_8704 0 6.8527e-18
C_MINT1_X_2880_Y_8960 MINT1_X_2880_Y_8960 0 1.2335e-17
C_MINT1_X_2880_Y_9280 MINT1_X_2880_Y_9280 0 1.3705e-17
C_MINT1_X_2880_Y_960 MINT1_X_2880_Y_960 0 1.3705e-17
C_MINT1_X_2880_Y_9600 MINT1_X_2880_Y_9600 0 9.5937e-18
C_MINT1_X_2880_Y_9728 MINT1_X_2880_Y_9728 0 6.8527e-18
C_MINT1_X_2880_Y_9920 MINT1_X_2880_Y_9920 0 5.8248e-18
C_MINT1_X_3200_Y_0 MINT1_X_3200_Y_0 0 6.8527e-18
C_MINT1_X_3200_Y_10000 MINT1_X_3200_Y_10000 0 1.7132e-18
C_MINT1_X_3200_Y_1024 MINT1_X_3200_Y_1024 0 6.8527e-18
C_MINT1_X_3200_Y_1280 MINT1_X_3200_Y_1280 0 1.2335e-17
C_MINT1_X_3200_Y_1600 MINT1_X_3200_Y_1600 0 1.3705e-17
C_MINT1_X_3200_Y_1920 MINT1_X_3200_Y_1920 0 9.5937e-18
C_MINT1_X_3200_Y_2048 MINT1_X_3200_Y_2048 0 6.8527e-18
C_MINT1_X_3200_Y_2240 MINT1_X_3200_Y_2240 0 1.0964e-17
C_MINT1_X_3200_Y_2560 MINT1_X_3200_Y_2560 0 1.3705e-17
C_MINT1_X_3200_Y_2880 MINT1_X_3200_Y_2880 0 1.0964e-17
C_MINT1_X_3200_Y_3072 MINT1_X_3200_Y_3072 0 6.8527e-18
C_MINT1_X_3200_Y_320 MINT1_X_3200_Y_320 0 1.3705e-17
C_MINT1_X_3200_Y_3200 MINT1_X_3200_Y_3200 0 9.5937e-18
C_MINT1_X_3200_Y_3520 MINT1_X_3200_Y_3520 0 1.3705e-17
C_MINT1_X_3200_Y_3840 MINT1_X_3200_Y_3840 0 1.2335e-17
C_MINT1_X_3200_Y_4096 MINT1_X_3200_Y_4096 0 6.8527e-18
C_MINT1_X_3200_Y_4160 MINT1_X_3200_Y_4160 0 8.2232e-18
C_MINT1_X_3200_Y_4480 MINT1_X_3200_Y_4480 0 1.3705e-17
C_MINT1_X_3200_Y_4800 MINT1_X_3200_Y_4800 0 1.3705e-17
C_MINT1_X_3200_Y_5120 MINT1_X_3200_Y_5120 0 1.3705e-17
C_MINT1_X_3200_Y_5440 MINT1_X_3200_Y_5440 0 1.3705e-17
C_MINT1_X_3200_Y_5760 MINT1_X_3200_Y_5760 0 1.3705e-17
C_MINT1_X_3200_Y_6080 MINT1_X_3200_Y_6080 0 8.2232e-18
C_MINT1_X_3200_Y_6144 MINT1_X_3200_Y_6144 0 6.8527e-18
C_MINT1_X_3200_Y_640 MINT1_X_3200_Y_640 0 1.3705e-17
C_MINT1_X_3200_Y_6400 MINT1_X_3200_Y_6400 0 1.2335e-17
C_MINT1_X_3200_Y_6720 MINT1_X_3200_Y_6720 0 1.3705e-17
C_MINT1_X_3200_Y_7040 MINT1_X_3200_Y_7040 0 9.5937e-18
C_MINT1_X_3200_Y_7168 MINT1_X_3200_Y_7168 0 6.8527e-18
C_MINT1_X_3200_Y_7360 MINT1_X_3200_Y_7360 0 1.0964e-17
C_MINT1_X_3200_Y_7680 MINT1_X_3200_Y_7680 0 1.3705e-17
C_MINT1_X_3200_Y_8000 MINT1_X_3200_Y_8000 0 1.0964e-17
C_MINT1_X_3200_Y_8192 MINT1_X_3200_Y_8192 0 6.8527e-18
C_MINT1_X_3200_Y_8320 MINT1_X_3200_Y_8320 0 9.5937e-18
C_MINT1_X_3200_Y_8640 MINT1_X_3200_Y_8640 0 1.3705e-17
C_MINT1_X_3200_Y_8960 MINT1_X_3200_Y_8960 0 1.2335e-17
C_MINT1_X_3200_Y_9216 MINT1_X_3200_Y_9216 0 6.8527e-18
C_MINT1_X_3200_Y_9280 MINT1_X_3200_Y_9280 0 8.2232e-18
C_MINT1_X_3200_Y_960 MINT1_X_3200_Y_960 0 8.2232e-18
C_MINT1_X_3200_Y_9600 MINT1_X_3200_Y_9600 0 1.3705e-17
C_MINT1_X_3200_Y_9920 MINT1_X_3200_Y_9920 0 8.5658e-18
C_MINT1_X_320_Y_0 MINT1_X_320_Y_0 0 6.8527e-18
C_MINT1_X_320_Y_10000 MINT1_X_320_Y_10000 0 1.7132e-18
C_MINT1_X_320_Y_1280 MINT1_X_320_Y_1280 0 1.2335e-17
C_MINT1_X_320_Y_1536 MINT1_X_320_Y_1536 0 6.8527e-18
C_MINT1_X_320_Y_1600 MINT1_X_320_Y_1600 0 8.2232e-18
C_MINT1_X_320_Y_1920 MINT1_X_320_Y_1920 0 1.3705e-17
C_MINT1_X_320_Y_2240 MINT1_X_320_Y_2240 0 1.3705e-17
C_MINT1_X_320_Y_2560 MINT1_X_320_Y_2560 0 1.3705e-17
C_MINT1_X_320_Y_2880 MINT1_X_320_Y_2880 0 1.3705e-17
C_MINT1_X_320_Y_320 MINT1_X_320_Y_320 0 1.0964e-17
C_MINT1_X_320_Y_3200 MINT1_X_320_Y_3200 0 1.3705e-17
C_MINT1_X_320_Y_3520 MINT1_X_320_Y_3520 0 8.2232e-18
C_MINT1_X_320_Y_3584 MINT1_X_320_Y_3584 0 6.8527e-18
C_MINT1_X_320_Y_3840 MINT1_X_320_Y_3840 0 1.2335e-17
C_MINT1_X_320_Y_4160 MINT1_X_320_Y_4160 0 1.3705e-17
C_MINT1_X_320_Y_4480 MINT1_X_320_Y_4480 0 9.5937e-18
C_MINT1_X_320_Y_4608 MINT1_X_320_Y_4608 0 6.8527e-18
C_MINT1_X_320_Y_4800 MINT1_X_320_Y_4800 0 1.0964e-17
C_MINT1_X_320_Y_512 MINT1_X_320_Y_512 0 6.8527e-18
C_MINT1_X_320_Y_5120 MINT1_X_320_Y_5120 0 1.3705e-17
C_MINT1_X_320_Y_5440 MINT1_X_320_Y_5440 0 1.0964e-17
C_MINT1_X_320_Y_5632 MINT1_X_320_Y_5632 0 6.8527e-18
C_MINT1_X_320_Y_5760 MINT1_X_320_Y_5760 0 9.5937e-18
C_MINT1_X_320_Y_6080 MINT1_X_320_Y_6080 0 1.3705e-17
C_MINT1_X_320_Y_640 MINT1_X_320_Y_640 0 9.5937e-18
C_MINT1_X_320_Y_6400 MINT1_X_320_Y_6400 0 1.2335e-17
C_MINT1_X_320_Y_6656 MINT1_X_320_Y_6656 0 6.8527e-18
C_MINT1_X_320_Y_6720 MINT1_X_320_Y_6720 0 8.2232e-18
C_MINT1_X_320_Y_7040 MINT1_X_320_Y_7040 0 1.3705e-17
C_MINT1_X_320_Y_7360 MINT1_X_320_Y_7360 0 1.3705e-17
C_MINT1_X_320_Y_7680 MINT1_X_320_Y_7680 0 1.3705e-17
C_MINT1_X_320_Y_8000 MINT1_X_320_Y_8000 0 1.3705e-17
C_MINT1_X_320_Y_8320 MINT1_X_320_Y_8320 0 1.3705e-17
C_MINT1_X_320_Y_8640 MINT1_X_320_Y_8640 0 8.2232e-18
C_MINT1_X_320_Y_8704 MINT1_X_320_Y_8704 0 6.8527e-18
C_MINT1_X_320_Y_8960 MINT1_X_320_Y_8960 0 1.2335e-17
C_MINT1_X_320_Y_9280 MINT1_X_320_Y_9280 0 1.3705e-17
C_MINT1_X_320_Y_960 MINT1_X_320_Y_960 0 1.3705e-17
C_MINT1_X_320_Y_9600 MINT1_X_320_Y_9600 0 9.5937e-18
C_MINT1_X_320_Y_9728 MINT1_X_320_Y_9728 0 6.8527e-18
C_MINT1_X_320_Y_9920 MINT1_X_320_Y_9920 0 5.8248e-18
C_MINT1_X_3520_Y_0 MINT1_X_3520_Y_0 0 6.8527e-18
C_MINT1_X_3520_Y_10000 MINT1_X_3520_Y_10000 0 1.7132e-18
C_MINT1_X_3520_Y_1280 MINT1_X_3520_Y_1280 0 1.2335e-17
C_MINT1_X_3520_Y_1536 MINT1_X_3520_Y_1536 0 6.8527e-18
C_MINT1_X_3520_Y_1600 MINT1_X_3520_Y_1600 0 8.2232e-18
C_MINT1_X_3520_Y_1920 MINT1_X_3520_Y_1920 0 1.3705e-17
C_MINT1_X_3520_Y_2240 MINT1_X_3520_Y_2240 0 1.3705e-17
C_MINT1_X_3520_Y_2560 MINT1_X_3520_Y_2560 0 1.3705e-17
C_MINT1_X_3520_Y_2880 MINT1_X_3520_Y_2880 0 1.3705e-17
C_MINT1_X_3520_Y_320 MINT1_X_3520_Y_320 0 1.0964e-17
C_MINT1_X_3520_Y_3200 MINT1_X_3520_Y_3200 0 1.3705e-17
C_MINT1_X_3520_Y_3520 MINT1_X_3520_Y_3520 0 8.2232e-18
C_MINT1_X_3520_Y_3584 MINT1_X_3520_Y_3584 0 6.8527e-18
C_MINT1_X_3520_Y_3840 MINT1_X_3520_Y_3840 0 1.2335e-17
C_MINT1_X_3520_Y_4160 MINT1_X_3520_Y_4160 0 1.3705e-17
C_MINT1_X_3520_Y_4480 MINT1_X_3520_Y_4480 0 9.5937e-18
C_MINT1_X_3520_Y_4608 MINT1_X_3520_Y_4608 0 6.8527e-18
C_MINT1_X_3520_Y_4800 MINT1_X_3520_Y_4800 0 1.0964e-17
C_MINT1_X_3520_Y_512 MINT1_X_3520_Y_512 0 6.8527e-18
C_MINT1_X_3520_Y_5120 MINT1_X_3520_Y_5120 0 1.3705e-17
C_MINT1_X_3520_Y_5440 MINT1_X_3520_Y_5440 0 1.0964e-17
C_MINT1_X_3520_Y_5632 MINT1_X_3520_Y_5632 0 6.8527e-18
C_MINT1_X_3520_Y_5760 MINT1_X_3520_Y_5760 0 9.5937e-18
C_MINT1_X_3520_Y_6080 MINT1_X_3520_Y_6080 0 1.3705e-17
C_MINT1_X_3520_Y_640 MINT1_X_3520_Y_640 0 9.5937e-18
C_MINT1_X_3520_Y_6400 MINT1_X_3520_Y_6400 0 1.2335e-17
C_MINT1_X_3520_Y_6656 MINT1_X_3520_Y_6656 0 6.8527e-18
C_MINT1_X_3520_Y_6720 MINT1_X_3520_Y_6720 0 8.2232e-18
C_MINT1_X_3520_Y_7040 MINT1_X_3520_Y_7040 0 1.3705e-17
C_MINT1_X_3520_Y_7360 MINT1_X_3520_Y_7360 0 1.3705e-17
C_MINT1_X_3520_Y_7680 MINT1_X_3520_Y_7680 0 1.3705e-17
C_MINT1_X_3520_Y_8000 MINT1_X_3520_Y_8000 0 1.3705e-17
C_MINT1_X_3520_Y_8320 MINT1_X_3520_Y_8320 0 1.3705e-17
C_MINT1_X_3520_Y_8640 MINT1_X_3520_Y_8640 0 8.2232e-18
C_MINT1_X_3520_Y_8704 MINT1_X_3520_Y_8704 0 6.8527e-18
C_MINT1_X_3520_Y_8960 MINT1_X_3520_Y_8960 0 1.2335e-17
C_MINT1_X_3520_Y_9280 MINT1_X_3520_Y_9280 0 1.3705e-17
C_MINT1_X_3520_Y_960 MINT1_X_3520_Y_960 0 1.3705e-17
C_MINT1_X_3520_Y_9600 MINT1_X_3520_Y_9600 0 9.5937e-18
C_MINT1_X_3520_Y_9728 MINT1_X_3520_Y_9728 0 6.8527e-18
C_MINT1_X_3520_Y_9920 MINT1_X_3520_Y_9920 0 5.8248e-18
C_MINT1_X_3840_Y_0 MINT1_X_3840_Y_0 0 6.8527e-18
C_MINT1_X_3840_Y_10000 MINT1_X_3840_Y_10000 0 1.7132e-18
C_MINT1_X_3840_Y_1024 MINT1_X_3840_Y_1024 0 6.8527e-18
C_MINT1_X_3840_Y_1280 MINT1_X_3840_Y_1280 0 1.2335e-17
C_MINT1_X_3840_Y_1600 MINT1_X_3840_Y_1600 0 1.3705e-17
C_MINT1_X_3840_Y_1920 MINT1_X_3840_Y_1920 0 9.5937e-18
C_MINT1_X_3840_Y_2048 MINT1_X_3840_Y_2048 0 6.8527e-18
C_MINT1_X_3840_Y_2240 MINT1_X_3840_Y_2240 0 1.0964e-17
C_MINT1_X_3840_Y_2560 MINT1_X_3840_Y_2560 0 1.3705e-17
C_MINT1_X_3840_Y_2880 MINT1_X_3840_Y_2880 0 1.0964e-17
C_MINT1_X_3840_Y_3072 MINT1_X_3840_Y_3072 0 6.8527e-18
C_MINT1_X_3840_Y_320 MINT1_X_3840_Y_320 0 1.3705e-17
C_MINT1_X_3840_Y_3200 MINT1_X_3840_Y_3200 0 9.5937e-18
C_MINT1_X_3840_Y_3520 MINT1_X_3840_Y_3520 0 1.3705e-17
C_MINT1_X_3840_Y_3840 MINT1_X_3840_Y_3840 0 1.2335e-17
C_MINT1_X_3840_Y_4096 MINT1_X_3840_Y_4096 0 6.8527e-18
C_MINT1_X_3840_Y_4160 MINT1_X_3840_Y_4160 0 8.2232e-18
C_MINT1_X_3840_Y_4480 MINT1_X_3840_Y_4480 0 1.3705e-17
C_MINT1_X_3840_Y_4800 MINT1_X_3840_Y_4800 0 1.3705e-17
C_MINT1_X_3840_Y_5120 MINT1_X_3840_Y_5120 0 1.3705e-17
C_MINT1_X_3840_Y_5440 MINT1_X_3840_Y_5440 0 1.3705e-17
C_MINT1_X_3840_Y_5760 MINT1_X_3840_Y_5760 0 1.3705e-17
C_MINT1_X_3840_Y_6080 MINT1_X_3840_Y_6080 0 8.2232e-18
C_MINT1_X_3840_Y_6144 MINT1_X_3840_Y_6144 0 6.8527e-18
C_MINT1_X_3840_Y_640 MINT1_X_3840_Y_640 0 1.3705e-17
C_MINT1_X_3840_Y_6400 MINT1_X_3840_Y_6400 0 1.2335e-17
C_MINT1_X_3840_Y_6720 MINT1_X_3840_Y_6720 0 1.3705e-17
C_MINT1_X_3840_Y_7040 MINT1_X_3840_Y_7040 0 9.5937e-18
C_MINT1_X_3840_Y_7168 MINT1_X_3840_Y_7168 0 6.8527e-18
C_MINT1_X_3840_Y_7360 MINT1_X_3840_Y_7360 0 1.0964e-17
C_MINT1_X_3840_Y_7680 MINT1_X_3840_Y_7680 0 1.3705e-17
C_MINT1_X_3840_Y_8000 MINT1_X_3840_Y_8000 0 1.0964e-17
C_MINT1_X_3840_Y_8192 MINT1_X_3840_Y_8192 0 6.8527e-18
C_MINT1_X_3840_Y_8320 MINT1_X_3840_Y_8320 0 9.5937e-18
C_MINT1_X_3840_Y_8640 MINT1_X_3840_Y_8640 0 1.3705e-17
C_MINT1_X_3840_Y_8960 MINT1_X_3840_Y_8960 0 1.2335e-17
C_MINT1_X_3840_Y_9216 MINT1_X_3840_Y_9216 0 6.8527e-18
C_MINT1_X_3840_Y_9280 MINT1_X_3840_Y_9280 0 8.2232e-18
C_MINT1_X_3840_Y_960 MINT1_X_3840_Y_960 0 8.2232e-18
C_MINT1_X_3840_Y_9600 MINT1_X_3840_Y_9600 0 1.3705e-17
C_MINT1_X_3840_Y_9920 MINT1_X_3840_Y_9920 0 8.5658e-18
C_MINT1_X_4160_Y_0 MINT1_X_4160_Y_0 0 6.8527e-18
C_MINT1_X_4160_Y_10000 MINT1_X_4160_Y_10000 0 1.7132e-18
C_MINT1_X_4160_Y_1280 MINT1_X_4160_Y_1280 0 1.2335e-17
C_MINT1_X_4160_Y_1536 MINT1_X_4160_Y_1536 0 6.8527e-18
C_MINT1_X_4160_Y_1600 MINT1_X_4160_Y_1600 0 8.2232e-18
C_MINT1_X_4160_Y_1920 MINT1_X_4160_Y_1920 0 1.3705e-17
C_MINT1_X_4160_Y_2240 MINT1_X_4160_Y_2240 0 1.3705e-17
C_MINT1_X_4160_Y_2560 MINT1_X_4160_Y_2560 0 1.3705e-17
C_MINT1_X_4160_Y_2880 MINT1_X_4160_Y_2880 0 1.3705e-17
C_MINT1_X_4160_Y_320 MINT1_X_4160_Y_320 0 1.0964e-17
C_MINT1_X_4160_Y_3200 MINT1_X_4160_Y_3200 0 1.3705e-17
C_MINT1_X_4160_Y_3520 MINT1_X_4160_Y_3520 0 8.2232e-18
C_MINT1_X_4160_Y_3584 MINT1_X_4160_Y_3584 0 6.8527e-18
C_MINT1_X_4160_Y_3840 MINT1_X_4160_Y_3840 0 1.2335e-17
C_MINT1_X_4160_Y_4160 MINT1_X_4160_Y_4160 0 1.3705e-17
C_MINT1_X_4160_Y_4480 MINT1_X_4160_Y_4480 0 9.5937e-18
C_MINT1_X_4160_Y_4608 MINT1_X_4160_Y_4608 0 6.8527e-18
C_MINT1_X_4160_Y_4800 MINT1_X_4160_Y_4800 0 1.0964e-17
C_MINT1_X_4160_Y_512 MINT1_X_4160_Y_512 0 6.8527e-18
C_MINT1_X_4160_Y_5120 MINT1_X_4160_Y_5120 0 1.3705e-17
C_MINT1_X_4160_Y_5440 MINT1_X_4160_Y_5440 0 1.0964e-17
C_MINT1_X_4160_Y_5632 MINT1_X_4160_Y_5632 0 6.8527e-18
C_MINT1_X_4160_Y_5760 MINT1_X_4160_Y_5760 0 9.5937e-18
C_MINT1_X_4160_Y_6080 MINT1_X_4160_Y_6080 0 1.3705e-17
C_MINT1_X_4160_Y_640 MINT1_X_4160_Y_640 0 9.5937e-18
C_MINT1_X_4160_Y_6400 MINT1_X_4160_Y_6400 0 1.2335e-17
C_MINT1_X_4160_Y_6656 MINT1_X_4160_Y_6656 0 6.8527e-18
C_MINT1_X_4160_Y_6720 MINT1_X_4160_Y_6720 0 8.2232e-18
C_MINT1_X_4160_Y_7040 MINT1_X_4160_Y_7040 0 1.3705e-17
C_MINT1_X_4160_Y_7360 MINT1_X_4160_Y_7360 0 1.3705e-17
C_MINT1_X_4160_Y_7680 MINT1_X_4160_Y_7680 0 1.3705e-17
C_MINT1_X_4160_Y_8000 MINT1_X_4160_Y_8000 0 1.3705e-17
C_MINT1_X_4160_Y_8320 MINT1_X_4160_Y_8320 0 1.3705e-17
C_MINT1_X_4160_Y_8640 MINT1_X_4160_Y_8640 0 8.2232e-18
C_MINT1_X_4160_Y_8704 MINT1_X_4160_Y_8704 0 6.8527e-18
C_MINT1_X_4160_Y_8960 MINT1_X_4160_Y_8960 0 1.2335e-17
C_MINT1_X_4160_Y_9280 MINT1_X_4160_Y_9280 0 1.3705e-17
C_MINT1_X_4160_Y_960 MINT1_X_4160_Y_960 0 1.3705e-17
C_MINT1_X_4160_Y_9600 MINT1_X_4160_Y_9600 0 9.5937e-18
C_MINT1_X_4160_Y_9728 MINT1_X_4160_Y_9728 0 6.8527e-18
C_MINT1_X_4160_Y_9920 MINT1_X_4160_Y_9920 0 5.8248e-18
C_MINT1_X_4480_Y_0 MINT1_X_4480_Y_0 0 6.8527e-18
C_MINT1_X_4480_Y_10000 MINT1_X_4480_Y_10000 0 1.7132e-18
C_MINT1_X_4480_Y_1024 MINT1_X_4480_Y_1024 0 6.8527e-18
C_MINT1_X_4480_Y_1280 MINT1_X_4480_Y_1280 0 1.2335e-17
C_MINT1_X_4480_Y_1600 MINT1_X_4480_Y_1600 0 1.3705e-17
C_MINT1_X_4480_Y_1920 MINT1_X_4480_Y_1920 0 9.5937e-18
C_MINT1_X_4480_Y_2048 MINT1_X_4480_Y_2048 0 6.8527e-18
C_MINT1_X_4480_Y_2240 MINT1_X_4480_Y_2240 0 1.0964e-17
C_MINT1_X_4480_Y_2560 MINT1_X_4480_Y_2560 0 1.3705e-17
C_MINT1_X_4480_Y_2880 MINT1_X_4480_Y_2880 0 1.0964e-17
C_MINT1_X_4480_Y_3072 MINT1_X_4480_Y_3072 0 6.8527e-18
C_MINT1_X_4480_Y_320 MINT1_X_4480_Y_320 0 1.3705e-17
C_MINT1_X_4480_Y_3200 MINT1_X_4480_Y_3200 0 9.5937e-18
C_MINT1_X_4480_Y_3520 MINT1_X_4480_Y_3520 0 1.3705e-17
C_MINT1_X_4480_Y_3840 MINT1_X_4480_Y_3840 0 1.2335e-17
C_MINT1_X_4480_Y_4096 MINT1_X_4480_Y_4096 0 6.8527e-18
C_MINT1_X_4480_Y_4160 MINT1_X_4480_Y_4160 0 8.2232e-18
C_MINT1_X_4480_Y_4480 MINT1_X_4480_Y_4480 0 1.3705e-17
C_MINT1_X_4480_Y_4800 MINT1_X_4480_Y_4800 0 1.3705e-17
C_MINT1_X_4480_Y_5120 MINT1_X_4480_Y_5120 0 1.3705e-17
C_MINT1_X_4480_Y_5440 MINT1_X_4480_Y_5440 0 1.3705e-17
C_MINT1_X_4480_Y_5760 MINT1_X_4480_Y_5760 0 1.3705e-17
C_MINT1_X_4480_Y_6080 MINT1_X_4480_Y_6080 0 8.2232e-18
C_MINT1_X_4480_Y_6144 MINT1_X_4480_Y_6144 0 6.8527e-18
C_MINT1_X_4480_Y_640 MINT1_X_4480_Y_640 0 1.3705e-17
C_MINT1_X_4480_Y_6400 MINT1_X_4480_Y_6400 0 1.2335e-17
C_MINT1_X_4480_Y_6720 MINT1_X_4480_Y_6720 0 1.3705e-17
C_MINT1_X_4480_Y_7040 MINT1_X_4480_Y_7040 0 9.5937e-18
C_MINT1_X_4480_Y_7168 MINT1_X_4480_Y_7168 0 6.8527e-18
C_MINT1_X_4480_Y_7360 MINT1_X_4480_Y_7360 0 1.0964e-17
C_MINT1_X_4480_Y_7680 MINT1_X_4480_Y_7680 0 1.3705e-17
C_MINT1_X_4480_Y_8000 MINT1_X_4480_Y_8000 0 1.0964e-17
C_MINT1_X_4480_Y_8192 MINT1_X_4480_Y_8192 0 6.8527e-18
C_MINT1_X_4480_Y_8320 MINT1_X_4480_Y_8320 0 9.5937e-18
C_MINT1_X_4480_Y_8640 MINT1_X_4480_Y_8640 0 1.3705e-17
C_MINT1_X_4480_Y_8960 MINT1_X_4480_Y_8960 0 1.2335e-17
C_MINT1_X_4480_Y_9216 MINT1_X_4480_Y_9216 0 6.8527e-18
C_MINT1_X_4480_Y_9280 MINT1_X_4480_Y_9280 0 8.2232e-18
C_MINT1_X_4480_Y_960 MINT1_X_4480_Y_960 0 8.2232e-18
C_MINT1_X_4480_Y_9600 MINT1_X_4480_Y_9600 0 1.3705e-17
C_MINT1_X_4480_Y_9920 MINT1_X_4480_Y_9920 0 8.5658e-18
C_MINT1_X_4800_Y_0 MINT1_X_4800_Y_0 0 6.8527e-18
C_MINT1_X_4800_Y_10000 MINT1_X_4800_Y_10000 0 1.7132e-18
C_MINT1_X_4800_Y_1280 MINT1_X_4800_Y_1280 0 1.2335e-17
C_MINT1_X_4800_Y_1536 MINT1_X_4800_Y_1536 0 6.8527e-18
C_MINT1_X_4800_Y_1600 MINT1_X_4800_Y_1600 0 8.2232e-18
C_MINT1_X_4800_Y_1920 MINT1_X_4800_Y_1920 0 1.3705e-17
C_MINT1_X_4800_Y_2240 MINT1_X_4800_Y_2240 0 1.3705e-17
C_MINT1_X_4800_Y_2560 MINT1_X_4800_Y_2560 0 1.3705e-17
C_MINT1_X_4800_Y_2880 MINT1_X_4800_Y_2880 0 1.3705e-17
C_MINT1_X_4800_Y_320 MINT1_X_4800_Y_320 0 1.0964e-17
C_MINT1_X_4800_Y_3200 MINT1_X_4800_Y_3200 0 1.3705e-17
C_MINT1_X_4800_Y_3520 MINT1_X_4800_Y_3520 0 8.2232e-18
C_MINT1_X_4800_Y_3584 MINT1_X_4800_Y_3584 0 6.8527e-18
C_MINT1_X_4800_Y_3840 MINT1_X_4800_Y_3840 0 1.2335e-17
C_MINT1_X_4800_Y_4160 MINT1_X_4800_Y_4160 0 1.3705e-17
C_MINT1_X_4800_Y_4480 MINT1_X_4800_Y_4480 0 9.5937e-18
C_MINT1_X_4800_Y_4608 MINT1_X_4800_Y_4608 0 6.8527e-18
C_MINT1_X_4800_Y_4800 MINT1_X_4800_Y_4800 0 1.0964e-17
C_MINT1_X_4800_Y_512 MINT1_X_4800_Y_512 0 6.8527e-18
C_MINT1_X_4800_Y_5120 MINT1_X_4800_Y_5120 0 1.3705e-17
C_MINT1_X_4800_Y_5440 MINT1_X_4800_Y_5440 0 1.0964e-17
C_MINT1_X_4800_Y_5632 MINT1_X_4800_Y_5632 0 6.8527e-18
C_MINT1_X_4800_Y_5760 MINT1_X_4800_Y_5760 0 9.5937e-18
C_MINT1_X_4800_Y_6080 MINT1_X_4800_Y_6080 0 1.3705e-17
C_MINT1_X_4800_Y_640 MINT1_X_4800_Y_640 0 9.5937e-18
C_MINT1_X_4800_Y_6400 MINT1_X_4800_Y_6400 0 1.2335e-17
C_MINT1_X_4800_Y_6656 MINT1_X_4800_Y_6656 0 6.8527e-18
C_MINT1_X_4800_Y_6720 MINT1_X_4800_Y_6720 0 8.2232e-18
C_MINT1_X_4800_Y_7040 MINT1_X_4800_Y_7040 0 1.3705e-17
C_MINT1_X_4800_Y_7360 MINT1_X_4800_Y_7360 0 1.3705e-17
C_MINT1_X_4800_Y_7680 MINT1_X_4800_Y_7680 0 1.3705e-17
C_MINT1_X_4800_Y_8000 MINT1_X_4800_Y_8000 0 1.3705e-17
C_MINT1_X_4800_Y_8320 MINT1_X_4800_Y_8320 0 1.3705e-17
C_MINT1_X_4800_Y_8640 MINT1_X_4800_Y_8640 0 8.2232e-18
C_MINT1_X_4800_Y_8704 MINT1_X_4800_Y_8704 0 6.8527e-18
C_MINT1_X_4800_Y_8960 MINT1_X_4800_Y_8960 0 1.2335e-17
C_MINT1_X_4800_Y_9280 MINT1_X_4800_Y_9280 0 1.3705e-17
C_MINT1_X_4800_Y_960 MINT1_X_4800_Y_960 0 1.3705e-17
C_MINT1_X_4800_Y_9600 MINT1_X_4800_Y_9600 0 9.5937e-18
C_MINT1_X_4800_Y_9728 MINT1_X_4800_Y_9728 0 6.8527e-18
C_MINT1_X_4800_Y_9920 MINT1_X_4800_Y_9920 0 5.8248e-18
C_MINT1_X_5120_Y_0 MINT1_X_5120_Y_0 0 6.8527e-18
C_MINT1_X_5120_Y_10000 MINT1_X_5120_Y_10000 0 1.7132e-18
C_MINT1_X_5120_Y_1024 MINT1_X_5120_Y_1024 0 6.8527e-18
C_MINT1_X_5120_Y_1280 MINT1_X_5120_Y_1280 0 1.2335e-17
C_MINT1_X_5120_Y_1600 MINT1_X_5120_Y_1600 0 1.3705e-17
C_MINT1_X_5120_Y_1920 MINT1_X_5120_Y_1920 0 9.5937e-18
C_MINT1_X_5120_Y_2048 MINT1_X_5120_Y_2048 0 6.8527e-18
C_MINT1_X_5120_Y_2240 MINT1_X_5120_Y_2240 0 1.0964e-17
C_MINT1_X_5120_Y_2560 MINT1_X_5120_Y_2560 0 1.3705e-17
C_MINT1_X_5120_Y_2880 MINT1_X_5120_Y_2880 0 1.0964e-17
C_MINT1_X_5120_Y_3072 MINT1_X_5120_Y_3072 0 6.8527e-18
C_MINT1_X_5120_Y_320 MINT1_X_5120_Y_320 0 1.3705e-17
C_MINT1_X_5120_Y_3200 MINT1_X_5120_Y_3200 0 9.5937e-18
C_MINT1_X_5120_Y_3520 MINT1_X_5120_Y_3520 0 1.3705e-17
C_MINT1_X_5120_Y_3840 MINT1_X_5120_Y_3840 0 1.2335e-17
C_MINT1_X_5120_Y_4096 MINT1_X_5120_Y_4096 0 6.8527e-18
C_MINT1_X_5120_Y_4160 MINT1_X_5120_Y_4160 0 8.2232e-18
C_MINT1_X_5120_Y_4480 MINT1_X_5120_Y_4480 0 1.3705e-17
C_MINT1_X_5120_Y_4800 MINT1_X_5120_Y_4800 0 1.3705e-17
C_MINT1_X_5120_Y_5120 MINT1_X_5120_Y_5120 0 1.3705e-17
C_MINT1_X_5120_Y_5440 MINT1_X_5120_Y_5440 0 1.3705e-17
C_MINT1_X_5120_Y_5760 MINT1_X_5120_Y_5760 0 1.3705e-17
C_MINT1_X_5120_Y_6080 MINT1_X_5120_Y_6080 0 8.2232e-18
C_MINT1_X_5120_Y_6144 MINT1_X_5120_Y_6144 0 6.8527e-18
C_MINT1_X_5120_Y_640 MINT1_X_5120_Y_640 0 1.3705e-17
C_MINT1_X_5120_Y_6400 MINT1_X_5120_Y_6400 0 1.2335e-17
C_MINT1_X_5120_Y_6720 MINT1_X_5120_Y_6720 0 1.3705e-17
C_MINT1_X_5120_Y_7040 MINT1_X_5120_Y_7040 0 9.5937e-18
C_MINT1_X_5120_Y_7168 MINT1_X_5120_Y_7168 0 6.8527e-18
C_MINT1_X_5120_Y_7360 MINT1_X_5120_Y_7360 0 1.0964e-17
C_MINT1_X_5120_Y_7680 MINT1_X_5120_Y_7680 0 1.3705e-17
C_MINT1_X_5120_Y_8000 MINT1_X_5120_Y_8000 0 1.0964e-17
C_MINT1_X_5120_Y_8192 MINT1_X_5120_Y_8192 0 6.8527e-18
C_MINT1_X_5120_Y_8320 MINT1_X_5120_Y_8320 0 9.5937e-18
C_MINT1_X_5120_Y_8640 MINT1_X_5120_Y_8640 0 1.3705e-17
C_MINT1_X_5120_Y_8960 MINT1_X_5120_Y_8960 0 1.2335e-17
C_MINT1_X_5120_Y_9216 MINT1_X_5120_Y_9216 0 6.8527e-18
C_MINT1_X_5120_Y_9280 MINT1_X_5120_Y_9280 0 8.2232e-18
C_MINT1_X_5120_Y_960 MINT1_X_5120_Y_960 0 8.2232e-18
C_MINT1_X_5120_Y_9600 MINT1_X_5120_Y_9600 0 1.3705e-17
C_MINT1_X_5120_Y_9920 MINT1_X_5120_Y_9920 0 8.5658e-18
C_MINT1_X_5440_Y_0 MINT1_X_5440_Y_0 0 6.8527e-18
C_MINT1_X_5440_Y_10000 MINT1_X_5440_Y_10000 0 1.7132e-18
C_MINT1_X_5440_Y_1280 MINT1_X_5440_Y_1280 0 1.2335e-17
C_MINT1_X_5440_Y_1536 MINT1_X_5440_Y_1536 0 6.8527e-18
C_MINT1_X_5440_Y_1600 MINT1_X_5440_Y_1600 0 8.2232e-18
C_MINT1_X_5440_Y_1920 MINT1_X_5440_Y_1920 0 1.3705e-17
C_MINT1_X_5440_Y_2240 MINT1_X_5440_Y_2240 0 1.3705e-17
C_MINT1_X_5440_Y_2560 MINT1_X_5440_Y_2560 0 1.3705e-17
C_MINT1_X_5440_Y_2880 MINT1_X_5440_Y_2880 0 1.3705e-17
C_MINT1_X_5440_Y_320 MINT1_X_5440_Y_320 0 1.0964e-17
C_MINT1_X_5440_Y_3200 MINT1_X_5440_Y_3200 0 1.3705e-17
C_MINT1_X_5440_Y_3520 MINT1_X_5440_Y_3520 0 8.2232e-18
C_MINT1_X_5440_Y_3584 MINT1_X_5440_Y_3584 0 6.8527e-18
C_MINT1_X_5440_Y_3840 MINT1_X_5440_Y_3840 0 1.2335e-17
C_MINT1_X_5440_Y_4160 MINT1_X_5440_Y_4160 0 1.3705e-17
C_MINT1_X_5440_Y_4480 MINT1_X_5440_Y_4480 0 9.5937e-18
C_MINT1_X_5440_Y_4608 MINT1_X_5440_Y_4608 0 6.8527e-18
C_MINT1_X_5440_Y_4800 MINT1_X_5440_Y_4800 0 1.0964e-17
C_MINT1_X_5440_Y_512 MINT1_X_5440_Y_512 0 6.8527e-18
C_MINT1_X_5440_Y_5120 MINT1_X_5440_Y_5120 0 1.3705e-17
C_MINT1_X_5440_Y_5440 MINT1_X_5440_Y_5440 0 1.0964e-17
C_MINT1_X_5440_Y_5632 MINT1_X_5440_Y_5632 0 6.8527e-18
C_MINT1_X_5440_Y_5760 MINT1_X_5440_Y_5760 0 9.5937e-18
C_MINT1_X_5440_Y_6080 MINT1_X_5440_Y_6080 0 1.3705e-17
C_MINT1_X_5440_Y_640 MINT1_X_5440_Y_640 0 9.5937e-18
C_MINT1_X_5440_Y_6400 MINT1_X_5440_Y_6400 0 1.2335e-17
C_MINT1_X_5440_Y_6656 MINT1_X_5440_Y_6656 0 6.8527e-18
C_MINT1_X_5440_Y_6720 MINT1_X_5440_Y_6720 0 8.2232e-18
C_MINT1_X_5440_Y_7040 MINT1_X_5440_Y_7040 0 1.3705e-17
C_MINT1_X_5440_Y_7360 MINT1_X_5440_Y_7360 0 1.3705e-17
C_MINT1_X_5440_Y_7680 MINT1_X_5440_Y_7680 0 1.3705e-17
C_MINT1_X_5440_Y_8000 MINT1_X_5440_Y_8000 0 1.3705e-17
C_MINT1_X_5440_Y_8320 MINT1_X_5440_Y_8320 0 1.3705e-17
C_MINT1_X_5440_Y_8640 MINT1_X_5440_Y_8640 0 8.2232e-18
C_MINT1_X_5440_Y_8704 MINT1_X_5440_Y_8704 0 6.8527e-18
C_MINT1_X_5440_Y_8960 MINT1_X_5440_Y_8960 0 1.2335e-17
C_MINT1_X_5440_Y_9280 MINT1_X_5440_Y_9280 0 1.3705e-17
C_MINT1_X_5440_Y_960 MINT1_X_5440_Y_960 0 1.3705e-17
C_MINT1_X_5440_Y_9600 MINT1_X_5440_Y_9600 0 9.5937e-18
C_MINT1_X_5440_Y_9728 MINT1_X_5440_Y_9728 0 6.8527e-18
C_MINT1_X_5440_Y_9920 MINT1_X_5440_Y_9920 0 5.8248e-18
C_MINT1_X_5760_Y_0 MINT1_X_5760_Y_0 0 6.8527e-18
C_MINT1_X_5760_Y_10000 MINT1_X_5760_Y_10000 0 1.7132e-18
C_MINT1_X_5760_Y_1024 MINT1_X_5760_Y_1024 0 6.8527e-18
C_MINT1_X_5760_Y_1280 MINT1_X_5760_Y_1280 0 1.2335e-17
C_MINT1_X_5760_Y_1600 MINT1_X_5760_Y_1600 0 1.3705e-17
C_MINT1_X_5760_Y_1920 MINT1_X_5760_Y_1920 0 9.5937e-18
C_MINT1_X_5760_Y_2048 MINT1_X_5760_Y_2048 0 6.8527e-18
C_MINT1_X_5760_Y_2240 MINT1_X_5760_Y_2240 0 1.0964e-17
C_MINT1_X_5760_Y_2560 MINT1_X_5760_Y_2560 0 1.3705e-17
C_MINT1_X_5760_Y_2880 MINT1_X_5760_Y_2880 0 1.0964e-17
C_MINT1_X_5760_Y_3072 MINT1_X_5760_Y_3072 0 6.8527e-18
C_MINT1_X_5760_Y_320 MINT1_X_5760_Y_320 0 1.3705e-17
C_MINT1_X_5760_Y_3200 MINT1_X_5760_Y_3200 0 9.5937e-18
C_MINT1_X_5760_Y_3520 MINT1_X_5760_Y_3520 0 1.3705e-17
C_MINT1_X_5760_Y_3840 MINT1_X_5760_Y_3840 0 1.2335e-17
C_MINT1_X_5760_Y_4096 MINT1_X_5760_Y_4096 0 6.8527e-18
C_MINT1_X_5760_Y_4160 MINT1_X_5760_Y_4160 0 8.2232e-18
C_MINT1_X_5760_Y_4480 MINT1_X_5760_Y_4480 0 1.3705e-17
C_MINT1_X_5760_Y_4800 MINT1_X_5760_Y_4800 0 1.3705e-17
C_MINT1_X_5760_Y_5120 MINT1_X_5760_Y_5120 0 1.3705e-17
C_MINT1_X_5760_Y_5440 MINT1_X_5760_Y_5440 0 1.3705e-17
C_MINT1_X_5760_Y_5760 MINT1_X_5760_Y_5760 0 1.3705e-17
C_MINT1_X_5760_Y_6080 MINT1_X_5760_Y_6080 0 8.2232e-18
C_MINT1_X_5760_Y_6144 MINT1_X_5760_Y_6144 0 6.8527e-18
C_MINT1_X_5760_Y_640 MINT1_X_5760_Y_640 0 1.3705e-17
C_MINT1_X_5760_Y_6400 MINT1_X_5760_Y_6400 0 1.2335e-17
C_MINT1_X_5760_Y_6720 MINT1_X_5760_Y_6720 0 1.3705e-17
C_MINT1_X_5760_Y_7040 MINT1_X_5760_Y_7040 0 9.5937e-18
C_MINT1_X_5760_Y_7168 MINT1_X_5760_Y_7168 0 6.8527e-18
C_MINT1_X_5760_Y_7360 MINT1_X_5760_Y_7360 0 1.0964e-17
C_MINT1_X_5760_Y_7680 MINT1_X_5760_Y_7680 0 1.3705e-17
C_MINT1_X_5760_Y_8000 MINT1_X_5760_Y_8000 0 1.0964e-17
C_MINT1_X_5760_Y_8192 MINT1_X_5760_Y_8192 0 6.8527e-18
C_MINT1_X_5760_Y_8320 MINT1_X_5760_Y_8320 0 9.5937e-18
C_MINT1_X_5760_Y_8640 MINT1_X_5760_Y_8640 0 1.3705e-17
C_MINT1_X_5760_Y_8960 MINT1_X_5760_Y_8960 0 1.2335e-17
C_MINT1_X_5760_Y_9216 MINT1_X_5760_Y_9216 0 6.8527e-18
C_MINT1_X_5760_Y_9280 MINT1_X_5760_Y_9280 0 8.2232e-18
C_MINT1_X_5760_Y_960 MINT1_X_5760_Y_960 0 8.2232e-18
C_MINT1_X_5760_Y_9600 MINT1_X_5760_Y_9600 0 1.3705e-17
C_MINT1_X_5760_Y_9920 MINT1_X_5760_Y_9920 0 8.5658e-18
C_MINT1_X_6080_Y_0 MINT1_X_6080_Y_0 0 6.8527e-18
C_MINT1_X_6080_Y_10000 MINT1_X_6080_Y_10000 0 1.7132e-18
C_MINT1_X_6080_Y_1280 MINT1_X_6080_Y_1280 0 1.2335e-17
C_MINT1_X_6080_Y_1536 MINT1_X_6080_Y_1536 0 6.8527e-18
C_MINT1_X_6080_Y_1600 MINT1_X_6080_Y_1600 0 8.2232e-18
C_MINT1_X_6080_Y_1920 MINT1_X_6080_Y_1920 0 1.3705e-17
C_MINT1_X_6080_Y_2240 MINT1_X_6080_Y_2240 0 1.3705e-17
C_MINT1_X_6080_Y_2560 MINT1_X_6080_Y_2560 0 1.3705e-17
C_MINT1_X_6080_Y_2880 MINT1_X_6080_Y_2880 0 1.3705e-17
C_MINT1_X_6080_Y_320 MINT1_X_6080_Y_320 0 1.0964e-17
C_MINT1_X_6080_Y_3200 MINT1_X_6080_Y_3200 0 1.3705e-17
C_MINT1_X_6080_Y_3520 MINT1_X_6080_Y_3520 0 8.2232e-18
C_MINT1_X_6080_Y_3584 MINT1_X_6080_Y_3584 0 6.8527e-18
C_MINT1_X_6080_Y_3840 MINT1_X_6080_Y_3840 0 1.2335e-17
C_MINT1_X_6080_Y_4160 MINT1_X_6080_Y_4160 0 1.3705e-17
C_MINT1_X_6080_Y_4480 MINT1_X_6080_Y_4480 0 9.5937e-18
C_MINT1_X_6080_Y_4608 MINT1_X_6080_Y_4608 0 6.8527e-18
C_MINT1_X_6080_Y_4800 MINT1_X_6080_Y_4800 0 1.0964e-17
C_MINT1_X_6080_Y_512 MINT1_X_6080_Y_512 0 6.8527e-18
C_MINT1_X_6080_Y_5120 MINT1_X_6080_Y_5120 0 1.3705e-17
C_MINT1_X_6080_Y_5440 MINT1_X_6080_Y_5440 0 1.0964e-17
C_MINT1_X_6080_Y_5632 MINT1_X_6080_Y_5632 0 6.8527e-18
C_MINT1_X_6080_Y_5760 MINT1_X_6080_Y_5760 0 9.5937e-18
C_MINT1_X_6080_Y_6080 MINT1_X_6080_Y_6080 0 1.3705e-17
C_MINT1_X_6080_Y_640 MINT1_X_6080_Y_640 0 9.5937e-18
C_MINT1_X_6080_Y_6400 MINT1_X_6080_Y_6400 0 1.2335e-17
C_MINT1_X_6080_Y_6656 MINT1_X_6080_Y_6656 0 6.8527e-18
C_MINT1_X_6080_Y_6720 MINT1_X_6080_Y_6720 0 8.2232e-18
C_MINT1_X_6080_Y_7040 MINT1_X_6080_Y_7040 0 1.3705e-17
C_MINT1_X_6080_Y_7360 MINT1_X_6080_Y_7360 0 1.3705e-17
C_MINT1_X_6080_Y_7680 MINT1_X_6080_Y_7680 0 1.3705e-17
C_MINT1_X_6080_Y_8000 MINT1_X_6080_Y_8000 0 1.3705e-17
C_MINT1_X_6080_Y_8320 MINT1_X_6080_Y_8320 0 1.3705e-17
C_MINT1_X_6080_Y_8640 MINT1_X_6080_Y_8640 0 8.2232e-18
C_MINT1_X_6080_Y_8704 MINT1_X_6080_Y_8704 0 6.8527e-18
C_MINT1_X_6080_Y_8960 MINT1_X_6080_Y_8960 0 1.2335e-17
C_MINT1_X_6080_Y_9280 MINT1_X_6080_Y_9280 0 1.3705e-17
C_MINT1_X_6080_Y_960 MINT1_X_6080_Y_960 0 1.3705e-17
C_MINT1_X_6080_Y_9600 MINT1_X_6080_Y_9600 0 9.5937e-18
C_MINT1_X_6080_Y_9728 MINT1_X_6080_Y_9728 0 6.8527e-18
C_MINT1_X_6080_Y_9920 MINT1_X_6080_Y_9920 0 5.8248e-18
C_MINT1_X_6400_Y_0 MINT1_X_6400_Y_0 0 6.8527e-18
C_MINT1_X_6400_Y_10000 MINT1_X_6400_Y_10000 0 1.7132e-18
C_MINT1_X_6400_Y_1024 MINT1_X_6400_Y_1024 0 6.8527e-18
C_MINT1_X_6400_Y_1280 MINT1_X_6400_Y_1280 0 1.2335e-17
C_MINT1_X_6400_Y_1600 MINT1_X_6400_Y_1600 0 1.3705e-17
C_MINT1_X_6400_Y_1920 MINT1_X_6400_Y_1920 0 9.5937e-18
C_MINT1_X_6400_Y_2048 MINT1_X_6400_Y_2048 0 6.8527e-18
C_MINT1_X_6400_Y_2240 MINT1_X_6400_Y_2240 0 1.0964e-17
C_MINT1_X_6400_Y_2560 MINT1_X_6400_Y_2560 0 1.3705e-17
C_MINT1_X_6400_Y_2880 MINT1_X_6400_Y_2880 0 1.0964e-17
C_MINT1_X_6400_Y_3072 MINT1_X_6400_Y_3072 0 6.8527e-18
C_MINT1_X_6400_Y_320 MINT1_X_6400_Y_320 0 1.3705e-17
C_MINT1_X_6400_Y_3200 MINT1_X_6400_Y_3200 0 9.5937e-18
C_MINT1_X_6400_Y_3520 MINT1_X_6400_Y_3520 0 1.3705e-17
C_MINT1_X_6400_Y_3840 MINT1_X_6400_Y_3840 0 1.2335e-17
C_MINT1_X_6400_Y_4096 MINT1_X_6400_Y_4096 0 6.8527e-18
C_MINT1_X_6400_Y_4160 MINT1_X_6400_Y_4160 0 8.2232e-18
C_MINT1_X_6400_Y_4480 MINT1_X_6400_Y_4480 0 1.3705e-17
C_MINT1_X_6400_Y_4800 MINT1_X_6400_Y_4800 0 1.3705e-17
C_MINT1_X_6400_Y_5120 MINT1_X_6400_Y_5120 0 1.3705e-17
C_MINT1_X_6400_Y_5440 MINT1_X_6400_Y_5440 0 1.3705e-17
C_MINT1_X_6400_Y_5760 MINT1_X_6400_Y_5760 0 1.3705e-17
C_MINT1_X_6400_Y_6080 MINT1_X_6400_Y_6080 0 8.2232e-18
C_MINT1_X_6400_Y_6144 MINT1_X_6400_Y_6144 0 6.8527e-18
C_MINT1_X_6400_Y_640 MINT1_X_6400_Y_640 0 1.3705e-17
C_MINT1_X_6400_Y_6400 MINT1_X_6400_Y_6400 0 1.2335e-17
C_MINT1_X_6400_Y_6720 MINT1_X_6400_Y_6720 0 1.3705e-17
C_MINT1_X_6400_Y_7040 MINT1_X_6400_Y_7040 0 9.5937e-18
C_MINT1_X_6400_Y_7168 MINT1_X_6400_Y_7168 0 6.8527e-18
C_MINT1_X_6400_Y_7360 MINT1_X_6400_Y_7360 0 1.0964e-17
C_MINT1_X_6400_Y_7680 MINT1_X_6400_Y_7680 0 1.3705e-17
C_MINT1_X_6400_Y_8000 MINT1_X_6400_Y_8000 0 1.0964e-17
C_MINT1_X_6400_Y_8192 MINT1_X_6400_Y_8192 0 6.8527e-18
C_MINT1_X_6400_Y_8320 MINT1_X_6400_Y_8320 0 9.5937e-18
C_MINT1_X_6400_Y_8640 MINT1_X_6400_Y_8640 0 1.3705e-17
C_MINT1_X_6400_Y_8960 MINT1_X_6400_Y_8960 0 1.2335e-17
C_MINT1_X_6400_Y_9216 MINT1_X_6400_Y_9216 0 6.8527e-18
C_MINT1_X_6400_Y_9280 MINT1_X_6400_Y_9280 0 8.2232e-18
C_MINT1_X_6400_Y_960 MINT1_X_6400_Y_960 0 8.2232e-18
C_MINT1_X_6400_Y_9600 MINT1_X_6400_Y_9600 0 1.3705e-17
C_MINT1_X_6400_Y_9920 MINT1_X_6400_Y_9920 0 8.5658e-18
C_MINT1_X_640_Y_0 MINT1_X_640_Y_0 0 6.8527e-18
C_MINT1_X_640_Y_10000 MINT1_X_640_Y_10000 0 1.7132e-18
C_MINT1_X_640_Y_1024 MINT1_X_640_Y_1024 0 6.8527e-18
C_MINT1_X_640_Y_1280 MINT1_X_640_Y_1280 0 1.2335e-17
C_MINT1_X_640_Y_1600 MINT1_X_640_Y_1600 0 1.3705e-17
C_MINT1_X_640_Y_1920 MINT1_X_640_Y_1920 0 9.5937e-18
C_MINT1_X_640_Y_2048 MINT1_X_640_Y_2048 0 6.8527e-18
C_MINT1_X_640_Y_2240 MINT1_X_640_Y_2240 0 1.0964e-17
C_MINT1_X_640_Y_2560 MINT1_X_640_Y_2560 0 1.3705e-17
C_MINT1_X_640_Y_2880 MINT1_X_640_Y_2880 0 1.0964e-17
C_MINT1_X_640_Y_3072 MINT1_X_640_Y_3072 0 6.8527e-18
C_MINT1_X_640_Y_320 MINT1_X_640_Y_320 0 1.3705e-17
C_MINT1_X_640_Y_3200 MINT1_X_640_Y_3200 0 9.5937e-18
C_MINT1_X_640_Y_3520 MINT1_X_640_Y_3520 0 1.3705e-17
C_MINT1_X_640_Y_3840 MINT1_X_640_Y_3840 0 1.2335e-17
C_MINT1_X_640_Y_4096 MINT1_X_640_Y_4096 0 6.8527e-18
C_MINT1_X_640_Y_4160 MINT1_X_640_Y_4160 0 8.2232e-18
C_MINT1_X_640_Y_4480 MINT1_X_640_Y_4480 0 1.3705e-17
C_MINT1_X_640_Y_4800 MINT1_X_640_Y_4800 0 1.3705e-17
C_MINT1_X_640_Y_5120 MINT1_X_640_Y_5120 0 1.3705e-17
C_MINT1_X_640_Y_5440 MINT1_X_640_Y_5440 0 1.3705e-17
C_MINT1_X_640_Y_5760 MINT1_X_640_Y_5760 0 1.3705e-17
C_MINT1_X_640_Y_6080 MINT1_X_640_Y_6080 0 8.2232e-18
C_MINT1_X_640_Y_6144 MINT1_X_640_Y_6144 0 6.8527e-18
C_MINT1_X_640_Y_640 MINT1_X_640_Y_640 0 1.3705e-17
C_MINT1_X_640_Y_6400 MINT1_X_640_Y_6400 0 1.2335e-17
C_MINT1_X_640_Y_6720 MINT1_X_640_Y_6720 0 1.3705e-17
C_MINT1_X_640_Y_7040 MINT1_X_640_Y_7040 0 9.5937e-18
C_MINT1_X_640_Y_7168 MINT1_X_640_Y_7168 0 6.8527e-18
C_MINT1_X_640_Y_7360 MINT1_X_640_Y_7360 0 1.0964e-17
C_MINT1_X_640_Y_7680 MINT1_X_640_Y_7680 0 1.3705e-17
C_MINT1_X_640_Y_8000 MINT1_X_640_Y_8000 0 1.0964e-17
C_MINT1_X_640_Y_8192 MINT1_X_640_Y_8192 0 6.8527e-18
C_MINT1_X_640_Y_8320 MINT1_X_640_Y_8320 0 9.5937e-18
C_MINT1_X_640_Y_8640 MINT1_X_640_Y_8640 0 1.3705e-17
C_MINT1_X_640_Y_8960 MINT1_X_640_Y_8960 0 1.2335e-17
C_MINT1_X_640_Y_9216 MINT1_X_640_Y_9216 0 6.8527e-18
C_MINT1_X_640_Y_9280 MINT1_X_640_Y_9280 0 8.2232e-18
C_MINT1_X_640_Y_960 MINT1_X_640_Y_960 0 8.2232e-18
C_MINT1_X_640_Y_9600 MINT1_X_640_Y_9600 0 1.3705e-17
C_MINT1_X_640_Y_9920 MINT1_X_640_Y_9920 0 8.5658e-18
C_MINT1_X_6720_Y_0 MINT1_X_6720_Y_0 0 6.8527e-18
C_MINT1_X_6720_Y_10000 MINT1_X_6720_Y_10000 0 1.7132e-18
C_MINT1_X_6720_Y_1280 MINT1_X_6720_Y_1280 0 1.2335e-17
C_MINT1_X_6720_Y_1536 MINT1_X_6720_Y_1536 0 6.8527e-18
C_MINT1_X_6720_Y_1600 MINT1_X_6720_Y_1600 0 8.2232e-18
C_MINT1_X_6720_Y_1920 MINT1_X_6720_Y_1920 0 1.3705e-17
C_MINT1_X_6720_Y_2240 MINT1_X_6720_Y_2240 0 1.3705e-17
C_MINT1_X_6720_Y_2560 MINT1_X_6720_Y_2560 0 1.3705e-17
C_MINT1_X_6720_Y_2880 MINT1_X_6720_Y_2880 0 1.3705e-17
C_MINT1_X_6720_Y_320 MINT1_X_6720_Y_320 0 1.0964e-17
C_MINT1_X_6720_Y_3200 MINT1_X_6720_Y_3200 0 1.3705e-17
C_MINT1_X_6720_Y_3520 MINT1_X_6720_Y_3520 0 8.2232e-18
C_MINT1_X_6720_Y_3584 MINT1_X_6720_Y_3584 0 6.8527e-18
C_MINT1_X_6720_Y_3840 MINT1_X_6720_Y_3840 0 1.2335e-17
C_MINT1_X_6720_Y_4160 MINT1_X_6720_Y_4160 0 1.3705e-17
C_MINT1_X_6720_Y_4480 MINT1_X_6720_Y_4480 0 9.5937e-18
C_MINT1_X_6720_Y_4608 MINT1_X_6720_Y_4608 0 6.8527e-18
C_MINT1_X_6720_Y_4800 MINT1_X_6720_Y_4800 0 1.0964e-17
C_MINT1_X_6720_Y_512 MINT1_X_6720_Y_512 0 6.8527e-18
C_MINT1_X_6720_Y_5120 MINT1_X_6720_Y_5120 0 1.3705e-17
C_MINT1_X_6720_Y_5440 MINT1_X_6720_Y_5440 0 1.0964e-17
C_MINT1_X_6720_Y_5632 MINT1_X_6720_Y_5632 0 6.8527e-18
C_MINT1_X_6720_Y_5760 MINT1_X_6720_Y_5760 0 9.5937e-18
C_MINT1_X_6720_Y_6080 MINT1_X_6720_Y_6080 0 1.3705e-17
C_MINT1_X_6720_Y_640 MINT1_X_6720_Y_640 0 9.5937e-18
C_MINT1_X_6720_Y_6400 MINT1_X_6720_Y_6400 0 1.2335e-17
C_MINT1_X_6720_Y_6656 MINT1_X_6720_Y_6656 0 6.8527e-18
C_MINT1_X_6720_Y_6720 MINT1_X_6720_Y_6720 0 8.2232e-18
C_MINT1_X_6720_Y_7040 MINT1_X_6720_Y_7040 0 1.3705e-17
C_MINT1_X_6720_Y_7360 MINT1_X_6720_Y_7360 0 1.3705e-17
C_MINT1_X_6720_Y_7680 MINT1_X_6720_Y_7680 0 1.3705e-17
C_MINT1_X_6720_Y_8000 MINT1_X_6720_Y_8000 0 1.3705e-17
C_MINT1_X_6720_Y_8320 MINT1_X_6720_Y_8320 0 1.3705e-17
C_MINT1_X_6720_Y_8640 MINT1_X_6720_Y_8640 0 8.2232e-18
C_MINT1_X_6720_Y_8704 MINT1_X_6720_Y_8704 0 6.8527e-18
C_MINT1_X_6720_Y_8960 MINT1_X_6720_Y_8960 0 1.2335e-17
C_MINT1_X_6720_Y_9280 MINT1_X_6720_Y_9280 0 1.3705e-17
C_MINT1_X_6720_Y_960 MINT1_X_6720_Y_960 0 1.3705e-17
C_MINT1_X_6720_Y_9600 MINT1_X_6720_Y_9600 0 9.5937e-18
C_MINT1_X_6720_Y_9728 MINT1_X_6720_Y_9728 0 6.8527e-18
C_MINT1_X_6720_Y_9920 MINT1_X_6720_Y_9920 0 5.8248e-18
C_MINT1_X_7040_Y_0 MINT1_X_7040_Y_0 0 6.8527e-18
C_MINT1_X_7040_Y_10000 MINT1_X_7040_Y_10000 0 1.7132e-18
C_MINT1_X_7040_Y_1024 MINT1_X_7040_Y_1024 0 6.8527e-18
C_MINT1_X_7040_Y_1280 MINT1_X_7040_Y_1280 0 1.2335e-17
C_MINT1_X_7040_Y_1600 MINT1_X_7040_Y_1600 0 1.3705e-17
C_MINT1_X_7040_Y_1920 MINT1_X_7040_Y_1920 0 9.5937e-18
C_MINT1_X_7040_Y_2048 MINT1_X_7040_Y_2048 0 6.8527e-18
C_MINT1_X_7040_Y_2240 MINT1_X_7040_Y_2240 0 1.0964e-17
C_MINT1_X_7040_Y_2560 MINT1_X_7040_Y_2560 0 1.3705e-17
C_MINT1_X_7040_Y_2880 MINT1_X_7040_Y_2880 0 1.0964e-17
C_MINT1_X_7040_Y_3072 MINT1_X_7040_Y_3072 0 6.8527e-18
C_MINT1_X_7040_Y_320 MINT1_X_7040_Y_320 0 1.3705e-17
C_MINT1_X_7040_Y_3200 MINT1_X_7040_Y_3200 0 9.5937e-18
C_MINT1_X_7040_Y_3520 MINT1_X_7040_Y_3520 0 1.3705e-17
C_MINT1_X_7040_Y_3840 MINT1_X_7040_Y_3840 0 1.2335e-17
C_MINT1_X_7040_Y_4096 MINT1_X_7040_Y_4096 0 6.8527e-18
C_MINT1_X_7040_Y_4160 MINT1_X_7040_Y_4160 0 8.2232e-18
C_MINT1_X_7040_Y_4480 MINT1_X_7040_Y_4480 0 1.3705e-17
C_MINT1_X_7040_Y_4800 MINT1_X_7040_Y_4800 0 1.3705e-17
C_MINT1_X_7040_Y_5120 MINT1_X_7040_Y_5120 0 1.3705e-17
C_MINT1_X_7040_Y_5440 MINT1_X_7040_Y_5440 0 1.3705e-17
C_MINT1_X_7040_Y_5760 MINT1_X_7040_Y_5760 0 1.3705e-17
C_MINT1_X_7040_Y_6080 MINT1_X_7040_Y_6080 0 8.2232e-18
C_MINT1_X_7040_Y_6144 MINT1_X_7040_Y_6144 0 6.8527e-18
C_MINT1_X_7040_Y_640 MINT1_X_7040_Y_640 0 1.3705e-17
C_MINT1_X_7040_Y_6400 MINT1_X_7040_Y_6400 0 1.2335e-17
C_MINT1_X_7040_Y_6720 MINT1_X_7040_Y_6720 0 1.3705e-17
C_MINT1_X_7040_Y_7040 MINT1_X_7040_Y_7040 0 9.5937e-18
C_MINT1_X_7040_Y_7168 MINT1_X_7040_Y_7168 0 6.8527e-18
C_MINT1_X_7040_Y_7360 MINT1_X_7040_Y_7360 0 1.0964e-17
C_MINT1_X_7040_Y_7680 MINT1_X_7040_Y_7680 0 1.3705e-17
C_MINT1_X_7040_Y_8000 MINT1_X_7040_Y_8000 0 1.0964e-17
C_MINT1_X_7040_Y_8192 MINT1_X_7040_Y_8192 0 6.8527e-18
C_MINT1_X_7040_Y_8320 MINT1_X_7040_Y_8320 0 9.5937e-18
C_MINT1_X_7040_Y_8640 MINT1_X_7040_Y_8640 0 1.3705e-17
C_MINT1_X_7040_Y_8960 MINT1_X_7040_Y_8960 0 1.2335e-17
C_MINT1_X_7040_Y_9216 MINT1_X_7040_Y_9216 0 6.8527e-18
C_MINT1_X_7040_Y_9280 MINT1_X_7040_Y_9280 0 8.2232e-18
C_MINT1_X_7040_Y_960 MINT1_X_7040_Y_960 0 8.2232e-18
C_MINT1_X_7040_Y_9600 MINT1_X_7040_Y_9600 0 1.3705e-17
C_MINT1_X_7040_Y_9920 MINT1_X_7040_Y_9920 0 8.5658e-18
C_MINT1_X_7360_Y_0 MINT1_X_7360_Y_0 0 6.8527e-18
C_MINT1_X_7360_Y_10000 MINT1_X_7360_Y_10000 0 1.7132e-18
C_MINT1_X_7360_Y_1280 MINT1_X_7360_Y_1280 0 1.2335e-17
C_MINT1_X_7360_Y_1536 MINT1_X_7360_Y_1536 0 6.8527e-18
C_MINT1_X_7360_Y_1600 MINT1_X_7360_Y_1600 0 8.2232e-18
C_MINT1_X_7360_Y_1920 MINT1_X_7360_Y_1920 0 1.3705e-17
C_MINT1_X_7360_Y_2240 MINT1_X_7360_Y_2240 0 1.3705e-17
C_MINT1_X_7360_Y_2560 MINT1_X_7360_Y_2560 0 1.3705e-17
C_MINT1_X_7360_Y_2880 MINT1_X_7360_Y_2880 0 1.3705e-17
C_MINT1_X_7360_Y_320 MINT1_X_7360_Y_320 0 1.0964e-17
C_MINT1_X_7360_Y_3200 MINT1_X_7360_Y_3200 0 1.3705e-17
C_MINT1_X_7360_Y_3520 MINT1_X_7360_Y_3520 0 8.2232e-18
C_MINT1_X_7360_Y_3584 MINT1_X_7360_Y_3584 0 6.8527e-18
C_MINT1_X_7360_Y_3840 MINT1_X_7360_Y_3840 0 1.2335e-17
C_MINT1_X_7360_Y_4160 MINT1_X_7360_Y_4160 0 1.3705e-17
C_MINT1_X_7360_Y_4480 MINT1_X_7360_Y_4480 0 9.5937e-18
C_MINT1_X_7360_Y_4608 MINT1_X_7360_Y_4608 0 6.8527e-18
C_MINT1_X_7360_Y_4800 MINT1_X_7360_Y_4800 0 1.0964e-17
C_MINT1_X_7360_Y_512 MINT1_X_7360_Y_512 0 6.8527e-18
C_MINT1_X_7360_Y_5120 MINT1_X_7360_Y_5120 0 1.3705e-17
C_MINT1_X_7360_Y_5440 MINT1_X_7360_Y_5440 0 1.0964e-17
C_MINT1_X_7360_Y_5632 MINT1_X_7360_Y_5632 0 6.8527e-18
C_MINT1_X_7360_Y_5760 MINT1_X_7360_Y_5760 0 9.5937e-18
C_MINT1_X_7360_Y_6080 MINT1_X_7360_Y_6080 0 1.3705e-17
C_MINT1_X_7360_Y_640 MINT1_X_7360_Y_640 0 9.5937e-18
C_MINT1_X_7360_Y_6400 MINT1_X_7360_Y_6400 0 1.2335e-17
C_MINT1_X_7360_Y_6656 MINT1_X_7360_Y_6656 0 6.8527e-18
C_MINT1_X_7360_Y_6720 MINT1_X_7360_Y_6720 0 8.2232e-18
C_MINT1_X_7360_Y_7040 MINT1_X_7360_Y_7040 0 1.3705e-17
C_MINT1_X_7360_Y_7360 MINT1_X_7360_Y_7360 0 1.3705e-17
C_MINT1_X_7360_Y_7680 MINT1_X_7360_Y_7680 0 1.3705e-17
C_MINT1_X_7360_Y_8000 MINT1_X_7360_Y_8000 0 1.3705e-17
C_MINT1_X_7360_Y_8320 MINT1_X_7360_Y_8320 0 1.3705e-17
C_MINT1_X_7360_Y_8640 MINT1_X_7360_Y_8640 0 8.2232e-18
C_MINT1_X_7360_Y_8704 MINT1_X_7360_Y_8704 0 6.8527e-18
C_MINT1_X_7360_Y_8960 MINT1_X_7360_Y_8960 0 1.2335e-17
C_MINT1_X_7360_Y_9280 MINT1_X_7360_Y_9280 0 1.3705e-17
C_MINT1_X_7360_Y_960 MINT1_X_7360_Y_960 0 1.3705e-17
C_MINT1_X_7360_Y_9600 MINT1_X_7360_Y_9600 0 9.5937e-18
C_MINT1_X_7360_Y_9728 MINT1_X_7360_Y_9728 0 6.8527e-18
C_MINT1_X_7360_Y_9920 MINT1_X_7360_Y_9920 0 5.8248e-18
C_MINT1_X_7680_Y_0 MINT1_X_7680_Y_0 0 6.8527e-18
C_MINT1_X_7680_Y_10000 MINT1_X_7680_Y_10000 0 1.7132e-18
C_MINT1_X_7680_Y_1024 MINT1_X_7680_Y_1024 0 6.8527e-18
C_MINT1_X_7680_Y_1280 MINT1_X_7680_Y_1280 0 1.2335e-17
C_MINT1_X_7680_Y_1600 MINT1_X_7680_Y_1600 0 1.3705e-17
C_MINT1_X_7680_Y_1920 MINT1_X_7680_Y_1920 0 9.5937e-18
C_MINT1_X_7680_Y_2048 MINT1_X_7680_Y_2048 0 6.8527e-18
C_MINT1_X_7680_Y_2240 MINT1_X_7680_Y_2240 0 1.0964e-17
C_MINT1_X_7680_Y_2560 MINT1_X_7680_Y_2560 0 1.3705e-17
C_MINT1_X_7680_Y_2880 MINT1_X_7680_Y_2880 0 1.0964e-17
C_MINT1_X_7680_Y_3072 MINT1_X_7680_Y_3072 0 6.8527e-18
C_MINT1_X_7680_Y_320 MINT1_X_7680_Y_320 0 1.3705e-17
C_MINT1_X_7680_Y_3200 MINT1_X_7680_Y_3200 0 9.5937e-18
C_MINT1_X_7680_Y_3520 MINT1_X_7680_Y_3520 0 1.3705e-17
C_MINT1_X_7680_Y_3840 MINT1_X_7680_Y_3840 0 1.2335e-17
C_MINT1_X_7680_Y_4096 MINT1_X_7680_Y_4096 0 6.8527e-18
C_MINT1_X_7680_Y_4160 MINT1_X_7680_Y_4160 0 8.2232e-18
C_MINT1_X_7680_Y_4480 MINT1_X_7680_Y_4480 0 1.3705e-17
C_MINT1_X_7680_Y_4800 MINT1_X_7680_Y_4800 0 1.3705e-17
C_MINT1_X_7680_Y_5120 MINT1_X_7680_Y_5120 0 1.3705e-17
C_MINT1_X_7680_Y_5440 MINT1_X_7680_Y_5440 0 1.3705e-17
C_MINT1_X_7680_Y_5760 MINT1_X_7680_Y_5760 0 1.3705e-17
C_MINT1_X_7680_Y_6080 MINT1_X_7680_Y_6080 0 8.2232e-18
C_MINT1_X_7680_Y_6144 MINT1_X_7680_Y_6144 0 6.8527e-18
C_MINT1_X_7680_Y_640 MINT1_X_7680_Y_640 0 1.3705e-17
C_MINT1_X_7680_Y_6400 MINT1_X_7680_Y_6400 0 1.2335e-17
C_MINT1_X_7680_Y_6720 MINT1_X_7680_Y_6720 0 1.3705e-17
C_MINT1_X_7680_Y_7040 MINT1_X_7680_Y_7040 0 9.5937e-18
C_MINT1_X_7680_Y_7168 MINT1_X_7680_Y_7168 0 6.8527e-18
C_MINT1_X_7680_Y_7360 MINT1_X_7680_Y_7360 0 1.0964e-17
C_MINT1_X_7680_Y_7680 MINT1_X_7680_Y_7680 0 1.3705e-17
C_MINT1_X_7680_Y_8000 MINT1_X_7680_Y_8000 0 1.0964e-17
C_MINT1_X_7680_Y_8192 MINT1_X_7680_Y_8192 0 6.8527e-18
C_MINT1_X_7680_Y_8320 MINT1_X_7680_Y_8320 0 9.5937e-18
C_MINT1_X_7680_Y_8640 MINT1_X_7680_Y_8640 0 1.3705e-17
C_MINT1_X_7680_Y_8960 MINT1_X_7680_Y_8960 0 1.2335e-17
C_MINT1_X_7680_Y_9216 MINT1_X_7680_Y_9216 0 6.8527e-18
C_MINT1_X_7680_Y_9280 MINT1_X_7680_Y_9280 0 8.2232e-18
C_MINT1_X_7680_Y_960 MINT1_X_7680_Y_960 0 8.2232e-18
C_MINT1_X_7680_Y_9600 MINT1_X_7680_Y_9600 0 1.3705e-17
C_MINT1_X_7680_Y_9920 MINT1_X_7680_Y_9920 0 8.5658e-18
C_MINT1_X_8000_Y_0 MINT1_X_8000_Y_0 0 6.8527e-18
C_MINT1_X_8000_Y_10000 MINT1_X_8000_Y_10000 0 1.7132e-18
C_MINT1_X_8000_Y_1280 MINT1_X_8000_Y_1280 0 1.2335e-17
C_MINT1_X_8000_Y_1536 MINT1_X_8000_Y_1536 0 6.8527e-18
C_MINT1_X_8000_Y_1600 MINT1_X_8000_Y_1600 0 8.2232e-18
C_MINT1_X_8000_Y_1920 MINT1_X_8000_Y_1920 0 1.3705e-17
C_MINT1_X_8000_Y_2240 MINT1_X_8000_Y_2240 0 1.3705e-17
C_MINT1_X_8000_Y_2560 MINT1_X_8000_Y_2560 0 1.3705e-17
C_MINT1_X_8000_Y_2880 MINT1_X_8000_Y_2880 0 1.3705e-17
C_MINT1_X_8000_Y_320 MINT1_X_8000_Y_320 0 1.0964e-17
C_MINT1_X_8000_Y_3200 MINT1_X_8000_Y_3200 0 1.3705e-17
C_MINT1_X_8000_Y_3520 MINT1_X_8000_Y_3520 0 8.2232e-18
C_MINT1_X_8000_Y_3584 MINT1_X_8000_Y_3584 0 6.8527e-18
C_MINT1_X_8000_Y_3840 MINT1_X_8000_Y_3840 0 1.2335e-17
C_MINT1_X_8000_Y_4160 MINT1_X_8000_Y_4160 0 1.3705e-17
C_MINT1_X_8000_Y_4480 MINT1_X_8000_Y_4480 0 9.5937e-18
C_MINT1_X_8000_Y_4608 MINT1_X_8000_Y_4608 0 6.8527e-18
C_MINT1_X_8000_Y_4800 MINT1_X_8000_Y_4800 0 1.0964e-17
C_MINT1_X_8000_Y_512 MINT1_X_8000_Y_512 0 6.8527e-18
C_MINT1_X_8000_Y_5120 MINT1_X_8000_Y_5120 0 1.3705e-17
C_MINT1_X_8000_Y_5440 MINT1_X_8000_Y_5440 0 1.0964e-17
C_MINT1_X_8000_Y_5632 MINT1_X_8000_Y_5632 0 6.8527e-18
C_MINT1_X_8000_Y_5760 MINT1_X_8000_Y_5760 0 9.5937e-18
C_MINT1_X_8000_Y_6080 MINT1_X_8000_Y_6080 0 1.3705e-17
C_MINT1_X_8000_Y_640 MINT1_X_8000_Y_640 0 9.5937e-18
C_MINT1_X_8000_Y_6400 MINT1_X_8000_Y_6400 0 1.2335e-17
C_MINT1_X_8000_Y_6656 MINT1_X_8000_Y_6656 0 6.8527e-18
C_MINT1_X_8000_Y_6720 MINT1_X_8000_Y_6720 0 8.2232e-18
C_MINT1_X_8000_Y_7040 MINT1_X_8000_Y_7040 0 1.3705e-17
C_MINT1_X_8000_Y_7360 MINT1_X_8000_Y_7360 0 1.3705e-17
C_MINT1_X_8000_Y_7680 MINT1_X_8000_Y_7680 0 1.3705e-17
C_MINT1_X_8000_Y_8000 MINT1_X_8000_Y_8000 0 1.3705e-17
C_MINT1_X_8000_Y_8320 MINT1_X_8000_Y_8320 0 1.3705e-17
C_MINT1_X_8000_Y_8640 MINT1_X_8000_Y_8640 0 8.2232e-18
C_MINT1_X_8000_Y_8704 MINT1_X_8000_Y_8704 0 6.8527e-18
C_MINT1_X_8000_Y_8960 MINT1_X_8000_Y_8960 0 1.2335e-17
C_MINT1_X_8000_Y_9280 MINT1_X_8000_Y_9280 0 1.3705e-17
C_MINT1_X_8000_Y_960 MINT1_X_8000_Y_960 0 1.3705e-17
C_MINT1_X_8000_Y_9600 MINT1_X_8000_Y_9600 0 9.5937e-18
C_MINT1_X_8000_Y_9728 MINT1_X_8000_Y_9728 0 6.8527e-18
C_MINT1_X_8000_Y_9920 MINT1_X_8000_Y_9920 0 5.8248e-18
C_MINT1_X_8320_Y_0 MINT1_X_8320_Y_0 0 6.8527e-18
C_MINT1_X_8320_Y_10000 MINT1_X_8320_Y_10000 0 1.7132e-18
C_MINT1_X_8320_Y_1024 MINT1_X_8320_Y_1024 0 6.8527e-18
C_MINT1_X_8320_Y_1280 MINT1_X_8320_Y_1280 0 1.2335e-17
C_MINT1_X_8320_Y_1600 MINT1_X_8320_Y_1600 0 1.3705e-17
C_MINT1_X_8320_Y_1920 MINT1_X_8320_Y_1920 0 9.5937e-18
C_MINT1_X_8320_Y_2048 MINT1_X_8320_Y_2048 0 6.8527e-18
C_MINT1_X_8320_Y_2240 MINT1_X_8320_Y_2240 0 1.0964e-17
C_MINT1_X_8320_Y_2560 MINT1_X_8320_Y_2560 0 1.3705e-17
C_MINT1_X_8320_Y_2880 MINT1_X_8320_Y_2880 0 1.0964e-17
C_MINT1_X_8320_Y_3072 MINT1_X_8320_Y_3072 0 6.8527e-18
C_MINT1_X_8320_Y_320 MINT1_X_8320_Y_320 0 1.3705e-17
C_MINT1_X_8320_Y_3200 MINT1_X_8320_Y_3200 0 9.5937e-18
C_MINT1_X_8320_Y_3520 MINT1_X_8320_Y_3520 0 1.3705e-17
C_MINT1_X_8320_Y_3840 MINT1_X_8320_Y_3840 0 1.2335e-17
C_MINT1_X_8320_Y_4096 MINT1_X_8320_Y_4096 0 6.8527e-18
C_MINT1_X_8320_Y_4160 MINT1_X_8320_Y_4160 0 8.2232e-18
C_MINT1_X_8320_Y_4480 MINT1_X_8320_Y_4480 0 1.3705e-17
C_MINT1_X_8320_Y_4800 MINT1_X_8320_Y_4800 0 1.3705e-17
C_MINT1_X_8320_Y_5120 MINT1_X_8320_Y_5120 0 1.3705e-17
C_MINT1_X_8320_Y_5440 MINT1_X_8320_Y_5440 0 1.3705e-17
C_MINT1_X_8320_Y_5760 MINT1_X_8320_Y_5760 0 1.3705e-17
C_MINT1_X_8320_Y_6080 MINT1_X_8320_Y_6080 0 8.2232e-18
C_MINT1_X_8320_Y_6144 MINT1_X_8320_Y_6144 0 6.8527e-18
C_MINT1_X_8320_Y_640 MINT1_X_8320_Y_640 0 1.3705e-17
C_MINT1_X_8320_Y_6400 MINT1_X_8320_Y_6400 0 1.2335e-17
C_MINT1_X_8320_Y_6720 MINT1_X_8320_Y_6720 0 1.3705e-17
C_MINT1_X_8320_Y_7040 MINT1_X_8320_Y_7040 0 9.5937e-18
C_MINT1_X_8320_Y_7168 MINT1_X_8320_Y_7168 0 6.8527e-18
C_MINT1_X_8320_Y_7360 MINT1_X_8320_Y_7360 0 1.0964e-17
C_MINT1_X_8320_Y_7680 MINT1_X_8320_Y_7680 0 1.3705e-17
C_MINT1_X_8320_Y_8000 MINT1_X_8320_Y_8000 0 1.0964e-17
C_MINT1_X_8320_Y_8192 MINT1_X_8320_Y_8192 0 6.8527e-18
C_MINT1_X_8320_Y_8320 MINT1_X_8320_Y_8320 0 9.5937e-18
C_MINT1_X_8320_Y_8640 MINT1_X_8320_Y_8640 0 1.3705e-17
C_MINT1_X_8320_Y_8960 MINT1_X_8320_Y_8960 0 1.2335e-17
C_MINT1_X_8320_Y_9216 MINT1_X_8320_Y_9216 0 6.8527e-18
C_MINT1_X_8320_Y_9280 MINT1_X_8320_Y_9280 0 8.2232e-18
C_MINT1_X_8320_Y_960 MINT1_X_8320_Y_960 0 8.2232e-18
C_MINT1_X_8320_Y_9600 MINT1_X_8320_Y_9600 0 1.3705e-17
C_MINT1_X_8320_Y_9920 MINT1_X_8320_Y_9920 0 8.5658e-18
C_MINT1_X_8640_Y_0 MINT1_X_8640_Y_0 0 6.8527e-18
C_MINT1_X_8640_Y_10000 MINT1_X_8640_Y_10000 0 1.7132e-18
C_MINT1_X_8640_Y_1280 MINT1_X_8640_Y_1280 0 1.2335e-17
C_MINT1_X_8640_Y_1536 MINT1_X_8640_Y_1536 0 6.8527e-18
C_MINT1_X_8640_Y_1600 MINT1_X_8640_Y_1600 0 8.2232e-18
C_MINT1_X_8640_Y_1920 MINT1_X_8640_Y_1920 0 1.3705e-17
C_MINT1_X_8640_Y_2240 MINT1_X_8640_Y_2240 0 1.3705e-17
C_MINT1_X_8640_Y_2560 MINT1_X_8640_Y_2560 0 1.3705e-17
C_MINT1_X_8640_Y_2880 MINT1_X_8640_Y_2880 0 1.3705e-17
C_MINT1_X_8640_Y_320 MINT1_X_8640_Y_320 0 1.0964e-17
C_MINT1_X_8640_Y_3200 MINT1_X_8640_Y_3200 0 1.3705e-17
C_MINT1_X_8640_Y_3520 MINT1_X_8640_Y_3520 0 8.2232e-18
C_MINT1_X_8640_Y_3584 MINT1_X_8640_Y_3584 0 6.8527e-18
C_MINT1_X_8640_Y_3840 MINT1_X_8640_Y_3840 0 1.2335e-17
C_MINT1_X_8640_Y_4160 MINT1_X_8640_Y_4160 0 1.3705e-17
C_MINT1_X_8640_Y_4480 MINT1_X_8640_Y_4480 0 9.5937e-18
C_MINT1_X_8640_Y_4608 MINT1_X_8640_Y_4608 0 6.8527e-18
C_MINT1_X_8640_Y_4800 MINT1_X_8640_Y_4800 0 1.0964e-17
C_MINT1_X_8640_Y_512 MINT1_X_8640_Y_512 0 6.8527e-18
C_MINT1_X_8640_Y_5120 MINT1_X_8640_Y_5120 0 1.3705e-17
C_MINT1_X_8640_Y_5440 MINT1_X_8640_Y_5440 0 1.0964e-17
C_MINT1_X_8640_Y_5632 MINT1_X_8640_Y_5632 0 6.8527e-18
C_MINT1_X_8640_Y_5760 MINT1_X_8640_Y_5760 0 9.5937e-18
C_MINT1_X_8640_Y_6080 MINT1_X_8640_Y_6080 0 1.3705e-17
C_MINT1_X_8640_Y_640 MINT1_X_8640_Y_640 0 9.5937e-18
C_MINT1_X_8640_Y_6400 MINT1_X_8640_Y_6400 0 1.2335e-17
C_MINT1_X_8640_Y_6656 MINT1_X_8640_Y_6656 0 6.8527e-18
C_MINT1_X_8640_Y_6720 MINT1_X_8640_Y_6720 0 8.2232e-18
C_MINT1_X_8640_Y_7040 MINT1_X_8640_Y_7040 0 1.3705e-17
C_MINT1_X_8640_Y_7360 MINT1_X_8640_Y_7360 0 1.3705e-17
C_MINT1_X_8640_Y_7680 MINT1_X_8640_Y_7680 0 1.3705e-17
C_MINT1_X_8640_Y_8000 MINT1_X_8640_Y_8000 0 1.3705e-17
C_MINT1_X_8640_Y_8320 MINT1_X_8640_Y_8320 0 1.3705e-17
C_MINT1_X_8640_Y_8640 MINT1_X_8640_Y_8640 0 8.2232e-18
C_MINT1_X_8640_Y_8704 MINT1_X_8640_Y_8704 0 6.8527e-18
C_MINT1_X_8640_Y_8960 MINT1_X_8640_Y_8960 0 1.2335e-17
C_MINT1_X_8640_Y_9280 MINT1_X_8640_Y_9280 0 1.3705e-17
C_MINT1_X_8640_Y_960 MINT1_X_8640_Y_960 0 1.3705e-17
C_MINT1_X_8640_Y_9600 MINT1_X_8640_Y_9600 0 9.5937e-18
C_MINT1_X_8640_Y_9728 MINT1_X_8640_Y_9728 0 6.8527e-18
C_MINT1_X_8640_Y_9920 MINT1_X_8640_Y_9920 0 5.8248e-18
C_MINT1_X_8960_Y_0 MINT1_X_8960_Y_0 0 6.8527e-18
C_MINT1_X_8960_Y_10000 MINT1_X_8960_Y_10000 0 1.7132e-18
C_MINT1_X_8960_Y_1024 MINT1_X_8960_Y_1024 0 6.8527e-18
C_MINT1_X_8960_Y_1280 MINT1_X_8960_Y_1280 0 1.2335e-17
C_MINT1_X_8960_Y_1600 MINT1_X_8960_Y_1600 0 1.3705e-17
C_MINT1_X_8960_Y_1920 MINT1_X_8960_Y_1920 0 9.5937e-18
C_MINT1_X_8960_Y_2048 MINT1_X_8960_Y_2048 0 6.8527e-18
C_MINT1_X_8960_Y_2240 MINT1_X_8960_Y_2240 0 1.0964e-17
C_MINT1_X_8960_Y_2560 MINT1_X_8960_Y_2560 0 1.3705e-17
C_MINT1_X_8960_Y_2880 MINT1_X_8960_Y_2880 0 1.0964e-17
C_MINT1_X_8960_Y_3072 MINT1_X_8960_Y_3072 0 6.8527e-18
C_MINT1_X_8960_Y_320 MINT1_X_8960_Y_320 0 1.3705e-17
C_MINT1_X_8960_Y_3200 MINT1_X_8960_Y_3200 0 9.5937e-18
C_MINT1_X_8960_Y_3520 MINT1_X_8960_Y_3520 0 1.3705e-17
C_MINT1_X_8960_Y_3840 MINT1_X_8960_Y_3840 0 1.2335e-17
C_MINT1_X_8960_Y_4096 MINT1_X_8960_Y_4096 0 6.8527e-18
C_MINT1_X_8960_Y_4160 MINT1_X_8960_Y_4160 0 8.2232e-18
C_MINT1_X_8960_Y_4480 MINT1_X_8960_Y_4480 0 1.3705e-17
C_MINT1_X_8960_Y_4800 MINT1_X_8960_Y_4800 0 1.3705e-17
C_MINT1_X_8960_Y_5120 MINT1_X_8960_Y_5120 0 1.3705e-17
C_MINT1_X_8960_Y_5440 MINT1_X_8960_Y_5440 0 1.3705e-17
C_MINT1_X_8960_Y_5760 MINT1_X_8960_Y_5760 0 1.3705e-17
C_MINT1_X_8960_Y_6080 MINT1_X_8960_Y_6080 0 8.2232e-18
C_MINT1_X_8960_Y_6144 MINT1_X_8960_Y_6144 0 6.8527e-18
C_MINT1_X_8960_Y_640 MINT1_X_8960_Y_640 0 1.3705e-17
C_MINT1_X_8960_Y_6400 MINT1_X_8960_Y_6400 0 1.2335e-17
C_MINT1_X_8960_Y_6720 MINT1_X_8960_Y_6720 0 1.3705e-17
C_MINT1_X_8960_Y_7040 MINT1_X_8960_Y_7040 0 9.5937e-18
C_MINT1_X_8960_Y_7168 MINT1_X_8960_Y_7168 0 6.8527e-18
C_MINT1_X_8960_Y_7360 MINT1_X_8960_Y_7360 0 1.0964e-17
C_MINT1_X_8960_Y_7680 MINT1_X_8960_Y_7680 0 1.3705e-17
C_MINT1_X_8960_Y_8000 MINT1_X_8960_Y_8000 0 1.0964e-17
C_MINT1_X_8960_Y_8192 MINT1_X_8960_Y_8192 0 6.8527e-18
C_MINT1_X_8960_Y_8320 MINT1_X_8960_Y_8320 0 9.5937e-18
C_MINT1_X_8960_Y_8640 MINT1_X_8960_Y_8640 0 1.3705e-17
C_MINT1_X_8960_Y_8960 MINT1_X_8960_Y_8960 0 1.2335e-17
C_MINT1_X_8960_Y_9216 MINT1_X_8960_Y_9216 0 6.8527e-18
C_MINT1_X_8960_Y_9280 MINT1_X_8960_Y_9280 0 8.2232e-18
C_MINT1_X_8960_Y_960 MINT1_X_8960_Y_960 0 8.2232e-18
C_MINT1_X_8960_Y_9600 MINT1_X_8960_Y_9600 0 1.3705e-17
C_MINT1_X_8960_Y_9920 MINT1_X_8960_Y_9920 0 8.5658e-18
C_MINT1_X_9280_Y_0 MINT1_X_9280_Y_0 0 6.8527e-18
C_MINT1_X_9280_Y_10000 MINT1_X_9280_Y_10000 0 1.7132e-18
C_MINT1_X_9280_Y_1280 MINT1_X_9280_Y_1280 0 1.2335e-17
C_MINT1_X_9280_Y_1536 MINT1_X_9280_Y_1536 0 6.8527e-18
C_MINT1_X_9280_Y_1600 MINT1_X_9280_Y_1600 0 8.2232e-18
C_MINT1_X_9280_Y_1920 MINT1_X_9280_Y_1920 0 1.3705e-17
C_MINT1_X_9280_Y_2240 MINT1_X_9280_Y_2240 0 1.3705e-17
C_MINT1_X_9280_Y_2560 MINT1_X_9280_Y_2560 0 1.3705e-17
C_MINT1_X_9280_Y_2880 MINT1_X_9280_Y_2880 0 1.3705e-17
C_MINT1_X_9280_Y_320 MINT1_X_9280_Y_320 0 1.0964e-17
C_MINT1_X_9280_Y_3200 MINT1_X_9280_Y_3200 0 1.3705e-17
C_MINT1_X_9280_Y_3520 MINT1_X_9280_Y_3520 0 8.2232e-18
C_MINT1_X_9280_Y_3584 MINT1_X_9280_Y_3584 0 6.8527e-18
C_MINT1_X_9280_Y_3840 MINT1_X_9280_Y_3840 0 1.2335e-17
C_MINT1_X_9280_Y_4160 MINT1_X_9280_Y_4160 0 1.3705e-17
C_MINT1_X_9280_Y_4480 MINT1_X_9280_Y_4480 0 9.5937e-18
C_MINT1_X_9280_Y_4608 MINT1_X_9280_Y_4608 0 6.8527e-18
C_MINT1_X_9280_Y_4800 MINT1_X_9280_Y_4800 0 1.0964e-17
C_MINT1_X_9280_Y_512 MINT1_X_9280_Y_512 0 6.8527e-18
C_MINT1_X_9280_Y_5120 MINT1_X_9280_Y_5120 0 1.3705e-17
C_MINT1_X_9280_Y_5440 MINT1_X_9280_Y_5440 0 1.0964e-17
C_MINT1_X_9280_Y_5632 MINT1_X_9280_Y_5632 0 6.8527e-18
C_MINT1_X_9280_Y_5760 MINT1_X_9280_Y_5760 0 9.5937e-18
C_MINT1_X_9280_Y_6080 MINT1_X_9280_Y_6080 0 1.3705e-17
C_MINT1_X_9280_Y_640 MINT1_X_9280_Y_640 0 9.5937e-18
C_MINT1_X_9280_Y_6400 MINT1_X_9280_Y_6400 0 1.2335e-17
C_MINT1_X_9280_Y_6656 MINT1_X_9280_Y_6656 0 6.8527e-18
C_MINT1_X_9280_Y_6720 MINT1_X_9280_Y_6720 0 8.2232e-18
C_MINT1_X_9280_Y_7040 MINT1_X_9280_Y_7040 0 1.3705e-17
C_MINT1_X_9280_Y_7360 MINT1_X_9280_Y_7360 0 1.3705e-17
C_MINT1_X_9280_Y_7680 MINT1_X_9280_Y_7680 0 1.3705e-17
C_MINT1_X_9280_Y_8000 MINT1_X_9280_Y_8000 0 1.3705e-17
C_MINT1_X_9280_Y_8320 MINT1_X_9280_Y_8320 0 1.3705e-17
C_MINT1_X_9280_Y_8640 MINT1_X_9280_Y_8640 0 8.2232e-18
C_MINT1_X_9280_Y_8704 MINT1_X_9280_Y_8704 0 6.8527e-18
C_MINT1_X_9280_Y_8960 MINT1_X_9280_Y_8960 0 1.2335e-17
C_MINT1_X_9280_Y_9280 MINT1_X_9280_Y_9280 0 1.3705e-17
C_MINT1_X_9280_Y_960 MINT1_X_9280_Y_960 0 1.3705e-17
C_MINT1_X_9280_Y_9600 MINT1_X_9280_Y_9600 0 9.5937e-18
C_MINT1_X_9280_Y_9728 MINT1_X_9280_Y_9728 0 6.8527e-18
C_MINT1_X_9280_Y_9920 MINT1_X_9280_Y_9920 0 5.8248e-18
C_MINT1_X_9600_Y_0 MINT1_X_9600_Y_0 0 6.8527e-18
C_MINT1_X_9600_Y_10000 MINT1_X_9600_Y_10000 0 1.7132e-18
C_MINT1_X_9600_Y_1024 MINT1_X_9600_Y_1024 0 6.8527e-18
C_MINT1_X_9600_Y_1280 MINT1_X_9600_Y_1280 0 1.2335e-17
C_MINT1_X_9600_Y_1600 MINT1_X_9600_Y_1600 0 1.3705e-17
C_MINT1_X_9600_Y_1920 MINT1_X_9600_Y_1920 0 9.5937e-18
C_MINT1_X_9600_Y_2048 MINT1_X_9600_Y_2048 0 6.8527e-18
C_MINT1_X_9600_Y_2240 MINT1_X_9600_Y_2240 0 1.0964e-17
C_MINT1_X_9600_Y_2560 MINT1_X_9600_Y_2560 0 1.3705e-17
C_MINT1_X_9600_Y_2880 MINT1_X_9600_Y_2880 0 1.0964e-17
C_MINT1_X_9600_Y_3072 MINT1_X_9600_Y_3072 0 6.8527e-18
C_MINT1_X_9600_Y_320 MINT1_X_9600_Y_320 0 1.3705e-17
C_MINT1_X_9600_Y_3200 MINT1_X_9600_Y_3200 0 9.5937e-18
C_MINT1_X_9600_Y_3520 MINT1_X_9600_Y_3520 0 1.3705e-17
C_MINT1_X_9600_Y_3840 MINT1_X_9600_Y_3840 0 1.2335e-17
C_MINT1_X_9600_Y_4096 MINT1_X_9600_Y_4096 0 6.8527e-18
C_MINT1_X_9600_Y_4160 MINT1_X_9600_Y_4160 0 8.2232e-18
C_MINT1_X_9600_Y_4480 MINT1_X_9600_Y_4480 0 1.3705e-17
C_MINT1_X_9600_Y_4800 MINT1_X_9600_Y_4800 0 1.3705e-17
C_MINT1_X_9600_Y_5120 MINT1_X_9600_Y_5120 0 1.3705e-17
C_MINT1_X_9600_Y_5440 MINT1_X_9600_Y_5440 0 1.3705e-17
C_MINT1_X_9600_Y_5760 MINT1_X_9600_Y_5760 0 1.3705e-17
C_MINT1_X_9600_Y_6080 MINT1_X_9600_Y_6080 0 8.2232e-18
C_MINT1_X_9600_Y_6144 MINT1_X_9600_Y_6144 0 6.8527e-18
C_MINT1_X_9600_Y_640 MINT1_X_9600_Y_640 0 1.3705e-17
C_MINT1_X_9600_Y_6400 MINT1_X_9600_Y_6400 0 1.2335e-17
C_MINT1_X_9600_Y_6720 MINT1_X_9600_Y_6720 0 1.3705e-17
C_MINT1_X_9600_Y_7040 MINT1_X_9600_Y_7040 0 9.5937e-18
C_MINT1_X_9600_Y_7168 MINT1_X_9600_Y_7168 0 6.8527e-18
C_MINT1_X_9600_Y_7360 MINT1_X_9600_Y_7360 0 1.0964e-17
C_MINT1_X_9600_Y_7680 MINT1_X_9600_Y_7680 0 1.3705e-17
C_MINT1_X_9600_Y_8000 MINT1_X_9600_Y_8000 0 1.0964e-17
C_MINT1_X_9600_Y_8192 MINT1_X_9600_Y_8192 0 6.8527e-18
C_MINT1_X_9600_Y_8320 MINT1_X_9600_Y_8320 0 9.5937e-18
C_MINT1_X_9600_Y_8640 MINT1_X_9600_Y_8640 0 1.3705e-17
C_MINT1_X_9600_Y_8960 MINT1_X_9600_Y_8960 0 1.2335e-17
C_MINT1_X_9600_Y_9216 MINT1_X_9600_Y_9216 0 6.8527e-18
C_MINT1_X_9600_Y_9280 MINT1_X_9600_Y_9280 0 8.2232e-18
C_MINT1_X_9600_Y_960 MINT1_X_9600_Y_960 0 8.2232e-18
C_MINT1_X_9600_Y_9600 MINT1_X_9600_Y_9600 0 1.3705e-17
C_MINT1_X_9600_Y_9920 MINT1_X_9600_Y_9920 0 8.5658e-18
C_MINT1_X_960_Y_0 MINT1_X_960_Y_0 0 6.8527e-18
C_MINT1_X_960_Y_10000 MINT1_X_960_Y_10000 0 1.7132e-18
C_MINT1_X_960_Y_1280 MINT1_X_960_Y_1280 0 1.2335e-17
C_MINT1_X_960_Y_1536 MINT1_X_960_Y_1536 0 6.8527e-18
C_MINT1_X_960_Y_1600 MINT1_X_960_Y_1600 0 8.2232e-18
C_MINT1_X_960_Y_1920 MINT1_X_960_Y_1920 0 1.3705e-17
C_MINT1_X_960_Y_2240 MINT1_X_960_Y_2240 0 1.3705e-17
C_MINT1_X_960_Y_2560 MINT1_X_960_Y_2560 0 1.3705e-17
C_MINT1_X_960_Y_2880 MINT1_X_960_Y_2880 0 1.3705e-17
C_MINT1_X_960_Y_320 MINT1_X_960_Y_320 0 1.0964e-17
C_MINT1_X_960_Y_3200 MINT1_X_960_Y_3200 0 1.3705e-17
C_MINT1_X_960_Y_3520 MINT1_X_960_Y_3520 0 8.2232e-18
C_MINT1_X_960_Y_3584 MINT1_X_960_Y_3584 0 6.8527e-18
C_MINT1_X_960_Y_3840 MINT1_X_960_Y_3840 0 1.2335e-17
C_MINT1_X_960_Y_4160 MINT1_X_960_Y_4160 0 1.3705e-17
C_MINT1_X_960_Y_4480 MINT1_X_960_Y_4480 0 9.5937e-18
C_MINT1_X_960_Y_4608 MINT1_X_960_Y_4608 0 6.8527e-18
C_MINT1_X_960_Y_4800 MINT1_X_960_Y_4800 0 1.0964e-17
C_MINT1_X_960_Y_512 MINT1_X_960_Y_512 0 6.8527e-18
C_MINT1_X_960_Y_5120 MINT1_X_960_Y_5120 0 1.3705e-17
C_MINT1_X_960_Y_5440 MINT1_X_960_Y_5440 0 1.0964e-17
C_MINT1_X_960_Y_5632 MINT1_X_960_Y_5632 0 6.8527e-18
C_MINT1_X_960_Y_5760 MINT1_X_960_Y_5760 0 9.5937e-18
C_MINT1_X_960_Y_6080 MINT1_X_960_Y_6080 0 1.3705e-17
C_MINT1_X_960_Y_640 MINT1_X_960_Y_640 0 9.5937e-18
C_MINT1_X_960_Y_6400 MINT1_X_960_Y_6400 0 1.2335e-17
C_MINT1_X_960_Y_6656 MINT1_X_960_Y_6656 0 6.8527e-18
C_MINT1_X_960_Y_6720 MINT1_X_960_Y_6720 0 8.2232e-18
C_MINT1_X_960_Y_7040 MINT1_X_960_Y_7040 0 1.3705e-17
C_MINT1_X_960_Y_7360 MINT1_X_960_Y_7360 0 1.3705e-17
C_MINT1_X_960_Y_7680 MINT1_X_960_Y_7680 0 1.3705e-17
C_MINT1_X_960_Y_8000 MINT1_X_960_Y_8000 0 1.3705e-17
C_MINT1_X_960_Y_8320 MINT1_X_960_Y_8320 0 1.3705e-17
C_MINT1_X_960_Y_8640 MINT1_X_960_Y_8640 0 8.2232e-18
C_MINT1_X_960_Y_8704 MINT1_X_960_Y_8704 0 6.8527e-18
C_MINT1_X_960_Y_8960 MINT1_X_960_Y_8960 0 1.2335e-17
C_MINT1_X_960_Y_9280 MINT1_X_960_Y_9280 0 1.3705e-17
C_MINT1_X_960_Y_960 MINT1_X_960_Y_960 0 1.3705e-17
C_MINT1_X_960_Y_9600 MINT1_X_960_Y_9600 0 9.5937e-18
C_MINT1_X_960_Y_9728 MINT1_X_960_Y_9728 0 6.8527e-18
C_MINT1_X_960_Y_9920 MINT1_X_960_Y_9920 0 5.8248e-18
C_MINT1_X_9920_Y_0 MINT1_X_9920_Y_0 0 6.8527e-18
C_MINT1_X_9920_Y_10000 MINT1_X_9920_Y_10000 0 1.7132e-18
C_MINT1_X_9920_Y_1280 MINT1_X_9920_Y_1280 0 1.2335e-17
C_MINT1_X_9920_Y_1536 MINT1_X_9920_Y_1536 0 6.8527e-18
C_MINT1_X_9920_Y_1600 MINT1_X_9920_Y_1600 0 8.2232e-18
C_MINT1_X_9920_Y_1920 MINT1_X_9920_Y_1920 0 1.3705e-17
C_MINT1_X_9920_Y_2240 MINT1_X_9920_Y_2240 0 1.3705e-17
C_MINT1_X_9920_Y_2560 MINT1_X_9920_Y_2560 0 1.3705e-17
C_MINT1_X_9920_Y_2880 MINT1_X_9920_Y_2880 0 1.3705e-17
C_MINT1_X_9920_Y_320 MINT1_X_9920_Y_320 0 1.0964e-17
C_MINT1_X_9920_Y_3200 MINT1_X_9920_Y_3200 0 1.3705e-17
C_MINT1_X_9920_Y_3520 MINT1_X_9920_Y_3520 0 8.2232e-18
C_MINT1_X_9920_Y_3584 MINT1_X_9920_Y_3584 0 6.8527e-18
C_MINT1_X_9920_Y_3840 MINT1_X_9920_Y_3840 0 1.2335e-17
C_MINT1_X_9920_Y_4160 MINT1_X_9920_Y_4160 0 1.3705e-17
C_MINT1_X_9920_Y_4480 MINT1_X_9920_Y_4480 0 9.5937e-18
C_MINT1_X_9920_Y_4608 MINT1_X_9920_Y_4608 0 6.8527e-18
C_MINT1_X_9920_Y_4800 MINT1_X_9920_Y_4800 0 1.0964e-17
C_MINT1_X_9920_Y_512 MINT1_X_9920_Y_512 0 6.8527e-18
C_MINT1_X_9920_Y_5120 MINT1_X_9920_Y_5120 0 1.3705e-17
C_MINT1_X_9920_Y_5440 MINT1_X_9920_Y_5440 0 1.0964e-17
C_MINT1_X_9920_Y_5632 MINT1_X_9920_Y_5632 0 6.8527e-18
C_MINT1_X_9920_Y_5760 MINT1_X_9920_Y_5760 0 9.5937e-18
C_MINT1_X_9920_Y_6080 MINT1_X_9920_Y_6080 0 1.3705e-17
C_MINT1_X_9920_Y_640 MINT1_X_9920_Y_640 0 9.5937e-18
C_MINT1_X_9920_Y_6400 MINT1_X_9920_Y_6400 0 1.2335e-17
C_MINT1_X_9920_Y_6656 MINT1_X_9920_Y_6656 0 6.8527e-18
C_MINT1_X_9920_Y_6720 MINT1_X_9920_Y_6720 0 8.2232e-18
C_MINT1_X_9920_Y_7040 MINT1_X_9920_Y_7040 0 1.3705e-17
C_MINT1_X_9920_Y_7360 MINT1_X_9920_Y_7360 0 1.3705e-17
C_MINT1_X_9920_Y_7680 MINT1_X_9920_Y_7680 0 1.3705e-17
C_MINT1_X_9920_Y_8000 MINT1_X_9920_Y_8000 0 1.3705e-17
C_MINT1_X_9920_Y_8320 MINT1_X_9920_Y_8320 0 1.3705e-17
C_MINT1_X_9920_Y_8640 MINT1_X_9920_Y_8640 0 8.2232e-18
C_MINT1_X_9920_Y_8704 MINT1_X_9920_Y_8704 0 6.8527e-18
C_MINT1_X_9920_Y_8960 MINT1_X_9920_Y_8960 0 1.2335e-17
C_MINT1_X_9920_Y_9280 MINT1_X_9920_Y_9280 0 1.3705e-17
C_MINT1_X_9920_Y_960 MINT1_X_9920_Y_960 0 1.3705e-17
C_MINT1_X_9920_Y_9600 MINT1_X_9920_Y_9600 0 9.5937e-18
C_MINT1_X_9920_Y_9728 MINT1_X_9920_Y_9728 0 6.8527e-18
C_MINT1_X_9920_Y_9920 MINT1_X_9920_Y_9920 0 5.8248e-18
C_MINT5_X_0_Y_0 MINT5_X_0_Y_0 0 4.1064e-18
C_MINT5_X_0_Y_10000 MINT5_X_0_Y_10000 0 1.0266e-18
C_MINT5_X_0_Y_1120 MINT5_X_0_Y_1120 0 4.1064e-18
C_MINT5_X_0_Y_1280 MINT5_X_0_Y_1280 0 6.1597e-18
C_MINT5_X_0_Y_1600 MINT5_X_0_Y_1600 0 8.2129e-18
C_MINT5_X_0_Y_1920 MINT5_X_0_Y_1920 0 8.2129e-18
C_MINT5_X_0_Y_2240 MINT5_X_0_Y_2240 0 8.2129e-18
C_MINT5_X_0_Y_2560 MINT5_X_0_Y_2560 0 8.2129e-18
C_MINT5_X_0_Y_2880 MINT5_X_0_Y_2880 0 8.2129e-18
C_MINT5_X_0_Y_320 MINT5_X_0_Y_320 0 8.2129e-18
C_MINT5_X_0_Y_3200 MINT5_X_0_Y_3200 0 6.1597e-18
C_MINT5_X_0_Y_3360 MINT5_X_0_Y_3360 0 4.1064e-18
C_MINT5_X_0_Y_3520 MINT5_X_0_Y_3520 0 6.1597e-18
C_MINT5_X_0_Y_3840 MINT5_X_0_Y_3840 0 8.2129e-18
C_MINT5_X_0_Y_4160 MINT5_X_0_Y_4160 0 8.2129e-18
C_MINT5_X_0_Y_4480 MINT5_X_0_Y_4480 0 8.2129e-18
C_MINT5_X_0_Y_4800 MINT5_X_0_Y_4800 0 8.2129e-18
C_MINT5_X_0_Y_5120 MINT5_X_0_Y_5120 0 8.2129e-18
C_MINT5_X_0_Y_5440 MINT5_X_0_Y_5440 0 6.1597e-18
C_MINT5_X_0_Y_5600 MINT5_X_0_Y_5600 0 4.1064e-18
C_MINT5_X_0_Y_5760 MINT5_X_0_Y_5760 0 6.1597e-18
C_MINT5_X_0_Y_6080 MINT5_X_0_Y_6080 0 8.2129e-18
C_MINT5_X_0_Y_640 MINT5_X_0_Y_640 0 8.2129e-18
C_MINT5_X_0_Y_6400 MINT5_X_0_Y_6400 0 8.2129e-18
C_MINT5_X_0_Y_6720 MINT5_X_0_Y_6720 0 8.2129e-18
C_MINT5_X_0_Y_7040 MINT5_X_0_Y_7040 0 8.2129e-18
C_MINT5_X_0_Y_7360 MINT5_X_0_Y_7360 0 8.2129e-18
C_MINT5_X_0_Y_7680 MINT5_X_0_Y_7680 0 6.1597e-18
C_MINT5_X_0_Y_7840 MINT5_X_0_Y_7840 0 4.1064e-18
C_MINT5_X_0_Y_8000 MINT5_X_0_Y_8000 0 6.1597e-18
C_MINT5_X_0_Y_8320 MINT5_X_0_Y_8320 0 8.2129e-18
C_MINT5_X_0_Y_8640 MINT5_X_0_Y_8640 0 8.2129e-18
C_MINT5_X_0_Y_8960 MINT5_X_0_Y_8960 0 8.2129e-18
C_MINT5_X_0_Y_9280 MINT5_X_0_Y_9280 0 8.2129e-18
C_MINT5_X_0_Y_960 MINT5_X_0_Y_960 0 6.1597e-18
C_MINT5_X_0_Y_9600 MINT5_X_0_Y_9600 0 8.2129e-18
C_MINT5_X_0_Y_9920 MINT5_X_0_Y_9920 0 5.1331e-18
C_MINT5_X_1280_Y_0 MINT5_X_1280_Y_0 0 4.1064e-18
C_MINT5_X_1280_Y_10000 MINT5_X_1280_Y_10000 0 1.0266e-18
C_MINT5_X_1280_Y_1120 MINT5_X_1280_Y_1120 0 4.1064e-18
C_MINT5_X_1280_Y_1280 MINT5_X_1280_Y_1280 0 6.1597e-18
C_MINT5_X_1280_Y_1600 MINT5_X_1280_Y_1600 0 8.2129e-18
C_MINT5_X_1280_Y_1920 MINT5_X_1280_Y_1920 0 8.2129e-18
C_MINT5_X_1280_Y_2240 MINT5_X_1280_Y_2240 0 8.2129e-18
C_MINT5_X_1280_Y_2560 MINT5_X_1280_Y_2560 0 8.2129e-18
C_MINT5_X_1280_Y_2880 MINT5_X_1280_Y_2880 0 8.2129e-18
C_MINT5_X_1280_Y_320 MINT5_X_1280_Y_320 0 8.2129e-18
C_MINT5_X_1280_Y_3200 MINT5_X_1280_Y_3200 0 6.1597e-18
C_MINT5_X_1280_Y_3360 MINT5_X_1280_Y_3360 0 4.1064e-18
C_MINT5_X_1280_Y_3520 MINT5_X_1280_Y_3520 0 6.1597e-18
C_MINT5_X_1280_Y_3840 MINT5_X_1280_Y_3840 0 8.2129e-18
C_MINT5_X_1280_Y_4160 MINT5_X_1280_Y_4160 0 8.2129e-18
C_MINT5_X_1280_Y_4480 MINT5_X_1280_Y_4480 0 8.2129e-18
C_MINT5_X_1280_Y_4800 MINT5_X_1280_Y_4800 0 8.2129e-18
C_MINT5_X_1280_Y_5120 MINT5_X_1280_Y_5120 0 8.2129e-18
C_MINT5_X_1280_Y_5440 MINT5_X_1280_Y_5440 0 6.1597e-18
C_MINT5_X_1280_Y_5600 MINT5_X_1280_Y_5600 0 4.1064e-18
C_MINT5_X_1280_Y_5760 MINT5_X_1280_Y_5760 0 6.1597e-18
C_MINT5_X_1280_Y_6080 MINT5_X_1280_Y_6080 0 8.2129e-18
C_MINT5_X_1280_Y_640 MINT5_X_1280_Y_640 0 8.2129e-18
C_MINT5_X_1280_Y_6400 MINT5_X_1280_Y_6400 0 8.2129e-18
C_MINT5_X_1280_Y_6720 MINT5_X_1280_Y_6720 0 8.2129e-18
C_MINT5_X_1280_Y_7040 MINT5_X_1280_Y_7040 0 8.2129e-18
C_MINT5_X_1280_Y_7360 MINT5_X_1280_Y_7360 0 8.2129e-18
C_MINT5_X_1280_Y_7680 MINT5_X_1280_Y_7680 0 6.1597e-18
C_MINT5_X_1280_Y_7840 MINT5_X_1280_Y_7840 0 4.1064e-18
C_MINT5_X_1280_Y_8000 MINT5_X_1280_Y_8000 0 6.1597e-18
C_MINT5_X_1280_Y_8320 MINT5_X_1280_Y_8320 0 8.2129e-18
C_MINT5_X_1280_Y_8640 MINT5_X_1280_Y_8640 0 8.2129e-18
C_MINT5_X_1280_Y_8960 MINT5_X_1280_Y_8960 0 8.2129e-18
C_MINT5_X_1280_Y_9280 MINT5_X_1280_Y_9280 0 8.2129e-18
C_MINT5_X_1280_Y_960 MINT5_X_1280_Y_960 0 6.1597e-18
C_MINT5_X_1280_Y_9600 MINT5_X_1280_Y_9600 0 8.2129e-18
C_MINT5_X_1280_Y_9920 MINT5_X_1280_Y_9920 0 5.1331e-18
C_MINT5_X_1600_Y_0 MINT5_X_1600_Y_0 0 4.1064e-18
C_MINT5_X_1600_Y_10000 MINT5_X_1600_Y_10000 0 1.0266e-18
C_MINT5_X_1600_Y_1280 MINT5_X_1600_Y_1280 0 8.2129e-18
C_MINT5_X_1600_Y_1600 MINT5_X_1600_Y_1600 0 5.1331e-18
C_MINT5_X_1600_Y_1680 MINT5_X_1600_Y_1680 0 4.1064e-18
C_MINT5_X_1600_Y_1920 MINT5_X_1600_Y_1920 0 7.1863e-18
C_MINT5_X_1600_Y_2240 MINT5_X_1600_Y_2240 0 8.2129e-18
C_MINT5_X_1600_Y_2560 MINT5_X_1600_Y_2560 0 7.1863e-18
C_MINT5_X_1600_Y_2800 MINT5_X_1600_Y_2800 0 4.1064e-18
C_MINT5_X_1600_Y_2880 MINT5_X_1600_Y_2880 0 5.1331e-18
C_MINT5_X_1600_Y_320 MINT5_X_1600_Y_320 0 7.1863e-18
C_MINT5_X_1600_Y_3200 MINT5_X_1600_Y_3200 0 8.2129e-18
C_MINT5_X_1600_Y_3520 MINT5_X_1600_Y_3520 0 8.2129e-18
C_MINT5_X_1600_Y_3840 MINT5_X_1600_Y_3840 0 5.1331e-18
C_MINT5_X_1600_Y_3920 MINT5_X_1600_Y_3920 0 4.1064e-18
C_MINT5_X_1600_Y_4160 MINT5_X_1600_Y_4160 0 7.1863e-18
C_MINT5_X_1600_Y_4480 MINT5_X_1600_Y_4480 0 8.2129e-18
C_MINT5_X_1600_Y_4800 MINT5_X_1600_Y_4800 0 7.1863e-18
C_MINT5_X_1600_Y_5040 MINT5_X_1600_Y_5040 0 4.1064e-18
C_MINT5_X_1600_Y_5120 MINT5_X_1600_Y_5120 0 5.1331e-18
C_MINT5_X_1600_Y_5440 MINT5_X_1600_Y_5440 0 8.2129e-18
C_MINT5_X_1600_Y_560 MINT5_X_1600_Y_560 0 4.1064e-18
C_MINT5_X_1600_Y_5760 MINT5_X_1600_Y_5760 0 8.2129e-18
C_MINT5_X_1600_Y_6080 MINT5_X_1600_Y_6080 0 5.1331e-18
C_MINT5_X_1600_Y_6160 MINT5_X_1600_Y_6160 0 4.1064e-18
C_MINT5_X_1600_Y_640 MINT5_X_1600_Y_640 0 5.1331e-18
C_MINT5_X_1600_Y_6400 MINT5_X_1600_Y_6400 0 7.1863e-18
C_MINT5_X_1600_Y_6720 MINT5_X_1600_Y_6720 0 8.2129e-18
C_MINT5_X_1600_Y_7040 MINT5_X_1600_Y_7040 0 7.1863e-18
C_MINT5_X_1600_Y_7280 MINT5_X_1600_Y_7280 0 4.1064e-18
C_MINT5_X_1600_Y_7360 MINT5_X_1600_Y_7360 0 5.1331e-18
C_MINT5_X_1600_Y_7680 MINT5_X_1600_Y_7680 0 8.2129e-18
C_MINT5_X_1600_Y_8000 MINT5_X_1600_Y_8000 0 8.2129e-18
C_MINT5_X_1600_Y_8320 MINT5_X_1600_Y_8320 0 5.1331e-18
C_MINT5_X_1600_Y_8400 MINT5_X_1600_Y_8400 0 4.1064e-18
C_MINT5_X_1600_Y_8640 MINT5_X_1600_Y_8640 0 7.1863e-18
C_MINT5_X_1600_Y_8960 MINT5_X_1600_Y_8960 0 8.2129e-18
C_MINT5_X_1600_Y_9280 MINT5_X_1600_Y_9280 0 7.1863e-18
C_MINT5_X_1600_Y_9520 MINT5_X_1600_Y_9520 0 4.1064e-18
C_MINT5_X_1600_Y_960 MINT5_X_1600_Y_960 0 8.2129e-18
C_MINT5_X_1600_Y_9600 MINT5_X_1600_Y_9600 0 5.1331e-18
C_MINT5_X_1600_Y_9920 MINT5_X_1600_Y_9920 0 5.1331e-18
C_MINT5_X_1920_Y_0 MINT5_X_1920_Y_0 0 4.1064e-18
C_MINT5_X_1920_Y_10000 MINT5_X_1920_Y_10000 0 1.0266e-18
C_MINT5_X_1920_Y_1120 MINT5_X_1920_Y_1120 0 4.1064e-18
C_MINT5_X_1920_Y_1280 MINT5_X_1920_Y_1280 0 6.1597e-18
C_MINT5_X_1920_Y_1600 MINT5_X_1920_Y_1600 0 8.2129e-18
C_MINT5_X_1920_Y_1920 MINT5_X_1920_Y_1920 0 8.2129e-18
C_MINT5_X_1920_Y_2240 MINT5_X_1920_Y_2240 0 8.2129e-18
C_MINT5_X_1920_Y_2560 MINT5_X_1920_Y_2560 0 8.2129e-18
C_MINT5_X_1920_Y_2880 MINT5_X_1920_Y_2880 0 8.2129e-18
C_MINT5_X_1920_Y_320 MINT5_X_1920_Y_320 0 8.2129e-18
C_MINT5_X_1920_Y_3200 MINT5_X_1920_Y_3200 0 6.1597e-18
C_MINT5_X_1920_Y_3360 MINT5_X_1920_Y_3360 0 4.1064e-18
C_MINT5_X_1920_Y_3520 MINT5_X_1920_Y_3520 0 6.1597e-18
C_MINT5_X_1920_Y_3840 MINT5_X_1920_Y_3840 0 8.2129e-18
C_MINT5_X_1920_Y_4160 MINT5_X_1920_Y_4160 0 8.2129e-18
C_MINT5_X_1920_Y_4480 MINT5_X_1920_Y_4480 0 8.2129e-18
C_MINT5_X_1920_Y_4800 MINT5_X_1920_Y_4800 0 8.2129e-18
C_MINT5_X_1920_Y_5120 MINT5_X_1920_Y_5120 0 8.2129e-18
C_MINT5_X_1920_Y_5440 MINT5_X_1920_Y_5440 0 6.1597e-18
C_MINT5_X_1920_Y_5600 MINT5_X_1920_Y_5600 0 4.1064e-18
C_MINT5_X_1920_Y_5760 MINT5_X_1920_Y_5760 0 6.1597e-18
C_MINT5_X_1920_Y_6080 MINT5_X_1920_Y_6080 0 8.2129e-18
C_MINT5_X_1920_Y_640 MINT5_X_1920_Y_640 0 8.2129e-18
C_MINT5_X_1920_Y_6400 MINT5_X_1920_Y_6400 0 8.2129e-18
C_MINT5_X_1920_Y_6720 MINT5_X_1920_Y_6720 0 8.2129e-18
C_MINT5_X_1920_Y_7040 MINT5_X_1920_Y_7040 0 8.2129e-18
C_MINT5_X_1920_Y_7360 MINT5_X_1920_Y_7360 0 8.2129e-18
C_MINT5_X_1920_Y_7680 MINT5_X_1920_Y_7680 0 6.1597e-18
C_MINT5_X_1920_Y_7840 MINT5_X_1920_Y_7840 0 4.1064e-18
C_MINT5_X_1920_Y_8000 MINT5_X_1920_Y_8000 0 6.1597e-18
C_MINT5_X_1920_Y_8320 MINT5_X_1920_Y_8320 0 8.2129e-18
C_MINT5_X_1920_Y_8640 MINT5_X_1920_Y_8640 0 8.2129e-18
C_MINT5_X_1920_Y_8960 MINT5_X_1920_Y_8960 0 8.2129e-18
C_MINT5_X_1920_Y_9280 MINT5_X_1920_Y_9280 0 8.2129e-18
C_MINT5_X_1920_Y_960 MINT5_X_1920_Y_960 0 6.1597e-18
C_MINT5_X_1920_Y_9600 MINT5_X_1920_Y_9600 0 8.2129e-18
C_MINT5_X_1920_Y_9920 MINT5_X_1920_Y_9920 0 5.1331e-18
C_MINT5_X_2240_Y_0 MINT5_X_2240_Y_0 0 4.1064e-18
C_MINT5_X_2240_Y_10000 MINT5_X_2240_Y_10000 0 1.0266e-18
C_MINT5_X_2240_Y_1280 MINT5_X_2240_Y_1280 0 8.2129e-18
C_MINT5_X_2240_Y_1600 MINT5_X_2240_Y_1600 0 5.1331e-18
C_MINT5_X_2240_Y_1680 MINT5_X_2240_Y_1680 0 4.1064e-18
C_MINT5_X_2240_Y_1920 MINT5_X_2240_Y_1920 0 7.1863e-18
C_MINT5_X_2240_Y_2240 MINT5_X_2240_Y_2240 0 8.2129e-18
C_MINT5_X_2240_Y_2560 MINT5_X_2240_Y_2560 0 7.1863e-18
C_MINT5_X_2240_Y_2800 MINT5_X_2240_Y_2800 0 4.1064e-18
C_MINT5_X_2240_Y_2880 MINT5_X_2240_Y_2880 0 5.1331e-18
C_MINT5_X_2240_Y_320 MINT5_X_2240_Y_320 0 7.1863e-18
C_MINT5_X_2240_Y_3200 MINT5_X_2240_Y_3200 0 8.2129e-18
C_MINT5_X_2240_Y_3520 MINT5_X_2240_Y_3520 0 8.2129e-18
C_MINT5_X_2240_Y_3840 MINT5_X_2240_Y_3840 0 5.1331e-18
C_MINT5_X_2240_Y_3920 MINT5_X_2240_Y_3920 0 4.1064e-18
C_MINT5_X_2240_Y_4160 MINT5_X_2240_Y_4160 0 7.1863e-18
C_MINT5_X_2240_Y_4480 MINT5_X_2240_Y_4480 0 8.2129e-18
C_MINT5_X_2240_Y_4800 MINT5_X_2240_Y_4800 0 7.1863e-18
C_MINT5_X_2240_Y_5040 MINT5_X_2240_Y_5040 0 4.1064e-18
C_MINT5_X_2240_Y_5120 MINT5_X_2240_Y_5120 0 5.1331e-18
C_MINT5_X_2240_Y_5440 MINT5_X_2240_Y_5440 0 8.2129e-18
C_MINT5_X_2240_Y_560 MINT5_X_2240_Y_560 0 4.1064e-18
C_MINT5_X_2240_Y_5760 MINT5_X_2240_Y_5760 0 8.2129e-18
C_MINT5_X_2240_Y_6080 MINT5_X_2240_Y_6080 0 5.1331e-18
C_MINT5_X_2240_Y_6160 MINT5_X_2240_Y_6160 0 4.1064e-18
C_MINT5_X_2240_Y_640 MINT5_X_2240_Y_640 0 5.1331e-18
C_MINT5_X_2240_Y_6400 MINT5_X_2240_Y_6400 0 7.1863e-18
C_MINT5_X_2240_Y_6720 MINT5_X_2240_Y_6720 0 8.2129e-18
C_MINT5_X_2240_Y_7040 MINT5_X_2240_Y_7040 0 7.1863e-18
C_MINT5_X_2240_Y_7280 MINT5_X_2240_Y_7280 0 4.1064e-18
C_MINT5_X_2240_Y_7360 MINT5_X_2240_Y_7360 0 5.1331e-18
C_MINT5_X_2240_Y_7680 MINT5_X_2240_Y_7680 0 8.2129e-18
C_MINT5_X_2240_Y_8000 MINT5_X_2240_Y_8000 0 8.2129e-18
C_MINT5_X_2240_Y_8320 MINT5_X_2240_Y_8320 0 5.1331e-18
C_MINT5_X_2240_Y_8400 MINT5_X_2240_Y_8400 0 4.1064e-18
C_MINT5_X_2240_Y_8640 MINT5_X_2240_Y_8640 0 7.1863e-18
C_MINT5_X_2240_Y_8960 MINT5_X_2240_Y_8960 0 8.2129e-18
C_MINT5_X_2240_Y_9280 MINT5_X_2240_Y_9280 0 7.1863e-18
C_MINT5_X_2240_Y_9520 MINT5_X_2240_Y_9520 0 4.1064e-18
C_MINT5_X_2240_Y_960 MINT5_X_2240_Y_960 0 8.2129e-18
C_MINT5_X_2240_Y_9600 MINT5_X_2240_Y_9600 0 5.1331e-18
C_MINT5_X_2240_Y_9920 MINT5_X_2240_Y_9920 0 5.1331e-18
C_MINT5_X_2560_Y_0 MINT5_X_2560_Y_0 0 4.1064e-18
C_MINT5_X_2560_Y_10000 MINT5_X_2560_Y_10000 0 1.0266e-18
C_MINT5_X_2560_Y_1120 MINT5_X_2560_Y_1120 0 4.1064e-18
C_MINT5_X_2560_Y_1280 MINT5_X_2560_Y_1280 0 6.1597e-18
C_MINT5_X_2560_Y_1600 MINT5_X_2560_Y_1600 0 8.2129e-18
C_MINT5_X_2560_Y_1920 MINT5_X_2560_Y_1920 0 8.2129e-18
C_MINT5_X_2560_Y_2240 MINT5_X_2560_Y_2240 0 8.2129e-18
C_MINT5_X_2560_Y_2560 MINT5_X_2560_Y_2560 0 8.2129e-18
C_MINT5_X_2560_Y_2880 MINT5_X_2560_Y_2880 0 8.2129e-18
C_MINT5_X_2560_Y_320 MINT5_X_2560_Y_320 0 8.2129e-18
C_MINT5_X_2560_Y_3200 MINT5_X_2560_Y_3200 0 6.1597e-18
C_MINT5_X_2560_Y_3360 MINT5_X_2560_Y_3360 0 4.1064e-18
C_MINT5_X_2560_Y_3520 MINT5_X_2560_Y_3520 0 6.1597e-18
C_MINT5_X_2560_Y_3840 MINT5_X_2560_Y_3840 0 8.2129e-18
C_MINT5_X_2560_Y_4160 MINT5_X_2560_Y_4160 0 8.2129e-18
C_MINT5_X_2560_Y_4480 MINT5_X_2560_Y_4480 0 8.2129e-18
C_MINT5_X_2560_Y_4800 MINT5_X_2560_Y_4800 0 8.2129e-18
C_MINT5_X_2560_Y_5120 MINT5_X_2560_Y_5120 0 8.2129e-18
C_MINT5_X_2560_Y_5440 MINT5_X_2560_Y_5440 0 6.1597e-18
C_MINT5_X_2560_Y_5600 MINT5_X_2560_Y_5600 0 4.1064e-18
C_MINT5_X_2560_Y_5760 MINT5_X_2560_Y_5760 0 6.1597e-18
C_MINT5_X_2560_Y_6080 MINT5_X_2560_Y_6080 0 8.2129e-18
C_MINT5_X_2560_Y_640 MINT5_X_2560_Y_640 0 8.2129e-18
C_MINT5_X_2560_Y_6400 MINT5_X_2560_Y_6400 0 8.2129e-18
C_MINT5_X_2560_Y_6720 MINT5_X_2560_Y_6720 0 8.2129e-18
C_MINT5_X_2560_Y_7040 MINT5_X_2560_Y_7040 0 8.2129e-18
C_MINT5_X_2560_Y_7360 MINT5_X_2560_Y_7360 0 8.2129e-18
C_MINT5_X_2560_Y_7680 MINT5_X_2560_Y_7680 0 6.1597e-18
C_MINT5_X_2560_Y_7840 MINT5_X_2560_Y_7840 0 4.1064e-18
C_MINT5_X_2560_Y_8000 MINT5_X_2560_Y_8000 0 6.1597e-18
C_MINT5_X_2560_Y_8320 MINT5_X_2560_Y_8320 0 8.2129e-18
C_MINT5_X_2560_Y_8640 MINT5_X_2560_Y_8640 0 8.2129e-18
C_MINT5_X_2560_Y_8960 MINT5_X_2560_Y_8960 0 8.2129e-18
C_MINT5_X_2560_Y_9280 MINT5_X_2560_Y_9280 0 8.2129e-18
C_MINT5_X_2560_Y_960 MINT5_X_2560_Y_960 0 6.1597e-18
C_MINT5_X_2560_Y_9600 MINT5_X_2560_Y_9600 0 8.2129e-18
C_MINT5_X_2560_Y_9920 MINT5_X_2560_Y_9920 0 5.1331e-18
C_MINT5_X_2880_Y_0 MINT5_X_2880_Y_0 0 4.1064e-18
C_MINT5_X_2880_Y_10000 MINT5_X_2880_Y_10000 0 1.0266e-18
C_MINT5_X_2880_Y_1280 MINT5_X_2880_Y_1280 0 8.2129e-18
C_MINT5_X_2880_Y_1600 MINT5_X_2880_Y_1600 0 5.1331e-18
C_MINT5_X_2880_Y_1680 MINT5_X_2880_Y_1680 0 4.1064e-18
C_MINT5_X_2880_Y_1920 MINT5_X_2880_Y_1920 0 7.1863e-18
C_MINT5_X_2880_Y_2240 MINT5_X_2880_Y_2240 0 8.2129e-18
C_MINT5_X_2880_Y_2560 MINT5_X_2880_Y_2560 0 7.1863e-18
C_MINT5_X_2880_Y_2800 MINT5_X_2880_Y_2800 0 4.1064e-18
C_MINT5_X_2880_Y_2880 MINT5_X_2880_Y_2880 0 5.1331e-18
C_MINT5_X_2880_Y_320 MINT5_X_2880_Y_320 0 7.1863e-18
C_MINT5_X_2880_Y_3200 MINT5_X_2880_Y_3200 0 8.2129e-18
C_MINT5_X_2880_Y_3520 MINT5_X_2880_Y_3520 0 8.2129e-18
C_MINT5_X_2880_Y_3840 MINT5_X_2880_Y_3840 0 5.1331e-18
C_MINT5_X_2880_Y_3920 MINT5_X_2880_Y_3920 0 4.1064e-18
C_MINT5_X_2880_Y_4160 MINT5_X_2880_Y_4160 0 7.1863e-18
C_MINT5_X_2880_Y_4480 MINT5_X_2880_Y_4480 0 8.2129e-18
C_MINT5_X_2880_Y_4800 MINT5_X_2880_Y_4800 0 7.1863e-18
C_MINT5_X_2880_Y_5040 MINT5_X_2880_Y_5040 0 4.1064e-18
C_MINT5_X_2880_Y_5120 MINT5_X_2880_Y_5120 0 5.1331e-18
C_MINT5_X_2880_Y_5440 MINT5_X_2880_Y_5440 0 8.2129e-18
C_MINT5_X_2880_Y_560 MINT5_X_2880_Y_560 0 4.1064e-18
C_MINT5_X_2880_Y_5760 MINT5_X_2880_Y_5760 0 8.2129e-18
C_MINT5_X_2880_Y_6080 MINT5_X_2880_Y_6080 0 5.1331e-18
C_MINT5_X_2880_Y_6160 MINT5_X_2880_Y_6160 0 4.1064e-18
C_MINT5_X_2880_Y_640 MINT5_X_2880_Y_640 0 5.1331e-18
C_MINT5_X_2880_Y_6400 MINT5_X_2880_Y_6400 0 7.1863e-18
C_MINT5_X_2880_Y_6720 MINT5_X_2880_Y_6720 0 8.2129e-18
C_MINT5_X_2880_Y_7040 MINT5_X_2880_Y_7040 0 7.1863e-18
C_MINT5_X_2880_Y_7280 MINT5_X_2880_Y_7280 0 4.1064e-18
C_MINT5_X_2880_Y_7360 MINT5_X_2880_Y_7360 0 5.1331e-18
C_MINT5_X_2880_Y_7680 MINT5_X_2880_Y_7680 0 8.2129e-18
C_MINT5_X_2880_Y_8000 MINT5_X_2880_Y_8000 0 8.2129e-18
C_MINT5_X_2880_Y_8320 MINT5_X_2880_Y_8320 0 5.1331e-18
C_MINT5_X_2880_Y_8400 MINT5_X_2880_Y_8400 0 4.1064e-18
C_MINT5_X_2880_Y_8640 MINT5_X_2880_Y_8640 0 7.1863e-18
C_MINT5_X_2880_Y_8960 MINT5_X_2880_Y_8960 0 8.2129e-18
C_MINT5_X_2880_Y_9280 MINT5_X_2880_Y_9280 0 7.1863e-18
C_MINT5_X_2880_Y_9520 MINT5_X_2880_Y_9520 0 4.1064e-18
C_MINT5_X_2880_Y_960 MINT5_X_2880_Y_960 0 8.2129e-18
C_MINT5_X_2880_Y_9600 MINT5_X_2880_Y_9600 0 5.1331e-18
C_MINT5_X_2880_Y_9920 MINT5_X_2880_Y_9920 0 5.1331e-18
C_MINT5_X_3200_Y_0 MINT5_X_3200_Y_0 0 4.1064e-18
C_MINT5_X_3200_Y_10000 MINT5_X_3200_Y_10000 0 1.0266e-18
C_MINT5_X_3200_Y_1120 MINT5_X_3200_Y_1120 0 4.1064e-18
C_MINT5_X_3200_Y_1280 MINT5_X_3200_Y_1280 0 6.1597e-18
C_MINT5_X_3200_Y_1600 MINT5_X_3200_Y_1600 0 8.2129e-18
C_MINT5_X_3200_Y_1920 MINT5_X_3200_Y_1920 0 8.2129e-18
C_MINT5_X_3200_Y_2240 MINT5_X_3200_Y_2240 0 8.2129e-18
C_MINT5_X_3200_Y_2560 MINT5_X_3200_Y_2560 0 8.2129e-18
C_MINT5_X_3200_Y_2880 MINT5_X_3200_Y_2880 0 8.2129e-18
C_MINT5_X_3200_Y_320 MINT5_X_3200_Y_320 0 8.2129e-18
C_MINT5_X_3200_Y_3200 MINT5_X_3200_Y_3200 0 6.1597e-18
C_MINT5_X_3200_Y_3360 MINT5_X_3200_Y_3360 0 4.1064e-18
C_MINT5_X_3200_Y_3520 MINT5_X_3200_Y_3520 0 6.1597e-18
C_MINT5_X_3200_Y_3840 MINT5_X_3200_Y_3840 0 8.2129e-18
C_MINT5_X_3200_Y_4160 MINT5_X_3200_Y_4160 0 8.2129e-18
C_MINT5_X_3200_Y_4480 MINT5_X_3200_Y_4480 0 8.2129e-18
C_MINT5_X_3200_Y_4800 MINT5_X_3200_Y_4800 0 8.2129e-18
C_MINT5_X_3200_Y_5120 MINT5_X_3200_Y_5120 0 8.2129e-18
C_MINT5_X_3200_Y_5440 MINT5_X_3200_Y_5440 0 6.1597e-18
C_MINT5_X_3200_Y_5600 MINT5_X_3200_Y_5600 0 4.1064e-18
C_MINT5_X_3200_Y_5760 MINT5_X_3200_Y_5760 0 6.1597e-18
C_MINT5_X_3200_Y_6080 MINT5_X_3200_Y_6080 0 8.2129e-18
C_MINT5_X_3200_Y_640 MINT5_X_3200_Y_640 0 8.2129e-18
C_MINT5_X_3200_Y_6400 MINT5_X_3200_Y_6400 0 8.2129e-18
C_MINT5_X_3200_Y_6720 MINT5_X_3200_Y_6720 0 8.2129e-18
C_MINT5_X_3200_Y_7040 MINT5_X_3200_Y_7040 0 8.2129e-18
C_MINT5_X_3200_Y_7360 MINT5_X_3200_Y_7360 0 8.2129e-18
C_MINT5_X_3200_Y_7680 MINT5_X_3200_Y_7680 0 6.1597e-18
C_MINT5_X_3200_Y_7840 MINT5_X_3200_Y_7840 0 4.1064e-18
C_MINT5_X_3200_Y_8000 MINT5_X_3200_Y_8000 0 6.1597e-18
C_MINT5_X_3200_Y_8320 MINT5_X_3200_Y_8320 0 8.2129e-18
C_MINT5_X_3200_Y_8640 MINT5_X_3200_Y_8640 0 8.2129e-18
C_MINT5_X_3200_Y_8960 MINT5_X_3200_Y_8960 0 8.2129e-18
C_MINT5_X_3200_Y_9280 MINT5_X_3200_Y_9280 0 8.2129e-18
C_MINT5_X_3200_Y_960 MINT5_X_3200_Y_960 0 6.1597e-18
C_MINT5_X_3200_Y_9600 MINT5_X_3200_Y_9600 0 8.2129e-18
C_MINT5_X_3200_Y_9920 MINT5_X_3200_Y_9920 0 5.1331e-18
C_MINT5_X_320_Y_0 MINT5_X_320_Y_0 0 4.1064e-18
C_MINT5_X_320_Y_10000 MINT5_X_320_Y_10000 0 1.0266e-18
C_MINT5_X_320_Y_1280 MINT5_X_320_Y_1280 0 8.2129e-18
C_MINT5_X_320_Y_1600 MINT5_X_320_Y_1600 0 5.1331e-18
C_MINT5_X_320_Y_1680 MINT5_X_320_Y_1680 0 4.1064e-18
C_MINT5_X_320_Y_1920 MINT5_X_320_Y_1920 0 7.1863e-18
C_MINT5_X_320_Y_2240 MINT5_X_320_Y_2240 0 8.2129e-18
C_MINT5_X_320_Y_2560 MINT5_X_320_Y_2560 0 7.1863e-18
C_MINT5_X_320_Y_2800 MINT5_X_320_Y_2800 0 4.1064e-18
C_MINT5_X_320_Y_2880 MINT5_X_320_Y_2880 0 5.1331e-18
C_MINT5_X_320_Y_320 MINT5_X_320_Y_320 0 7.1863e-18
C_MINT5_X_320_Y_3200 MINT5_X_320_Y_3200 0 8.2129e-18
C_MINT5_X_320_Y_3520 MINT5_X_320_Y_3520 0 8.2129e-18
C_MINT5_X_320_Y_3840 MINT5_X_320_Y_3840 0 5.1331e-18
C_MINT5_X_320_Y_3920 MINT5_X_320_Y_3920 0 4.1064e-18
C_MINT5_X_320_Y_4160 MINT5_X_320_Y_4160 0 7.1863e-18
C_MINT5_X_320_Y_4480 MINT5_X_320_Y_4480 0 8.2129e-18
C_MINT5_X_320_Y_4800 MINT5_X_320_Y_4800 0 7.1863e-18
C_MINT5_X_320_Y_5040 MINT5_X_320_Y_5040 0 4.1064e-18
C_MINT5_X_320_Y_5120 MINT5_X_320_Y_5120 0 5.1331e-18
C_MINT5_X_320_Y_5440 MINT5_X_320_Y_5440 0 8.2129e-18
C_MINT5_X_320_Y_560 MINT5_X_320_Y_560 0 4.1064e-18
C_MINT5_X_320_Y_5760 MINT5_X_320_Y_5760 0 8.2129e-18
C_MINT5_X_320_Y_6080 MINT5_X_320_Y_6080 0 5.1331e-18
C_MINT5_X_320_Y_6160 MINT5_X_320_Y_6160 0 4.1064e-18
C_MINT5_X_320_Y_640 MINT5_X_320_Y_640 0 5.1331e-18
C_MINT5_X_320_Y_6400 MINT5_X_320_Y_6400 0 7.1863e-18
C_MINT5_X_320_Y_6720 MINT5_X_320_Y_6720 0 8.2129e-18
C_MINT5_X_320_Y_7040 MINT5_X_320_Y_7040 0 7.1863e-18
C_MINT5_X_320_Y_7280 MINT5_X_320_Y_7280 0 4.1064e-18
C_MINT5_X_320_Y_7360 MINT5_X_320_Y_7360 0 5.1331e-18
C_MINT5_X_320_Y_7680 MINT5_X_320_Y_7680 0 8.2129e-18
C_MINT5_X_320_Y_8000 MINT5_X_320_Y_8000 0 8.2129e-18
C_MINT5_X_320_Y_8320 MINT5_X_320_Y_8320 0 5.1331e-18
C_MINT5_X_320_Y_8400 MINT5_X_320_Y_8400 0 4.1064e-18
C_MINT5_X_320_Y_8640 MINT5_X_320_Y_8640 0 7.1863e-18
C_MINT5_X_320_Y_8960 MINT5_X_320_Y_8960 0 8.2129e-18
C_MINT5_X_320_Y_9280 MINT5_X_320_Y_9280 0 7.1863e-18
C_MINT5_X_320_Y_9520 MINT5_X_320_Y_9520 0 4.1064e-18
C_MINT5_X_320_Y_960 MINT5_X_320_Y_960 0 8.2129e-18
C_MINT5_X_320_Y_9600 MINT5_X_320_Y_9600 0 5.1331e-18
C_MINT5_X_320_Y_9920 MINT5_X_320_Y_9920 0 5.1331e-18
C_MINT5_X_3520_Y_0 MINT5_X_3520_Y_0 0 4.1064e-18
C_MINT5_X_3520_Y_10000 MINT5_X_3520_Y_10000 0 1.0266e-18
C_MINT5_X_3520_Y_1280 MINT5_X_3520_Y_1280 0 8.2129e-18
C_MINT5_X_3520_Y_1600 MINT5_X_3520_Y_1600 0 5.1331e-18
C_MINT5_X_3520_Y_1680 MINT5_X_3520_Y_1680 0 4.1064e-18
C_MINT5_X_3520_Y_1920 MINT5_X_3520_Y_1920 0 7.1863e-18
C_MINT5_X_3520_Y_2240 MINT5_X_3520_Y_2240 0 8.2129e-18
C_MINT5_X_3520_Y_2560 MINT5_X_3520_Y_2560 0 7.1863e-18
C_MINT5_X_3520_Y_2800 MINT5_X_3520_Y_2800 0 4.1064e-18
C_MINT5_X_3520_Y_2880 MINT5_X_3520_Y_2880 0 5.1331e-18
C_MINT5_X_3520_Y_320 MINT5_X_3520_Y_320 0 7.1863e-18
C_MINT5_X_3520_Y_3200 MINT5_X_3520_Y_3200 0 8.2129e-18
C_MINT5_X_3520_Y_3520 MINT5_X_3520_Y_3520 0 8.2129e-18
C_MINT5_X_3520_Y_3840 MINT5_X_3520_Y_3840 0 5.1331e-18
C_MINT5_X_3520_Y_3920 MINT5_X_3520_Y_3920 0 4.1064e-18
C_MINT5_X_3520_Y_4160 MINT5_X_3520_Y_4160 0 7.1863e-18
C_MINT5_X_3520_Y_4480 MINT5_X_3520_Y_4480 0 8.2129e-18
C_MINT5_X_3520_Y_4800 MINT5_X_3520_Y_4800 0 7.1863e-18
C_MINT5_X_3520_Y_5040 MINT5_X_3520_Y_5040 0 4.1064e-18
C_MINT5_X_3520_Y_5120 MINT5_X_3520_Y_5120 0 5.1331e-18
C_MINT5_X_3520_Y_5440 MINT5_X_3520_Y_5440 0 8.2129e-18
C_MINT5_X_3520_Y_560 MINT5_X_3520_Y_560 0 4.1064e-18
C_MINT5_X_3520_Y_5760 MINT5_X_3520_Y_5760 0 8.2129e-18
C_MINT5_X_3520_Y_6080 MINT5_X_3520_Y_6080 0 5.1331e-18
C_MINT5_X_3520_Y_6160 MINT5_X_3520_Y_6160 0 4.1064e-18
C_MINT5_X_3520_Y_640 MINT5_X_3520_Y_640 0 5.1331e-18
C_MINT5_X_3520_Y_6400 MINT5_X_3520_Y_6400 0 7.1863e-18
C_MINT5_X_3520_Y_6720 MINT5_X_3520_Y_6720 0 8.2129e-18
C_MINT5_X_3520_Y_7040 MINT5_X_3520_Y_7040 0 7.1863e-18
C_MINT5_X_3520_Y_7280 MINT5_X_3520_Y_7280 0 4.1064e-18
C_MINT5_X_3520_Y_7360 MINT5_X_3520_Y_7360 0 5.1331e-18
C_MINT5_X_3520_Y_7680 MINT5_X_3520_Y_7680 0 8.2129e-18
C_MINT5_X_3520_Y_8000 MINT5_X_3520_Y_8000 0 8.2129e-18
C_MINT5_X_3520_Y_8320 MINT5_X_3520_Y_8320 0 5.1331e-18
C_MINT5_X_3520_Y_8400 MINT5_X_3520_Y_8400 0 4.1064e-18
C_MINT5_X_3520_Y_8640 MINT5_X_3520_Y_8640 0 7.1863e-18
C_MINT5_X_3520_Y_8960 MINT5_X_3520_Y_8960 0 8.2129e-18
C_MINT5_X_3520_Y_9280 MINT5_X_3520_Y_9280 0 7.1863e-18
C_MINT5_X_3520_Y_9520 MINT5_X_3520_Y_9520 0 4.1064e-18
C_MINT5_X_3520_Y_960 MINT5_X_3520_Y_960 0 8.2129e-18
C_MINT5_X_3520_Y_9600 MINT5_X_3520_Y_9600 0 5.1331e-18
C_MINT5_X_3520_Y_9920 MINT5_X_3520_Y_9920 0 5.1331e-18
C_MINT5_X_3840_Y_0 MINT5_X_3840_Y_0 0 4.1064e-18
C_MINT5_X_3840_Y_10000 MINT5_X_3840_Y_10000 0 1.0266e-18
C_MINT5_X_3840_Y_1120 MINT5_X_3840_Y_1120 0 4.1064e-18
C_MINT5_X_3840_Y_1280 MINT5_X_3840_Y_1280 0 6.1597e-18
C_MINT5_X_3840_Y_1600 MINT5_X_3840_Y_1600 0 8.2129e-18
C_MINT5_X_3840_Y_1920 MINT5_X_3840_Y_1920 0 8.2129e-18
C_MINT5_X_3840_Y_2240 MINT5_X_3840_Y_2240 0 8.2129e-18
C_MINT5_X_3840_Y_2560 MINT5_X_3840_Y_2560 0 8.2129e-18
C_MINT5_X_3840_Y_2880 MINT5_X_3840_Y_2880 0 8.2129e-18
C_MINT5_X_3840_Y_320 MINT5_X_3840_Y_320 0 8.2129e-18
C_MINT5_X_3840_Y_3200 MINT5_X_3840_Y_3200 0 6.1597e-18
C_MINT5_X_3840_Y_3360 MINT5_X_3840_Y_3360 0 4.1064e-18
C_MINT5_X_3840_Y_3520 MINT5_X_3840_Y_3520 0 6.1597e-18
C_MINT5_X_3840_Y_3840 MINT5_X_3840_Y_3840 0 8.2129e-18
C_MINT5_X_3840_Y_4160 MINT5_X_3840_Y_4160 0 8.2129e-18
C_MINT5_X_3840_Y_4480 MINT5_X_3840_Y_4480 0 8.2129e-18
C_MINT5_X_3840_Y_4800 MINT5_X_3840_Y_4800 0 8.2129e-18
C_MINT5_X_3840_Y_5120 MINT5_X_3840_Y_5120 0 8.2129e-18
C_MINT5_X_3840_Y_5440 MINT5_X_3840_Y_5440 0 6.1597e-18
C_MINT5_X_3840_Y_5600 MINT5_X_3840_Y_5600 0 4.1064e-18
C_MINT5_X_3840_Y_5760 MINT5_X_3840_Y_5760 0 6.1597e-18
C_MINT5_X_3840_Y_6080 MINT5_X_3840_Y_6080 0 8.2129e-18
C_MINT5_X_3840_Y_640 MINT5_X_3840_Y_640 0 8.2129e-18
C_MINT5_X_3840_Y_6400 MINT5_X_3840_Y_6400 0 8.2129e-18
C_MINT5_X_3840_Y_6720 MINT5_X_3840_Y_6720 0 8.2129e-18
C_MINT5_X_3840_Y_7040 MINT5_X_3840_Y_7040 0 8.2129e-18
C_MINT5_X_3840_Y_7360 MINT5_X_3840_Y_7360 0 8.2129e-18
C_MINT5_X_3840_Y_7680 MINT5_X_3840_Y_7680 0 6.1597e-18
C_MINT5_X_3840_Y_7840 MINT5_X_3840_Y_7840 0 4.1064e-18
C_MINT5_X_3840_Y_8000 MINT5_X_3840_Y_8000 0 6.1597e-18
C_MINT5_X_3840_Y_8320 MINT5_X_3840_Y_8320 0 8.2129e-18
C_MINT5_X_3840_Y_8640 MINT5_X_3840_Y_8640 0 8.2129e-18
C_MINT5_X_3840_Y_8960 MINT5_X_3840_Y_8960 0 8.2129e-18
C_MINT5_X_3840_Y_9280 MINT5_X_3840_Y_9280 0 8.2129e-18
C_MINT5_X_3840_Y_960 MINT5_X_3840_Y_960 0 6.1597e-18
C_MINT5_X_3840_Y_9600 MINT5_X_3840_Y_9600 0 8.2129e-18
C_MINT5_X_3840_Y_9920 MINT5_X_3840_Y_9920 0 5.1331e-18
C_MINT5_X_4160_Y_0 MINT5_X_4160_Y_0 0 4.1064e-18
C_MINT5_X_4160_Y_10000 MINT5_X_4160_Y_10000 0 1.0266e-18
C_MINT5_X_4160_Y_1280 MINT5_X_4160_Y_1280 0 8.2129e-18
C_MINT5_X_4160_Y_1600 MINT5_X_4160_Y_1600 0 5.1331e-18
C_MINT5_X_4160_Y_1680 MINT5_X_4160_Y_1680 0 4.1064e-18
C_MINT5_X_4160_Y_1920 MINT5_X_4160_Y_1920 0 7.1863e-18
C_MINT5_X_4160_Y_2240 MINT5_X_4160_Y_2240 0 8.2129e-18
C_MINT5_X_4160_Y_2560 MINT5_X_4160_Y_2560 0 7.1863e-18
C_MINT5_X_4160_Y_2800 MINT5_X_4160_Y_2800 0 4.1064e-18
C_MINT5_X_4160_Y_2880 MINT5_X_4160_Y_2880 0 5.1331e-18
C_MINT5_X_4160_Y_320 MINT5_X_4160_Y_320 0 7.1863e-18
C_MINT5_X_4160_Y_3200 MINT5_X_4160_Y_3200 0 8.2129e-18
C_MINT5_X_4160_Y_3520 MINT5_X_4160_Y_3520 0 8.2129e-18
C_MINT5_X_4160_Y_3840 MINT5_X_4160_Y_3840 0 5.1331e-18
C_MINT5_X_4160_Y_3920 MINT5_X_4160_Y_3920 0 4.1064e-18
C_MINT5_X_4160_Y_4160 MINT5_X_4160_Y_4160 0 7.1863e-18
C_MINT5_X_4160_Y_4480 MINT5_X_4160_Y_4480 0 8.2129e-18
C_MINT5_X_4160_Y_4800 MINT5_X_4160_Y_4800 0 7.1863e-18
C_MINT5_X_4160_Y_5040 MINT5_X_4160_Y_5040 0 4.1064e-18
C_MINT5_X_4160_Y_5120 MINT5_X_4160_Y_5120 0 5.1331e-18
C_MINT5_X_4160_Y_5440 MINT5_X_4160_Y_5440 0 8.2129e-18
C_MINT5_X_4160_Y_560 MINT5_X_4160_Y_560 0 4.1064e-18
C_MINT5_X_4160_Y_5760 MINT5_X_4160_Y_5760 0 8.2129e-18
C_MINT5_X_4160_Y_6080 MINT5_X_4160_Y_6080 0 5.1331e-18
C_MINT5_X_4160_Y_6160 MINT5_X_4160_Y_6160 0 4.1064e-18
C_MINT5_X_4160_Y_640 MINT5_X_4160_Y_640 0 5.1331e-18
C_MINT5_X_4160_Y_6400 MINT5_X_4160_Y_6400 0 7.1863e-18
C_MINT5_X_4160_Y_6720 MINT5_X_4160_Y_6720 0 8.2129e-18
C_MINT5_X_4160_Y_7040 MINT5_X_4160_Y_7040 0 7.1863e-18
C_MINT5_X_4160_Y_7280 MINT5_X_4160_Y_7280 0 4.1064e-18
C_MINT5_X_4160_Y_7360 MINT5_X_4160_Y_7360 0 5.1331e-18
C_MINT5_X_4160_Y_7680 MINT5_X_4160_Y_7680 0 8.2129e-18
C_MINT5_X_4160_Y_8000 MINT5_X_4160_Y_8000 0 8.2129e-18
C_MINT5_X_4160_Y_8320 MINT5_X_4160_Y_8320 0 5.1331e-18
C_MINT5_X_4160_Y_8400 MINT5_X_4160_Y_8400 0 4.1064e-18
C_MINT5_X_4160_Y_8640 MINT5_X_4160_Y_8640 0 7.1863e-18
C_MINT5_X_4160_Y_8960 MINT5_X_4160_Y_8960 0 8.2129e-18
C_MINT5_X_4160_Y_9280 MINT5_X_4160_Y_9280 0 7.1863e-18
C_MINT5_X_4160_Y_9520 MINT5_X_4160_Y_9520 0 4.1064e-18
C_MINT5_X_4160_Y_960 MINT5_X_4160_Y_960 0 8.2129e-18
C_MINT5_X_4160_Y_9600 MINT5_X_4160_Y_9600 0 5.1331e-18
C_MINT5_X_4160_Y_9920 MINT5_X_4160_Y_9920 0 5.1331e-18
C_MINT5_X_4480_Y_0 MINT5_X_4480_Y_0 0 4.1064e-18
C_MINT5_X_4480_Y_10000 MINT5_X_4480_Y_10000 0 1.0266e-18
C_MINT5_X_4480_Y_1120 MINT5_X_4480_Y_1120 0 4.1064e-18
C_MINT5_X_4480_Y_1280 MINT5_X_4480_Y_1280 0 6.1597e-18
C_MINT5_X_4480_Y_1600 MINT5_X_4480_Y_1600 0 8.2129e-18
C_MINT5_X_4480_Y_1920 MINT5_X_4480_Y_1920 0 8.2129e-18
C_MINT5_X_4480_Y_2240 MINT5_X_4480_Y_2240 0 8.2129e-18
C_MINT5_X_4480_Y_2560 MINT5_X_4480_Y_2560 0 8.2129e-18
C_MINT5_X_4480_Y_2880 MINT5_X_4480_Y_2880 0 8.2129e-18
C_MINT5_X_4480_Y_320 MINT5_X_4480_Y_320 0 8.2129e-18
C_MINT5_X_4480_Y_3200 MINT5_X_4480_Y_3200 0 6.1597e-18
C_MINT5_X_4480_Y_3360 MINT5_X_4480_Y_3360 0 4.1064e-18
C_MINT5_X_4480_Y_3520 MINT5_X_4480_Y_3520 0 6.1597e-18
C_MINT5_X_4480_Y_3840 MINT5_X_4480_Y_3840 0 8.2129e-18
C_MINT5_X_4480_Y_4160 MINT5_X_4480_Y_4160 0 8.2129e-18
C_MINT5_X_4480_Y_4480 MINT5_X_4480_Y_4480 0 8.2129e-18
C_MINT5_X_4480_Y_4800 MINT5_X_4480_Y_4800 0 8.2129e-18
C_MINT5_X_4480_Y_5120 MINT5_X_4480_Y_5120 0 8.2129e-18
C_MINT5_X_4480_Y_5440 MINT5_X_4480_Y_5440 0 6.1597e-18
C_MINT5_X_4480_Y_5600 MINT5_X_4480_Y_5600 0 4.1064e-18
C_MINT5_X_4480_Y_5760 MINT5_X_4480_Y_5760 0 6.1597e-18
C_MINT5_X_4480_Y_6080 MINT5_X_4480_Y_6080 0 8.2129e-18
C_MINT5_X_4480_Y_640 MINT5_X_4480_Y_640 0 8.2129e-18
C_MINT5_X_4480_Y_6400 MINT5_X_4480_Y_6400 0 8.2129e-18
C_MINT5_X_4480_Y_6720 MINT5_X_4480_Y_6720 0 8.2129e-18
C_MINT5_X_4480_Y_7040 MINT5_X_4480_Y_7040 0 8.2129e-18
C_MINT5_X_4480_Y_7360 MINT5_X_4480_Y_7360 0 8.2129e-18
C_MINT5_X_4480_Y_7680 MINT5_X_4480_Y_7680 0 6.1597e-18
C_MINT5_X_4480_Y_7840 MINT5_X_4480_Y_7840 0 4.1064e-18
C_MINT5_X_4480_Y_8000 MINT5_X_4480_Y_8000 0 6.1597e-18
C_MINT5_X_4480_Y_8320 MINT5_X_4480_Y_8320 0 8.2129e-18
C_MINT5_X_4480_Y_8640 MINT5_X_4480_Y_8640 0 8.2129e-18
C_MINT5_X_4480_Y_8960 MINT5_X_4480_Y_8960 0 8.2129e-18
C_MINT5_X_4480_Y_9280 MINT5_X_4480_Y_9280 0 8.2129e-18
C_MINT5_X_4480_Y_960 MINT5_X_4480_Y_960 0 6.1597e-18
C_MINT5_X_4480_Y_9600 MINT5_X_4480_Y_9600 0 8.2129e-18
C_MINT5_X_4480_Y_9920 MINT5_X_4480_Y_9920 0 5.1331e-18
C_MINT5_X_4800_Y_0 MINT5_X_4800_Y_0 0 4.1064e-18
C_MINT5_X_4800_Y_10000 MINT5_X_4800_Y_10000 0 1.0266e-18
C_MINT5_X_4800_Y_1280 MINT5_X_4800_Y_1280 0 8.2129e-18
C_MINT5_X_4800_Y_1600 MINT5_X_4800_Y_1600 0 5.1331e-18
C_MINT5_X_4800_Y_1680 MINT5_X_4800_Y_1680 0 4.1064e-18
C_MINT5_X_4800_Y_1920 MINT5_X_4800_Y_1920 0 7.1863e-18
C_MINT5_X_4800_Y_2240 MINT5_X_4800_Y_2240 0 8.2129e-18
C_MINT5_X_4800_Y_2560 MINT5_X_4800_Y_2560 0 7.1863e-18
C_MINT5_X_4800_Y_2800 MINT5_X_4800_Y_2800 0 4.1064e-18
C_MINT5_X_4800_Y_2880 MINT5_X_4800_Y_2880 0 5.1331e-18
C_MINT5_X_4800_Y_320 MINT5_X_4800_Y_320 0 7.1863e-18
C_MINT5_X_4800_Y_3200 MINT5_X_4800_Y_3200 0 8.2129e-18
C_MINT5_X_4800_Y_3520 MINT5_X_4800_Y_3520 0 8.2129e-18
C_MINT5_X_4800_Y_3840 MINT5_X_4800_Y_3840 0 5.1331e-18
C_MINT5_X_4800_Y_3920 MINT5_X_4800_Y_3920 0 4.1064e-18
C_MINT5_X_4800_Y_4160 MINT5_X_4800_Y_4160 0 7.1863e-18
C_MINT5_X_4800_Y_4480 MINT5_X_4800_Y_4480 0 8.2129e-18
C_MINT5_X_4800_Y_4800 MINT5_X_4800_Y_4800 0 7.1863e-18
C_MINT5_X_4800_Y_5040 MINT5_X_4800_Y_5040 0 4.1064e-18
C_MINT5_X_4800_Y_5120 MINT5_X_4800_Y_5120 0 5.1331e-18
C_MINT5_X_4800_Y_5440 MINT5_X_4800_Y_5440 0 8.2129e-18
C_MINT5_X_4800_Y_560 MINT5_X_4800_Y_560 0 4.1064e-18
C_MINT5_X_4800_Y_5760 MINT5_X_4800_Y_5760 0 8.2129e-18
C_MINT5_X_4800_Y_6080 MINT5_X_4800_Y_6080 0 5.1331e-18
C_MINT5_X_4800_Y_6160 MINT5_X_4800_Y_6160 0 4.1064e-18
C_MINT5_X_4800_Y_640 MINT5_X_4800_Y_640 0 5.1331e-18
C_MINT5_X_4800_Y_6400 MINT5_X_4800_Y_6400 0 7.1863e-18
C_MINT5_X_4800_Y_6720 MINT5_X_4800_Y_6720 0 8.2129e-18
C_MINT5_X_4800_Y_7040 MINT5_X_4800_Y_7040 0 7.1863e-18
C_MINT5_X_4800_Y_7280 MINT5_X_4800_Y_7280 0 4.1064e-18
C_MINT5_X_4800_Y_7360 MINT5_X_4800_Y_7360 0 5.1331e-18
C_MINT5_X_4800_Y_7680 MINT5_X_4800_Y_7680 0 8.2129e-18
C_MINT5_X_4800_Y_8000 MINT5_X_4800_Y_8000 0 8.2129e-18
C_MINT5_X_4800_Y_8320 MINT5_X_4800_Y_8320 0 5.1331e-18
C_MINT5_X_4800_Y_8400 MINT5_X_4800_Y_8400 0 4.1064e-18
C_MINT5_X_4800_Y_8640 MINT5_X_4800_Y_8640 0 7.1863e-18
C_MINT5_X_4800_Y_8960 MINT5_X_4800_Y_8960 0 8.2129e-18
C_MINT5_X_4800_Y_9280 MINT5_X_4800_Y_9280 0 7.1863e-18
C_MINT5_X_4800_Y_9520 MINT5_X_4800_Y_9520 0 4.1064e-18
C_MINT5_X_4800_Y_960 MINT5_X_4800_Y_960 0 8.2129e-18
C_MINT5_X_4800_Y_9600 MINT5_X_4800_Y_9600 0 5.1331e-18
C_MINT5_X_4800_Y_9920 MINT5_X_4800_Y_9920 0 5.1331e-18
C_MINT5_X_5120_Y_0 MINT5_X_5120_Y_0 0 4.1064e-18
C_MINT5_X_5120_Y_10000 MINT5_X_5120_Y_10000 0 1.0266e-18
C_MINT5_X_5120_Y_1120 MINT5_X_5120_Y_1120 0 4.1064e-18
C_MINT5_X_5120_Y_1280 MINT5_X_5120_Y_1280 0 6.1597e-18
C_MINT5_X_5120_Y_1600 MINT5_X_5120_Y_1600 0 8.2129e-18
C_MINT5_X_5120_Y_1920 MINT5_X_5120_Y_1920 0 8.2129e-18
C_MINT5_X_5120_Y_2240 MINT5_X_5120_Y_2240 0 8.2129e-18
C_MINT5_X_5120_Y_2560 MINT5_X_5120_Y_2560 0 8.2129e-18
C_MINT5_X_5120_Y_2880 MINT5_X_5120_Y_2880 0 8.2129e-18
C_MINT5_X_5120_Y_320 MINT5_X_5120_Y_320 0 8.2129e-18
C_MINT5_X_5120_Y_3200 MINT5_X_5120_Y_3200 0 6.1597e-18
C_MINT5_X_5120_Y_3360 MINT5_X_5120_Y_3360 0 4.1064e-18
C_MINT5_X_5120_Y_3520 MINT5_X_5120_Y_3520 0 6.1597e-18
C_MINT5_X_5120_Y_3840 MINT5_X_5120_Y_3840 0 8.2129e-18
C_MINT5_X_5120_Y_4160 MINT5_X_5120_Y_4160 0 8.2129e-18
C_MINT5_X_5120_Y_4480 MINT5_X_5120_Y_4480 0 8.2129e-18
C_MINT5_X_5120_Y_4800 MINT5_X_5120_Y_4800 0 8.2129e-18
C_MINT5_X_5120_Y_5120 MINT5_X_5120_Y_5120 0 8.2129e-18
C_MINT5_X_5120_Y_5440 MINT5_X_5120_Y_5440 0 6.1597e-18
C_MINT5_X_5120_Y_5600 MINT5_X_5120_Y_5600 0 4.1064e-18
C_MINT5_X_5120_Y_5760 MINT5_X_5120_Y_5760 0 6.1597e-18
C_MINT5_X_5120_Y_6080 MINT5_X_5120_Y_6080 0 8.2129e-18
C_MINT5_X_5120_Y_640 MINT5_X_5120_Y_640 0 8.2129e-18
C_MINT5_X_5120_Y_6400 MINT5_X_5120_Y_6400 0 8.2129e-18
C_MINT5_X_5120_Y_6720 MINT5_X_5120_Y_6720 0 8.2129e-18
C_MINT5_X_5120_Y_7040 MINT5_X_5120_Y_7040 0 8.2129e-18
C_MINT5_X_5120_Y_7360 MINT5_X_5120_Y_7360 0 8.2129e-18
C_MINT5_X_5120_Y_7680 MINT5_X_5120_Y_7680 0 6.1597e-18
C_MINT5_X_5120_Y_7840 MINT5_X_5120_Y_7840 0 4.1064e-18
C_MINT5_X_5120_Y_8000 MINT5_X_5120_Y_8000 0 6.1597e-18
C_MINT5_X_5120_Y_8320 MINT5_X_5120_Y_8320 0 8.2129e-18
C_MINT5_X_5120_Y_8640 MINT5_X_5120_Y_8640 0 8.2129e-18
C_MINT5_X_5120_Y_8960 MINT5_X_5120_Y_8960 0 8.2129e-18
C_MINT5_X_5120_Y_9280 MINT5_X_5120_Y_9280 0 8.2129e-18
C_MINT5_X_5120_Y_960 MINT5_X_5120_Y_960 0 6.1597e-18
C_MINT5_X_5120_Y_9600 MINT5_X_5120_Y_9600 0 8.2129e-18
C_MINT5_X_5120_Y_9920 MINT5_X_5120_Y_9920 0 5.1331e-18
C_MINT5_X_5440_Y_0 MINT5_X_5440_Y_0 0 4.1064e-18
C_MINT5_X_5440_Y_10000 MINT5_X_5440_Y_10000 0 1.0266e-18
C_MINT5_X_5440_Y_1280 MINT5_X_5440_Y_1280 0 8.2129e-18
C_MINT5_X_5440_Y_1600 MINT5_X_5440_Y_1600 0 5.1331e-18
C_MINT5_X_5440_Y_1680 MINT5_X_5440_Y_1680 0 4.1064e-18
C_MINT5_X_5440_Y_1920 MINT5_X_5440_Y_1920 0 7.1863e-18
C_MINT5_X_5440_Y_2240 MINT5_X_5440_Y_2240 0 8.2129e-18
C_MINT5_X_5440_Y_2560 MINT5_X_5440_Y_2560 0 7.1863e-18
C_MINT5_X_5440_Y_2800 MINT5_X_5440_Y_2800 0 4.1064e-18
C_MINT5_X_5440_Y_2880 MINT5_X_5440_Y_2880 0 5.1331e-18
C_MINT5_X_5440_Y_320 MINT5_X_5440_Y_320 0 7.1863e-18
C_MINT5_X_5440_Y_3200 MINT5_X_5440_Y_3200 0 8.2129e-18
C_MINT5_X_5440_Y_3520 MINT5_X_5440_Y_3520 0 8.2129e-18
C_MINT5_X_5440_Y_3840 MINT5_X_5440_Y_3840 0 5.1331e-18
C_MINT5_X_5440_Y_3920 MINT5_X_5440_Y_3920 0 4.1064e-18
C_MINT5_X_5440_Y_4160 MINT5_X_5440_Y_4160 0 7.1863e-18
C_MINT5_X_5440_Y_4480 MINT5_X_5440_Y_4480 0 8.2129e-18
C_MINT5_X_5440_Y_4800 MINT5_X_5440_Y_4800 0 7.1863e-18
C_MINT5_X_5440_Y_5040 MINT5_X_5440_Y_5040 0 4.1064e-18
C_MINT5_X_5440_Y_5120 MINT5_X_5440_Y_5120 0 5.1331e-18
C_MINT5_X_5440_Y_5440 MINT5_X_5440_Y_5440 0 8.2129e-18
C_MINT5_X_5440_Y_560 MINT5_X_5440_Y_560 0 4.1064e-18
C_MINT5_X_5440_Y_5760 MINT5_X_5440_Y_5760 0 8.2129e-18
C_MINT5_X_5440_Y_6080 MINT5_X_5440_Y_6080 0 5.1331e-18
C_MINT5_X_5440_Y_6160 MINT5_X_5440_Y_6160 0 4.1064e-18
C_MINT5_X_5440_Y_640 MINT5_X_5440_Y_640 0 5.1331e-18
C_MINT5_X_5440_Y_6400 MINT5_X_5440_Y_6400 0 7.1863e-18
C_MINT5_X_5440_Y_6720 MINT5_X_5440_Y_6720 0 8.2129e-18
C_MINT5_X_5440_Y_7040 MINT5_X_5440_Y_7040 0 7.1863e-18
C_MINT5_X_5440_Y_7280 MINT5_X_5440_Y_7280 0 4.1064e-18
C_MINT5_X_5440_Y_7360 MINT5_X_5440_Y_7360 0 5.1331e-18
C_MINT5_X_5440_Y_7680 MINT5_X_5440_Y_7680 0 8.2129e-18
C_MINT5_X_5440_Y_8000 MINT5_X_5440_Y_8000 0 8.2129e-18
C_MINT5_X_5440_Y_8320 MINT5_X_5440_Y_8320 0 5.1331e-18
C_MINT5_X_5440_Y_8400 MINT5_X_5440_Y_8400 0 4.1064e-18
C_MINT5_X_5440_Y_8640 MINT5_X_5440_Y_8640 0 7.1863e-18
C_MINT5_X_5440_Y_8960 MINT5_X_5440_Y_8960 0 8.2129e-18
C_MINT5_X_5440_Y_9280 MINT5_X_5440_Y_9280 0 7.1863e-18
C_MINT5_X_5440_Y_9520 MINT5_X_5440_Y_9520 0 4.1064e-18
C_MINT5_X_5440_Y_960 MINT5_X_5440_Y_960 0 8.2129e-18
C_MINT5_X_5440_Y_9600 MINT5_X_5440_Y_9600 0 5.1331e-18
C_MINT5_X_5440_Y_9920 MINT5_X_5440_Y_9920 0 5.1331e-18
C_MINT5_X_5760_Y_0 MINT5_X_5760_Y_0 0 4.1064e-18
C_MINT5_X_5760_Y_10000 MINT5_X_5760_Y_10000 0 1.0266e-18
C_MINT5_X_5760_Y_1120 MINT5_X_5760_Y_1120 0 4.1064e-18
C_MINT5_X_5760_Y_1280 MINT5_X_5760_Y_1280 0 6.1597e-18
C_MINT5_X_5760_Y_1600 MINT5_X_5760_Y_1600 0 8.2129e-18
C_MINT5_X_5760_Y_1920 MINT5_X_5760_Y_1920 0 8.2129e-18
C_MINT5_X_5760_Y_2240 MINT5_X_5760_Y_2240 0 8.2129e-18
C_MINT5_X_5760_Y_2560 MINT5_X_5760_Y_2560 0 8.2129e-18
C_MINT5_X_5760_Y_2880 MINT5_X_5760_Y_2880 0 8.2129e-18
C_MINT5_X_5760_Y_320 MINT5_X_5760_Y_320 0 8.2129e-18
C_MINT5_X_5760_Y_3200 MINT5_X_5760_Y_3200 0 6.1597e-18
C_MINT5_X_5760_Y_3360 MINT5_X_5760_Y_3360 0 4.1064e-18
C_MINT5_X_5760_Y_3520 MINT5_X_5760_Y_3520 0 6.1597e-18
C_MINT5_X_5760_Y_3840 MINT5_X_5760_Y_3840 0 8.2129e-18
C_MINT5_X_5760_Y_4160 MINT5_X_5760_Y_4160 0 8.2129e-18
C_MINT5_X_5760_Y_4480 MINT5_X_5760_Y_4480 0 8.2129e-18
C_MINT5_X_5760_Y_4800 MINT5_X_5760_Y_4800 0 8.2129e-18
C_MINT5_X_5760_Y_5120 MINT5_X_5760_Y_5120 0 8.2129e-18
C_MINT5_X_5760_Y_5440 MINT5_X_5760_Y_5440 0 6.1597e-18
C_MINT5_X_5760_Y_5600 MINT5_X_5760_Y_5600 0 4.1064e-18
C_MINT5_X_5760_Y_5760 MINT5_X_5760_Y_5760 0 6.1597e-18
C_MINT5_X_5760_Y_6080 MINT5_X_5760_Y_6080 0 8.2129e-18
C_MINT5_X_5760_Y_640 MINT5_X_5760_Y_640 0 8.2129e-18
C_MINT5_X_5760_Y_6400 MINT5_X_5760_Y_6400 0 8.2129e-18
C_MINT5_X_5760_Y_6720 MINT5_X_5760_Y_6720 0 8.2129e-18
C_MINT5_X_5760_Y_7040 MINT5_X_5760_Y_7040 0 8.2129e-18
C_MINT5_X_5760_Y_7360 MINT5_X_5760_Y_7360 0 8.2129e-18
C_MINT5_X_5760_Y_7680 MINT5_X_5760_Y_7680 0 6.1597e-18
C_MINT5_X_5760_Y_7840 MINT5_X_5760_Y_7840 0 4.1064e-18
C_MINT5_X_5760_Y_8000 MINT5_X_5760_Y_8000 0 6.1597e-18
C_MINT5_X_5760_Y_8320 MINT5_X_5760_Y_8320 0 8.2129e-18
C_MINT5_X_5760_Y_8640 MINT5_X_5760_Y_8640 0 8.2129e-18
C_MINT5_X_5760_Y_8960 MINT5_X_5760_Y_8960 0 8.2129e-18
C_MINT5_X_5760_Y_9280 MINT5_X_5760_Y_9280 0 8.2129e-18
C_MINT5_X_5760_Y_960 MINT5_X_5760_Y_960 0 6.1597e-18
C_MINT5_X_5760_Y_9600 MINT5_X_5760_Y_9600 0 8.2129e-18
C_MINT5_X_5760_Y_9920 MINT5_X_5760_Y_9920 0 5.1331e-18
C_MINT5_X_6080_Y_0 MINT5_X_6080_Y_0 0 4.1064e-18
C_MINT5_X_6080_Y_10000 MINT5_X_6080_Y_10000 0 1.0266e-18
C_MINT5_X_6080_Y_1280 MINT5_X_6080_Y_1280 0 8.2129e-18
C_MINT5_X_6080_Y_1600 MINT5_X_6080_Y_1600 0 5.1331e-18
C_MINT5_X_6080_Y_1680 MINT5_X_6080_Y_1680 0 4.1064e-18
C_MINT5_X_6080_Y_1920 MINT5_X_6080_Y_1920 0 7.1863e-18
C_MINT5_X_6080_Y_2240 MINT5_X_6080_Y_2240 0 8.2129e-18
C_MINT5_X_6080_Y_2560 MINT5_X_6080_Y_2560 0 7.1863e-18
C_MINT5_X_6080_Y_2800 MINT5_X_6080_Y_2800 0 4.1064e-18
C_MINT5_X_6080_Y_2880 MINT5_X_6080_Y_2880 0 5.1331e-18
C_MINT5_X_6080_Y_320 MINT5_X_6080_Y_320 0 7.1863e-18
C_MINT5_X_6080_Y_3200 MINT5_X_6080_Y_3200 0 8.2129e-18
C_MINT5_X_6080_Y_3520 MINT5_X_6080_Y_3520 0 8.2129e-18
C_MINT5_X_6080_Y_3840 MINT5_X_6080_Y_3840 0 5.1331e-18
C_MINT5_X_6080_Y_3920 MINT5_X_6080_Y_3920 0 4.1064e-18
C_MINT5_X_6080_Y_4160 MINT5_X_6080_Y_4160 0 7.1863e-18
C_MINT5_X_6080_Y_4480 MINT5_X_6080_Y_4480 0 8.2129e-18
C_MINT5_X_6080_Y_4800 MINT5_X_6080_Y_4800 0 7.1863e-18
C_MINT5_X_6080_Y_5040 MINT5_X_6080_Y_5040 0 4.1064e-18
C_MINT5_X_6080_Y_5120 MINT5_X_6080_Y_5120 0 5.1331e-18
C_MINT5_X_6080_Y_5440 MINT5_X_6080_Y_5440 0 8.2129e-18
C_MINT5_X_6080_Y_560 MINT5_X_6080_Y_560 0 4.1064e-18
C_MINT5_X_6080_Y_5760 MINT5_X_6080_Y_5760 0 8.2129e-18
C_MINT5_X_6080_Y_6080 MINT5_X_6080_Y_6080 0 5.1331e-18
C_MINT5_X_6080_Y_6160 MINT5_X_6080_Y_6160 0 4.1064e-18
C_MINT5_X_6080_Y_640 MINT5_X_6080_Y_640 0 5.1331e-18
C_MINT5_X_6080_Y_6400 MINT5_X_6080_Y_6400 0 7.1863e-18
C_MINT5_X_6080_Y_6720 MINT5_X_6080_Y_6720 0 8.2129e-18
C_MINT5_X_6080_Y_7040 MINT5_X_6080_Y_7040 0 7.1863e-18
C_MINT5_X_6080_Y_7280 MINT5_X_6080_Y_7280 0 4.1064e-18
C_MINT5_X_6080_Y_7360 MINT5_X_6080_Y_7360 0 5.1331e-18
C_MINT5_X_6080_Y_7680 MINT5_X_6080_Y_7680 0 8.2129e-18
C_MINT5_X_6080_Y_8000 MINT5_X_6080_Y_8000 0 8.2129e-18
C_MINT5_X_6080_Y_8320 MINT5_X_6080_Y_8320 0 5.1331e-18
C_MINT5_X_6080_Y_8400 MINT5_X_6080_Y_8400 0 4.1064e-18
C_MINT5_X_6080_Y_8640 MINT5_X_6080_Y_8640 0 7.1863e-18
C_MINT5_X_6080_Y_8960 MINT5_X_6080_Y_8960 0 8.2129e-18
C_MINT5_X_6080_Y_9280 MINT5_X_6080_Y_9280 0 7.1863e-18
C_MINT5_X_6080_Y_9520 MINT5_X_6080_Y_9520 0 4.1064e-18
C_MINT5_X_6080_Y_960 MINT5_X_6080_Y_960 0 8.2129e-18
C_MINT5_X_6080_Y_9600 MINT5_X_6080_Y_9600 0 5.1331e-18
C_MINT5_X_6080_Y_9920 MINT5_X_6080_Y_9920 0 5.1331e-18
C_MINT5_X_6400_Y_0 MINT5_X_6400_Y_0 0 4.1064e-18
C_MINT5_X_6400_Y_10000 MINT5_X_6400_Y_10000 0 1.0266e-18
C_MINT5_X_6400_Y_1120 MINT5_X_6400_Y_1120 0 4.1064e-18
C_MINT5_X_6400_Y_1280 MINT5_X_6400_Y_1280 0 6.1597e-18
C_MINT5_X_6400_Y_1600 MINT5_X_6400_Y_1600 0 8.2129e-18
C_MINT5_X_6400_Y_1920 MINT5_X_6400_Y_1920 0 8.2129e-18
C_MINT5_X_6400_Y_2240 MINT5_X_6400_Y_2240 0 8.2129e-18
C_MINT5_X_6400_Y_2560 MINT5_X_6400_Y_2560 0 8.2129e-18
C_MINT5_X_6400_Y_2880 MINT5_X_6400_Y_2880 0 8.2129e-18
C_MINT5_X_6400_Y_320 MINT5_X_6400_Y_320 0 8.2129e-18
C_MINT5_X_6400_Y_3200 MINT5_X_6400_Y_3200 0 6.1597e-18
C_MINT5_X_6400_Y_3360 MINT5_X_6400_Y_3360 0 4.1064e-18
C_MINT5_X_6400_Y_3520 MINT5_X_6400_Y_3520 0 6.1597e-18
C_MINT5_X_6400_Y_3840 MINT5_X_6400_Y_3840 0 8.2129e-18
C_MINT5_X_6400_Y_4160 MINT5_X_6400_Y_4160 0 8.2129e-18
C_MINT5_X_6400_Y_4480 MINT5_X_6400_Y_4480 0 8.2129e-18
C_MINT5_X_6400_Y_4800 MINT5_X_6400_Y_4800 0 8.2129e-18
C_MINT5_X_6400_Y_5120 MINT5_X_6400_Y_5120 0 8.2129e-18
C_MINT5_X_6400_Y_5440 MINT5_X_6400_Y_5440 0 6.1597e-18
C_MINT5_X_6400_Y_5600 MINT5_X_6400_Y_5600 0 4.1064e-18
C_MINT5_X_6400_Y_5760 MINT5_X_6400_Y_5760 0 6.1597e-18
C_MINT5_X_6400_Y_6080 MINT5_X_6400_Y_6080 0 8.2129e-18
C_MINT5_X_6400_Y_640 MINT5_X_6400_Y_640 0 8.2129e-18
C_MINT5_X_6400_Y_6400 MINT5_X_6400_Y_6400 0 8.2129e-18
C_MINT5_X_6400_Y_6720 MINT5_X_6400_Y_6720 0 8.2129e-18
C_MINT5_X_6400_Y_7040 MINT5_X_6400_Y_7040 0 8.2129e-18
C_MINT5_X_6400_Y_7360 MINT5_X_6400_Y_7360 0 8.2129e-18
C_MINT5_X_6400_Y_7680 MINT5_X_6400_Y_7680 0 6.1597e-18
C_MINT5_X_6400_Y_7840 MINT5_X_6400_Y_7840 0 4.1064e-18
C_MINT5_X_6400_Y_8000 MINT5_X_6400_Y_8000 0 6.1597e-18
C_MINT5_X_6400_Y_8320 MINT5_X_6400_Y_8320 0 8.2129e-18
C_MINT5_X_6400_Y_8640 MINT5_X_6400_Y_8640 0 8.2129e-18
C_MINT5_X_6400_Y_8960 MINT5_X_6400_Y_8960 0 8.2129e-18
C_MINT5_X_6400_Y_9280 MINT5_X_6400_Y_9280 0 8.2129e-18
C_MINT5_X_6400_Y_960 MINT5_X_6400_Y_960 0 6.1597e-18
C_MINT5_X_6400_Y_9600 MINT5_X_6400_Y_9600 0 8.2129e-18
C_MINT5_X_6400_Y_9920 MINT5_X_6400_Y_9920 0 5.1331e-18
C_MINT5_X_640_Y_0 MINT5_X_640_Y_0 0 4.1064e-18
C_MINT5_X_640_Y_10000 MINT5_X_640_Y_10000 0 1.0266e-18
C_MINT5_X_640_Y_1120 MINT5_X_640_Y_1120 0 4.1064e-18
C_MINT5_X_640_Y_1280 MINT5_X_640_Y_1280 0 6.1597e-18
C_MINT5_X_640_Y_1600 MINT5_X_640_Y_1600 0 8.2129e-18
C_MINT5_X_640_Y_1920 MINT5_X_640_Y_1920 0 8.2129e-18
C_MINT5_X_640_Y_2240 MINT5_X_640_Y_2240 0 8.2129e-18
C_MINT5_X_640_Y_2560 MINT5_X_640_Y_2560 0 8.2129e-18
C_MINT5_X_640_Y_2880 MINT5_X_640_Y_2880 0 8.2129e-18
C_MINT5_X_640_Y_320 MINT5_X_640_Y_320 0 8.2129e-18
C_MINT5_X_640_Y_3200 MINT5_X_640_Y_3200 0 6.1597e-18
C_MINT5_X_640_Y_3360 MINT5_X_640_Y_3360 0 4.1064e-18
C_MINT5_X_640_Y_3520 MINT5_X_640_Y_3520 0 6.1597e-18
C_MINT5_X_640_Y_3840 MINT5_X_640_Y_3840 0 8.2129e-18
C_MINT5_X_640_Y_4160 MINT5_X_640_Y_4160 0 8.2129e-18
C_MINT5_X_640_Y_4480 MINT5_X_640_Y_4480 0 8.2129e-18
C_MINT5_X_640_Y_4800 MINT5_X_640_Y_4800 0 8.2129e-18
C_MINT5_X_640_Y_5120 MINT5_X_640_Y_5120 0 8.2129e-18
C_MINT5_X_640_Y_5440 MINT5_X_640_Y_5440 0 6.1597e-18
C_MINT5_X_640_Y_5600 MINT5_X_640_Y_5600 0 4.1064e-18
C_MINT5_X_640_Y_5760 MINT5_X_640_Y_5760 0 6.1597e-18
C_MINT5_X_640_Y_6080 MINT5_X_640_Y_6080 0 8.2129e-18
C_MINT5_X_640_Y_640 MINT5_X_640_Y_640 0 8.2129e-18
C_MINT5_X_640_Y_6400 MINT5_X_640_Y_6400 0 8.2129e-18
C_MINT5_X_640_Y_6720 MINT5_X_640_Y_6720 0 8.2129e-18
C_MINT5_X_640_Y_7040 MINT5_X_640_Y_7040 0 8.2129e-18
C_MINT5_X_640_Y_7360 MINT5_X_640_Y_7360 0 8.2129e-18
C_MINT5_X_640_Y_7680 MINT5_X_640_Y_7680 0 6.1597e-18
C_MINT5_X_640_Y_7840 MINT5_X_640_Y_7840 0 4.1064e-18
C_MINT5_X_640_Y_8000 MINT5_X_640_Y_8000 0 6.1597e-18
C_MINT5_X_640_Y_8320 MINT5_X_640_Y_8320 0 8.2129e-18
C_MINT5_X_640_Y_8640 MINT5_X_640_Y_8640 0 8.2129e-18
C_MINT5_X_640_Y_8960 MINT5_X_640_Y_8960 0 8.2129e-18
C_MINT5_X_640_Y_9280 MINT5_X_640_Y_9280 0 8.2129e-18
C_MINT5_X_640_Y_960 MINT5_X_640_Y_960 0 6.1597e-18
C_MINT5_X_640_Y_9600 MINT5_X_640_Y_9600 0 8.2129e-18
C_MINT5_X_640_Y_9920 MINT5_X_640_Y_9920 0 5.1331e-18
C_MINT5_X_6720_Y_0 MINT5_X_6720_Y_0 0 4.1064e-18
C_MINT5_X_6720_Y_10000 MINT5_X_6720_Y_10000 0 1.0266e-18
C_MINT5_X_6720_Y_1280 MINT5_X_6720_Y_1280 0 8.2129e-18
C_MINT5_X_6720_Y_1600 MINT5_X_6720_Y_1600 0 5.1331e-18
C_MINT5_X_6720_Y_1680 MINT5_X_6720_Y_1680 0 4.1064e-18
C_MINT5_X_6720_Y_1920 MINT5_X_6720_Y_1920 0 7.1863e-18
C_MINT5_X_6720_Y_2240 MINT5_X_6720_Y_2240 0 8.2129e-18
C_MINT5_X_6720_Y_2560 MINT5_X_6720_Y_2560 0 7.1863e-18
C_MINT5_X_6720_Y_2800 MINT5_X_6720_Y_2800 0 4.1064e-18
C_MINT5_X_6720_Y_2880 MINT5_X_6720_Y_2880 0 5.1331e-18
C_MINT5_X_6720_Y_320 MINT5_X_6720_Y_320 0 7.1863e-18
C_MINT5_X_6720_Y_3200 MINT5_X_6720_Y_3200 0 8.2129e-18
C_MINT5_X_6720_Y_3520 MINT5_X_6720_Y_3520 0 8.2129e-18
C_MINT5_X_6720_Y_3840 MINT5_X_6720_Y_3840 0 5.1331e-18
C_MINT5_X_6720_Y_3920 MINT5_X_6720_Y_3920 0 4.1064e-18
C_MINT5_X_6720_Y_4160 MINT5_X_6720_Y_4160 0 7.1863e-18
C_MINT5_X_6720_Y_4480 MINT5_X_6720_Y_4480 0 8.2129e-18
C_MINT5_X_6720_Y_4800 MINT5_X_6720_Y_4800 0 7.1863e-18
C_MINT5_X_6720_Y_5040 MINT5_X_6720_Y_5040 0 4.1064e-18
C_MINT5_X_6720_Y_5120 MINT5_X_6720_Y_5120 0 5.1331e-18
C_MINT5_X_6720_Y_5440 MINT5_X_6720_Y_5440 0 8.2129e-18
C_MINT5_X_6720_Y_560 MINT5_X_6720_Y_560 0 4.1064e-18
C_MINT5_X_6720_Y_5760 MINT5_X_6720_Y_5760 0 8.2129e-18
C_MINT5_X_6720_Y_6080 MINT5_X_6720_Y_6080 0 5.1331e-18
C_MINT5_X_6720_Y_6160 MINT5_X_6720_Y_6160 0 4.1064e-18
C_MINT5_X_6720_Y_640 MINT5_X_6720_Y_640 0 5.1331e-18
C_MINT5_X_6720_Y_6400 MINT5_X_6720_Y_6400 0 7.1863e-18
C_MINT5_X_6720_Y_6720 MINT5_X_6720_Y_6720 0 8.2129e-18
C_MINT5_X_6720_Y_7040 MINT5_X_6720_Y_7040 0 7.1863e-18
C_MINT5_X_6720_Y_7280 MINT5_X_6720_Y_7280 0 4.1064e-18
C_MINT5_X_6720_Y_7360 MINT5_X_6720_Y_7360 0 5.1331e-18
C_MINT5_X_6720_Y_7680 MINT5_X_6720_Y_7680 0 8.2129e-18
C_MINT5_X_6720_Y_8000 MINT5_X_6720_Y_8000 0 8.2129e-18
C_MINT5_X_6720_Y_8320 MINT5_X_6720_Y_8320 0 5.1331e-18
C_MINT5_X_6720_Y_8400 MINT5_X_6720_Y_8400 0 4.1064e-18
C_MINT5_X_6720_Y_8640 MINT5_X_6720_Y_8640 0 7.1863e-18
C_MINT5_X_6720_Y_8960 MINT5_X_6720_Y_8960 0 8.2129e-18
C_MINT5_X_6720_Y_9280 MINT5_X_6720_Y_9280 0 7.1863e-18
C_MINT5_X_6720_Y_9520 MINT5_X_6720_Y_9520 0 4.1064e-18
C_MINT5_X_6720_Y_960 MINT5_X_6720_Y_960 0 8.2129e-18
C_MINT5_X_6720_Y_9600 MINT5_X_6720_Y_9600 0 5.1331e-18
C_MINT5_X_6720_Y_9920 MINT5_X_6720_Y_9920 0 5.1331e-18
C_MINT5_X_7040_Y_0 MINT5_X_7040_Y_0 0 4.1064e-18
C_MINT5_X_7040_Y_10000 MINT5_X_7040_Y_10000 0 1.0266e-18
C_MINT5_X_7040_Y_1120 MINT5_X_7040_Y_1120 0 4.1064e-18
C_MINT5_X_7040_Y_1280 MINT5_X_7040_Y_1280 0 6.1597e-18
C_MINT5_X_7040_Y_1600 MINT5_X_7040_Y_1600 0 8.2129e-18
C_MINT5_X_7040_Y_1920 MINT5_X_7040_Y_1920 0 8.2129e-18
C_MINT5_X_7040_Y_2240 MINT5_X_7040_Y_2240 0 8.2129e-18
C_MINT5_X_7040_Y_2560 MINT5_X_7040_Y_2560 0 8.2129e-18
C_MINT5_X_7040_Y_2880 MINT5_X_7040_Y_2880 0 8.2129e-18
C_MINT5_X_7040_Y_320 MINT5_X_7040_Y_320 0 8.2129e-18
C_MINT5_X_7040_Y_3200 MINT5_X_7040_Y_3200 0 6.1597e-18
C_MINT5_X_7040_Y_3360 MINT5_X_7040_Y_3360 0 4.1064e-18
C_MINT5_X_7040_Y_3520 MINT5_X_7040_Y_3520 0 6.1597e-18
C_MINT5_X_7040_Y_3840 MINT5_X_7040_Y_3840 0 8.2129e-18
C_MINT5_X_7040_Y_4160 MINT5_X_7040_Y_4160 0 8.2129e-18
C_MINT5_X_7040_Y_4480 MINT5_X_7040_Y_4480 0 8.2129e-18
C_MINT5_X_7040_Y_4800 MINT5_X_7040_Y_4800 0 8.2129e-18
C_MINT5_X_7040_Y_5120 MINT5_X_7040_Y_5120 0 8.2129e-18
C_MINT5_X_7040_Y_5440 MINT5_X_7040_Y_5440 0 6.1597e-18
C_MINT5_X_7040_Y_5600 MINT5_X_7040_Y_5600 0 4.1064e-18
C_MINT5_X_7040_Y_5760 MINT5_X_7040_Y_5760 0 6.1597e-18
C_MINT5_X_7040_Y_6080 MINT5_X_7040_Y_6080 0 8.2129e-18
C_MINT5_X_7040_Y_640 MINT5_X_7040_Y_640 0 8.2129e-18
C_MINT5_X_7040_Y_6400 MINT5_X_7040_Y_6400 0 8.2129e-18
C_MINT5_X_7040_Y_6720 MINT5_X_7040_Y_6720 0 8.2129e-18
C_MINT5_X_7040_Y_7040 MINT5_X_7040_Y_7040 0 8.2129e-18
C_MINT5_X_7040_Y_7360 MINT5_X_7040_Y_7360 0 8.2129e-18
C_MINT5_X_7040_Y_7680 MINT5_X_7040_Y_7680 0 6.1597e-18
C_MINT5_X_7040_Y_7840 MINT5_X_7040_Y_7840 0 4.1064e-18
C_MINT5_X_7040_Y_8000 MINT5_X_7040_Y_8000 0 6.1597e-18
C_MINT5_X_7040_Y_8320 MINT5_X_7040_Y_8320 0 8.2129e-18
C_MINT5_X_7040_Y_8640 MINT5_X_7040_Y_8640 0 8.2129e-18
C_MINT5_X_7040_Y_8960 MINT5_X_7040_Y_8960 0 8.2129e-18
C_MINT5_X_7040_Y_9280 MINT5_X_7040_Y_9280 0 8.2129e-18
C_MINT5_X_7040_Y_960 MINT5_X_7040_Y_960 0 6.1597e-18
C_MINT5_X_7040_Y_9600 MINT5_X_7040_Y_9600 0 8.2129e-18
C_MINT5_X_7040_Y_9920 MINT5_X_7040_Y_9920 0 5.1331e-18
C_MINT5_X_7360_Y_0 MINT5_X_7360_Y_0 0 4.1064e-18
C_MINT5_X_7360_Y_10000 MINT5_X_7360_Y_10000 0 1.0266e-18
C_MINT5_X_7360_Y_1280 MINT5_X_7360_Y_1280 0 8.2129e-18
C_MINT5_X_7360_Y_1600 MINT5_X_7360_Y_1600 0 5.1331e-18
C_MINT5_X_7360_Y_1680 MINT5_X_7360_Y_1680 0 4.1064e-18
C_MINT5_X_7360_Y_1920 MINT5_X_7360_Y_1920 0 7.1863e-18
C_MINT5_X_7360_Y_2240 MINT5_X_7360_Y_2240 0 8.2129e-18
C_MINT5_X_7360_Y_2560 MINT5_X_7360_Y_2560 0 7.1863e-18
C_MINT5_X_7360_Y_2800 MINT5_X_7360_Y_2800 0 4.1064e-18
C_MINT5_X_7360_Y_2880 MINT5_X_7360_Y_2880 0 5.1331e-18
C_MINT5_X_7360_Y_320 MINT5_X_7360_Y_320 0 7.1863e-18
C_MINT5_X_7360_Y_3200 MINT5_X_7360_Y_3200 0 8.2129e-18
C_MINT5_X_7360_Y_3520 MINT5_X_7360_Y_3520 0 8.2129e-18
C_MINT5_X_7360_Y_3840 MINT5_X_7360_Y_3840 0 5.1331e-18
C_MINT5_X_7360_Y_3920 MINT5_X_7360_Y_3920 0 4.1064e-18
C_MINT5_X_7360_Y_4160 MINT5_X_7360_Y_4160 0 7.1863e-18
C_MINT5_X_7360_Y_4480 MINT5_X_7360_Y_4480 0 8.2129e-18
C_MINT5_X_7360_Y_4800 MINT5_X_7360_Y_4800 0 7.1863e-18
C_MINT5_X_7360_Y_5040 MINT5_X_7360_Y_5040 0 4.1064e-18
C_MINT5_X_7360_Y_5120 MINT5_X_7360_Y_5120 0 5.1331e-18
C_MINT5_X_7360_Y_5440 MINT5_X_7360_Y_5440 0 8.2129e-18
C_MINT5_X_7360_Y_560 MINT5_X_7360_Y_560 0 4.1064e-18
C_MINT5_X_7360_Y_5760 MINT5_X_7360_Y_5760 0 8.2129e-18
C_MINT5_X_7360_Y_6080 MINT5_X_7360_Y_6080 0 5.1331e-18
C_MINT5_X_7360_Y_6160 MINT5_X_7360_Y_6160 0 4.1064e-18
C_MINT5_X_7360_Y_640 MINT5_X_7360_Y_640 0 5.1331e-18
C_MINT5_X_7360_Y_6400 MINT5_X_7360_Y_6400 0 7.1863e-18
C_MINT5_X_7360_Y_6720 MINT5_X_7360_Y_6720 0 8.2129e-18
C_MINT5_X_7360_Y_7040 MINT5_X_7360_Y_7040 0 7.1863e-18
C_MINT5_X_7360_Y_7280 MINT5_X_7360_Y_7280 0 4.1064e-18
C_MINT5_X_7360_Y_7360 MINT5_X_7360_Y_7360 0 5.1331e-18
C_MINT5_X_7360_Y_7680 MINT5_X_7360_Y_7680 0 8.2129e-18
C_MINT5_X_7360_Y_8000 MINT5_X_7360_Y_8000 0 8.2129e-18
C_MINT5_X_7360_Y_8320 MINT5_X_7360_Y_8320 0 5.1331e-18
C_MINT5_X_7360_Y_8400 MINT5_X_7360_Y_8400 0 4.1064e-18
C_MINT5_X_7360_Y_8640 MINT5_X_7360_Y_8640 0 7.1863e-18
C_MINT5_X_7360_Y_8960 MINT5_X_7360_Y_8960 0 8.2129e-18
C_MINT5_X_7360_Y_9280 MINT5_X_7360_Y_9280 0 7.1863e-18
C_MINT5_X_7360_Y_9520 MINT5_X_7360_Y_9520 0 4.1064e-18
C_MINT5_X_7360_Y_960 MINT5_X_7360_Y_960 0 8.2129e-18
C_MINT5_X_7360_Y_9600 MINT5_X_7360_Y_9600 0 5.1331e-18
C_MINT5_X_7360_Y_9920 MINT5_X_7360_Y_9920 0 5.1331e-18
C_MINT5_X_7680_Y_0 MINT5_X_7680_Y_0 0 4.1064e-18
C_MINT5_X_7680_Y_10000 MINT5_X_7680_Y_10000 0 1.0266e-18
C_MINT5_X_7680_Y_1120 MINT5_X_7680_Y_1120 0 4.1064e-18
C_MINT5_X_7680_Y_1280 MINT5_X_7680_Y_1280 0 6.1597e-18
C_MINT5_X_7680_Y_1600 MINT5_X_7680_Y_1600 0 8.2129e-18
C_MINT5_X_7680_Y_1920 MINT5_X_7680_Y_1920 0 8.2129e-18
C_MINT5_X_7680_Y_2240 MINT5_X_7680_Y_2240 0 8.2129e-18
C_MINT5_X_7680_Y_2560 MINT5_X_7680_Y_2560 0 8.2129e-18
C_MINT5_X_7680_Y_2880 MINT5_X_7680_Y_2880 0 8.2129e-18
C_MINT5_X_7680_Y_320 MINT5_X_7680_Y_320 0 8.2129e-18
C_MINT5_X_7680_Y_3200 MINT5_X_7680_Y_3200 0 6.1597e-18
C_MINT5_X_7680_Y_3360 MINT5_X_7680_Y_3360 0 4.1064e-18
C_MINT5_X_7680_Y_3520 MINT5_X_7680_Y_3520 0 6.1597e-18
C_MINT5_X_7680_Y_3840 MINT5_X_7680_Y_3840 0 8.2129e-18
C_MINT5_X_7680_Y_4160 MINT5_X_7680_Y_4160 0 8.2129e-18
C_MINT5_X_7680_Y_4480 MINT5_X_7680_Y_4480 0 8.2129e-18
C_MINT5_X_7680_Y_4800 MINT5_X_7680_Y_4800 0 8.2129e-18
C_MINT5_X_7680_Y_5120 MINT5_X_7680_Y_5120 0 8.2129e-18
C_MINT5_X_7680_Y_5440 MINT5_X_7680_Y_5440 0 6.1597e-18
C_MINT5_X_7680_Y_5600 MINT5_X_7680_Y_5600 0 4.1064e-18
C_MINT5_X_7680_Y_5760 MINT5_X_7680_Y_5760 0 6.1597e-18
C_MINT5_X_7680_Y_6080 MINT5_X_7680_Y_6080 0 8.2129e-18
C_MINT5_X_7680_Y_640 MINT5_X_7680_Y_640 0 8.2129e-18
C_MINT5_X_7680_Y_6400 MINT5_X_7680_Y_6400 0 8.2129e-18
C_MINT5_X_7680_Y_6720 MINT5_X_7680_Y_6720 0 8.2129e-18
C_MINT5_X_7680_Y_7040 MINT5_X_7680_Y_7040 0 8.2129e-18
C_MINT5_X_7680_Y_7360 MINT5_X_7680_Y_7360 0 8.2129e-18
C_MINT5_X_7680_Y_7680 MINT5_X_7680_Y_7680 0 6.1597e-18
C_MINT5_X_7680_Y_7840 MINT5_X_7680_Y_7840 0 4.1064e-18
C_MINT5_X_7680_Y_8000 MINT5_X_7680_Y_8000 0 6.1597e-18
C_MINT5_X_7680_Y_8320 MINT5_X_7680_Y_8320 0 8.2129e-18
C_MINT5_X_7680_Y_8640 MINT5_X_7680_Y_8640 0 8.2129e-18
C_MINT5_X_7680_Y_8960 MINT5_X_7680_Y_8960 0 8.2129e-18
C_MINT5_X_7680_Y_9280 MINT5_X_7680_Y_9280 0 8.2129e-18
C_MINT5_X_7680_Y_960 MINT5_X_7680_Y_960 0 6.1597e-18
C_MINT5_X_7680_Y_9600 MINT5_X_7680_Y_9600 0 8.2129e-18
C_MINT5_X_7680_Y_9920 MINT5_X_7680_Y_9920 0 5.1331e-18
C_MINT5_X_8000_Y_0 MINT5_X_8000_Y_0 0 4.1064e-18
C_MINT5_X_8000_Y_10000 MINT5_X_8000_Y_10000 0 1.0266e-18
C_MINT5_X_8000_Y_1280 MINT5_X_8000_Y_1280 0 8.2129e-18
C_MINT5_X_8000_Y_1600 MINT5_X_8000_Y_1600 0 5.1331e-18
C_MINT5_X_8000_Y_1680 MINT5_X_8000_Y_1680 0 4.1064e-18
C_MINT5_X_8000_Y_1920 MINT5_X_8000_Y_1920 0 7.1863e-18
C_MINT5_X_8000_Y_2240 MINT5_X_8000_Y_2240 0 8.2129e-18
C_MINT5_X_8000_Y_2560 MINT5_X_8000_Y_2560 0 7.1863e-18
C_MINT5_X_8000_Y_2800 MINT5_X_8000_Y_2800 0 4.1064e-18
C_MINT5_X_8000_Y_2880 MINT5_X_8000_Y_2880 0 5.1331e-18
C_MINT5_X_8000_Y_320 MINT5_X_8000_Y_320 0 7.1863e-18
C_MINT5_X_8000_Y_3200 MINT5_X_8000_Y_3200 0 8.2129e-18
C_MINT5_X_8000_Y_3520 MINT5_X_8000_Y_3520 0 8.2129e-18
C_MINT5_X_8000_Y_3840 MINT5_X_8000_Y_3840 0 5.1331e-18
C_MINT5_X_8000_Y_3920 MINT5_X_8000_Y_3920 0 4.1064e-18
C_MINT5_X_8000_Y_4160 MINT5_X_8000_Y_4160 0 7.1863e-18
C_MINT5_X_8000_Y_4480 MINT5_X_8000_Y_4480 0 8.2129e-18
C_MINT5_X_8000_Y_4800 MINT5_X_8000_Y_4800 0 7.1863e-18
C_MINT5_X_8000_Y_5040 MINT5_X_8000_Y_5040 0 4.1064e-18
C_MINT5_X_8000_Y_5120 MINT5_X_8000_Y_5120 0 5.1331e-18
C_MINT5_X_8000_Y_5440 MINT5_X_8000_Y_5440 0 8.2129e-18
C_MINT5_X_8000_Y_560 MINT5_X_8000_Y_560 0 4.1064e-18
C_MINT5_X_8000_Y_5760 MINT5_X_8000_Y_5760 0 8.2129e-18
C_MINT5_X_8000_Y_6080 MINT5_X_8000_Y_6080 0 5.1331e-18
C_MINT5_X_8000_Y_6160 MINT5_X_8000_Y_6160 0 4.1064e-18
C_MINT5_X_8000_Y_640 MINT5_X_8000_Y_640 0 5.1331e-18
C_MINT5_X_8000_Y_6400 MINT5_X_8000_Y_6400 0 7.1863e-18
C_MINT5_X_8000_Y_6720 MINT5_X_8000_Y_6720 0 8.2129e-18
C_MINT5_X_8000_Y_7040 MINT5_X_8000_Y_7040 0 7.1863e-18
C_MINT5_X_8000_Y_7280 MINT5_X_8000_Y_7280 0 4.1064e-18
C_MINT5_X_8000_Y_7360 MINT5_X_8000_Y_7360 0 5.1331e-18
C_MINT5_X_8000_Y_7680 MINT5_X_8000_Y_7680 0 8.2129e-18
C_MINT5_X_8000_Y_8000 MINT5_X_8000_Y_8000 0 8.2129e-18
C_MINT5_X_8000_Y_8320 MINT5_X_8000_Y_8320 0 5.1331e-18
C_MINT5_X_8000_Y_8400 MINT5_X_8000_Y_8400 0 4.1064e-18
C_MINT5_X_8000_Y_8640 MINT5_X_8000_Y_8640 0 7.1863e-18
C_MINT5_X_8000_Y_8960 MINT5_X_8000_Y_8960 0 8.2129e-18
C_MINT5_X_8000_Y_9280 MINT5_X_8000_Y_9280 0 7.1863e-18
C_MINT5_X_8000_Y_9520 MINT5_X_8000_Y_9520 0 4.1064e-18
C_MINT5_X_8000_Y_960 MINT5_X_8000_Y_960 0 8.2129e-18
C_MINT5_X_8000_Y_9600 MINT5_X_8000_Y_9600 0 5.1331e-18
C_MINT5_X_8000_Y_9920 MINT5_X_8000_Y_9920 0 5.1331e-18
C_MINT5_X_8320_Y_0 MINT5_X_8320_Y_0 0 4.1064e-18
C_MINT5_X_8320_Y_10000 MINT5_X_8320_Y_10000 0 1.0266e-18
C_MINT5_X_8320_Y_1120 MINT5_X_8320_Y_1120 0 4.1064e-18
C_MINT5_X_8320_Y_1280 MINT5_X_8320_Y_1280 0 6.1597e-18
C_MINT5_X_8320_Y_1600 MINT5_X_8320_Y_1600 0 8.2129e-18
C_MINT5_X_8320_Y_1920 MINT5_X_8320_Y_1920 0 8.2129e-18
C_MINT5_X_8320_Y_2240 MINT5_X_8320_Y_2240 0 8.2129e-18
C_MINT5_X_8320_Y_2560 MINT5_X_8320_Y_2560 0 8.2129e-18
C_MINT5_X_8320_Y_2880 MINT5_X_8320_Y_2880 0 8.2129e-18
C_MINT5_X_8320_Y_320 MINT5_X_8320_Y_320 0 8.2129e-18
C_MINT5_X_8320_Y_3200 MINT5_X_8320_Y_3200 0 6.1597e-18
C_MINT5_X_8320_Y_3360 MINT5_X_8320_Y_3360 0 4.1064e-18
C_MINT5_X_8320_Y_3520 MINT5_X_8320_Y_3520 0 6.1597e-18
C_MINT5_X_8320_Y_3840 MINT5_X_8320_Y_3840 0 8.2129e-18
C_MINT5_X_8320_Y_4160 MINT5_X_8320_Y_4160 0 8.2129e-18
C_MINT5_X_8320_Y_4480 MINT5_X_8320_Y_4480 0 8.2129e-18
C_MINT5_X_8320_Y_4800 MINT5_X_8320_Y_4800 0 8.2129e-18
C_MINT5_X_8320_Y_5120 MINT5_X_8320_Y_5120 0 8.2129e-18
C_MINT5_X_8320_Y_5440 MINT5_X_8320_Y_5440 0 6.1597e-18
C_MINT5_X_8320_Y_5600 MINT5_X_8320_Y_5600 0 4.1064e-18
C_MINT5_X_8320_Y_5760 MINT5_X_8320_Y_5760 0 6.1597e-18
C_MINT5_X_8320_Y_6080 MINT5_X_8320_Y_6080 0 8.2129e-18
C_MINT5_X_8320_Y_640 MINT5_X_8320_Y_640 0 8.2129e-18
C_MINT5_X_8320_Y_6400 MINT5_X_8320_Y_6400 0 8.2129e-18
C_MINT5_X_8320_Y_6720 MINT5_X_8320_Y_6720 0 8.2129e-18
C_MINT5_X_8320_Y_7040 MINT5_X_8320_Y_7040 0 8.2129e-18
C_MINT5_X_8320_Y_7360 MINT5_X_8320_Y_7360 0 8.2129e-18
C_MINT5_X_8320_Y_7680 MINT5_X_8320_Y_7680 0 6.1597e-18
C_MINT5_X_8320_Y_7840 MINT5_X_8320_Y_7840 0 4.1064e-18
C_MINT5_X_8320_Y_8000 MINT5_X_8320_Y_8000 0 6.1597e-18
C_MINT5_X_8320_Y_8320 MINT5_X_8320_Y_8320 0 8.2129e-18
C_MINT5_X_8320_Y_8640 MINT5_X_8320_Y_8640 0 8.2129e-18
C_MINT5_X_8320_Y_8960 MINT5_X_8320_Y_8960 0 8.2129e-18
C_MINT5_X_8320_Y_9280 MINT5_X_8320_Y_9280 0 8.2129e-18
C_MINT5_X_8320_Y_960 MINT5_X_8320_Y_960 0 6.1597e-18
C_MINT5_X_8320_Y_9600 MINT5_X_8320_Y_9600 0 8.2129e-18
C_MINT5_X_8320_Y_9920 MINT5_X_8320_Y_9920 0 5.1331e-18
C_MINT5_X_8640_Y_0 MINT5_X_8640_Y_0 0 4.1064e-18
C_MINT5_X_8640_Y_10000 MINT5_X_8640_Y_10000 0 1.0266e-18
C_MINT5_X_8640_Y_1280 MINT5_X_8640_Y_1280 0 8.2129e-18
C_MINT5_X_8640_Y_1600 MINT5_X_8640_Y_1600 0 5.1331e-18
C_MINT5_X_8640_Y_1680 MINT5_X_8640_Y_1680 0 4.1064e-18
C_MINT5_X_8640_Y_1920 MINT5_X_8640_Y_1920 0 7.1863e-18
C_MINT5_X_8640_Y_2240 MINT5_X_8640_Y_2240 0 8.2129e-18
C_MINT5_X_8640_Y_2560 MINT5_X_8640_Y_2560 0 7.1863e-18
C_MINT5_X_8640_Y_2800 MINT5_X_8640_Y_2800 0 4.1064e-18
C_MINT5_X_8640_Y_2880 MINT5_X_8640_Y_2880 0 5.1331e-18
C_MINT5_X_8640_Y_320 MINT5_X_8640_Y_320 0 7.1863e-18
C_MINT5_X_8640_Y_3200 MINT5_X_8640_Y_3200 0 8.2129e-18
C_MINT5_X_8640_Y_3520 MINT5_X_8640_Y_3520 0 8.2129e-18
C_MINT5_X_8640_Y_3840 MINT5_X_8640_Y_3840 0 5.1331e-18
C_MINT5_X_8640_Y_3920 MINT5_X_8640_Y_3920 0 4.1064e-18
C_MINT5_X_8640_Y_4160 MINT5_X_8640_Y_4160 0 7.1863e-18
C_MINT5_X_8640_Y_4480 MINT5_X_8640_Y_4480 0 8.2129e-18
C_MINT5_X_8640_Y_4800 MINT5_X_8640_Y_4800 0 7.1863e-18
C_MINT5_X_8640_Y_5040 MINT5_X_8640_Y_5040 0 4.1064e-18
C_MINT5_X_8640_Y_5120 MINT5_X_8640_Y_5120 0 5.1331e-18
C_MINT5_X_8640_Y_5440 MINT5_X_8640_Y_5440 0 8.2129e-18
C_MINT5_X_8640_Y_560 MINT5_X_8640_Y_560 0 4.1064e-18
C_MINT5_X_8640_Y_5760 MINT5_X_8640_Y_5760 0 8.2129e-18
C_MINT5_X_8640_Y_6080 MINT5_X_8640_Y_6080 0 5.1331e-18
C_MINT5_X_8640_Y_6160 MINT5_X_8640_Y_6160 0 4.1064e-18
C_MINT5_X_8640_Y_640 MINT5_X_8640_Y_640 0 5.1331e-18
C_MINT5_X_8640_Y_6400 MINT5_X_8640_Y_6400 0 7.1863e-18
C_MINT5_X_8640_Y_6720 MINT5_X_8640_Y_6720 0 8.2129e-18
C_MINT5_X_8640_Y_7040 MINT5_X_8640_Y_7040 0 7.1863e-18
C_MINT5_X_8640_Y_7280 MINT5_X_8640_Y_7280 0 4.1064e-18
C_MINT5_X_8640_Y_7360 MINT5_X_8640_Y_7360 0 5.1331e-18
C_MINT5_X_8640_Y_7680 MINT5_X_8640_Y_7680 0 8.2129e-18
C_MINT5_X_8640_Y_8000 MINT5_X_8640_Y_8000 0 8.2129e-18
C_MINT5_X_8640_Y_8320 MINT5_X_8640_Y_8320 0 5.1331e-18
C_MINT5_X_8640_Y_8400 MINT5_X_8640_Y_8400 0 4.1064e-18
C_MINT5_X_8640_Y_8640 MINT5_X_8640_Y_8640 0 7.1863e-18
C_MINT5_X_8640_Y_8960 MINT5_X_8640_Y_8960 0 8.2129e-18
C_MINT5_X_8640_Y_9280 MINT5_X_8640_Y_9280 0 7.1863e-18
C_MINT5_X_8640_Y_9520 MINT5_X_8640_Y_9520 0 4.1064e-18
C_MINT5_X_8640_Y_960 MINT5_X_8640_Y_960 0 8.2129e-18
C_MINT5_X_8640_Y_9600 MINT5_X_8640_Y_9600 0 5.1331e-18
C_MINT5_X_8640_Y_9920 MINT5_X_8640_Y_9920 0 5.1331e-18
C_MINT5_X_8960_Y_0 MINT5_X_8960_Y_0 0 4.1064e-18
C_MINT5_X_8960_Y_10000 MINT5_X_8960_Y_10000 0 1.0266e-18
C_MINT5_X_8960_Y_1120 MINT5_X_8960_Y_1120 0 4.1064e-18
C_MINT5_X_8960_Y_1280 MINT5_X_8960_Y_1280 0 6.1597e-18
C_MINT5_X_8960_Y_1600 MINT5_X_8960_Y_1600 0 8.2129e-18
C_MINT5_X_8960_Y_1920 MINT5_X_8960_Y_1920 0 8.2129e-18
C_MINT5_X_8960_Y_2240 MINT5_X_8960_Y_2240 0 8.2129e-18
C_MINT5_X_8960_Y_2560 MINT5_X_8960_Y_2560 0 8.2129e-18
C_MINT5_X_8960_Y_2880 MINT5_X_8960_Y_2880 0 8.2129e-18
C_MINT5_X_8960_Y_320 MINT5_X_8960_Y_320 0 8.2129e-18
C_MINT5_X_8960_Y_3200 MINT5_X_8960_Y_3200 0 6.1597e-18
C_MINT5_X_8960_Y_3360 MINT5_X_8960_Y_3360 0 4.1064e-18
C_MINT5_X_8960_Y_3520 MINT5_X_8960_Y_3520 0 6.1597e-18
C_MINT5_X_8960_Y_3840 MINT5_X_8960_Y_3840 0 8.2129e-18
C_MINT5_X_8960_Y_4160 MINT5_X_8960_Y_4160 0 8.2129e-18
C_MINT5_X_8960_Y_4480 MINT5_X_8960_Y_4480 0 8.2129e-18
C_MINT5_X_8960_Y_4800 MINT5_X_8960_Y_4800 0 8.2129e-18
C_MINT5_X_8960_Y_5120 MINT5_X_8960_Y_5120 0 8.2129e-18
C_MINT5_X_8960_Y_5440 MINT5_X_8960_Y_5440 0 6.1597e-18
C_MINT5_X_8960_Y_5600 MINT5_X_8960_Y_5600 0 4.1064e-18
C_MINT5_X_8960_Y_5760 MINT5_X_8960_Y_5760 0 6.1597e-18
C_MINT5_X_8960_Y_6080 MINT5_X_8960_Y_6080 0 8.2129e-18
C_MINT5_X_8960_Y_640 MINT5_X_8960_Y_640 0 8.2129e-18
C_MINT5_X_8960_Y_6400 MINT5_X_8960_Y_6400 0 8.2129e-18
C_MINT5_X_8960_Y_6720 MINT5_X_8960_Y_6720 0 8.2129e-18
C_MINT5_X_8960_Y_7040 MINT5_X_8960_Y_7040 0 8.2129e-18
C_MINT5_X_8960_Y_7360 MINT5_X_8960_Y_7360 0 8.2129e-18
C_MINT5_X_8960_Y_7680 MINT5_X_8960_Y_7680 0 6.1597e-18
C_MINT5_X_8960_Y_7840 MINT5_X_8960_Y_7840 0 4.1064e-18
C_MINT5_X_8960_Y_8000 MINT5_X_8960_Y_8000 0 6.1597e-18
C_MINT5_X_8960_Y_8320 MINT5_X_8960_Y_8320 0 8.2129e-18
C_MINT5_X_8960_Y_8640 MINT5_X_8960_Y_8640 0 8.2129e-18
C_MINT5_X_8960_Y_8960 MINT5_X_8960_Y_8960 0 8.2129e-18
C_MINT5_X_8960_Y_9280 MINT5_X_8960_Y_9280 0 8.2129e-18
C_MINT5_X_8960_Y_960 MINT5_X_8960_Y_960 0 6.1597e-18
C_MINT5_X_8960_Y_9600 MINT5_X_8960_Y_9600 0 8.2129e-18
C_MINT5_X_8960_Y_9920 MINT5_X_8960_Y_9920 0 5.1331e-18
C_MINT5_X_9280_Y_0 MINT5_X_9280_Y_0 0 4.1064e-18
C_MINT5_X_9280_Y_10000 MINT5_X_9280_Y_10000 0 1.0266e-18
C_MINT5_X_9280_Y_1280 MINT5_X_9280_Y_1280 0 8.2129e-18
C_MINT5_X_9280_Y_1600 MINT5_X_9280_Y_1600 0 5.1331e-18
C_MINT5_X_9280_Y_1680 MINT5_X_9280_Y_1680 0 4.1064e-18
C_MINT5_X_9280_Y_1920 MINT5_X_9280_Y_1920 0 7.1863e-18
C_MINT5_X_9280_Y_2240 MINT5_X_9280_Y_2240 0 8.2129e-18
C_MINT5_X_9280_Y_2560 MINT5_X_9280_Y_2560 0 7.1863e-18
C_MINT5_X_9280_Y_2800 MINT5_X_9280_Y_2800 0 4.1064e-18
C_MINT5_X_9280_Y_2880 MINT5_X_9280_Y_2880 0 5.1331e-18
C_MINT5_X_9280_Y_320 MINT5_X_9280_Y_320 0 7.1863e-18
C_MINT5_X_9280_Y_3200 MINT5_X_9280_Y_3200 0 8.2129e-18
C_MINT5_X_9280_Y_3520 MINT5_X_9280_Y_3520 0 8.2129e-18
C_MINT5_X_9280_Y_3840 MINT5_X_9280_Y_3840 0 5.1331e-18
C_MINT5_X_9280_Y_3920 MINT5_X_9280_Y_3920 0 4.1064e-18
C_MINT5_X_9280_Y_4160 MINT5_X_9280_Y_4160 0 7.1863e-18
C_MINT5_X_9280_Y_4480 MINT5_X_9280_Y_4480 0 8.2129e-18
C_MINT5_X_9280_Y_4800 MINT5_X_9280_Y_4800 0 7.1863e-18
C_MINT5_X_9280_Y_5040 MINT5_X_9280_Y_5040 0 4.1064e-18
C_MINT5_X_9280_Y_5120 MINT5_X_9280_Y_5120 0 5.1331e-18
C_MINT5_X_9280_Y_5440 MINT5_X_9280_Y_5440 0 8.2129e-18
C_MINT5_X_9280_Y_560 MINT5_X_9280_Y_560 0 4.1064e-18
C_MINT5_X_9280_Y_5760 MINT5_X_9280_Y_5760 0 8.2129e-18
C_MINT5_X_9280_Y_6080 MINT5_X_9280_Y_6080 0 5.1331e-18
C_MINT5_X_9280_Y_6160 MINT5_X_9280_Y_6160 0 4.1064e-18
C_MINT5_X_9280_Y_640 MINT5_X_9280_Y_640 0 5.1331e-18
C_MINT5_X_9280_Y_6400 MINT5_X_9280_Y_6400 0 7.1863e-18
C_MINT5_X_9280_Y_6720 MINT5_X_9280_Y_6720 0 8.2129e-18
C_MINT5_X_9280_Y_7040 MINT5_X_9280_Y_7040 0 7.1863e-18
C_MINT5_X_9280_Y_7280 MINT5_X_9280_Y_7280 0 4.1064e-18
C_MINT5_X_9280_Y_7360 MINT5_X_9280_Y_7360 0 5.1331e-18
C_MINT5_X_9280_Y_7680 MINT5_X_9280_Y_7680 0 8.2129e-18
C_MINT5_X_9280_Y_8000 MINT5_X_9280_Y_8000 0 8.2129e-18
C_MINT5_X_9280_Y_8320 MINT5_X_9280_Y_8320 0 5.1331e-18
C_MINT5_X_9280_Y_8400 MINT5_X_9280_Y_8400 0 4.1064e-18
C_MINT5_X_9280_Y_8640 MINT5_X_9280_Y_8640 0 7.1863e-18
C_MINT5_X_9280_Y_8960 MINT5_X_9280_Y_8960 0 8.2129e-18
C_MINT5_X_9280_Y_9280 MINT5_X_9280_Y_9280 0 7.1863e-18
C_MINT5_X_9280_Y_9520 MINT5_X_9280_Y_9520 0 4.1064e-18
C_MINT5_X_9280_Y_960 MINT5_X_9280_Y_960 0 8.2129e-18
C_MINT5_X_9280_Y_9600 MINT5_X_9280_Y_9600 0 5.1331e-18
C_MINT5_X_9280_Y_9920 MINT5_X_9280_Y_9920 0 5.1331e-18
C_MINT5_X_9600_Y_0 MINT5_X_9600_Y_0 0 4.1064e-18
C_MINT5_X_9600_Y_10000 MINT5_X_9600_Y_10000 0 1.0266e-18
C_MINT5_X_9600_Y_1120 MINT5_X_9600_Y_1120 0 4.1064e-18
C_MINT5_X_9600_Y_1280 MINT5_X_9600_Y_1280 0 6.1597e-18
C_MINT5_X_9600_Y_1600 MINT5_X_9600_Y_1600 0 8.2129e-18
C_MINT5_X_9600_Y_1920 MINT5_X_9600_Y_1920 0 8.2129e-18
C_MINT5_X_9600_Y_2240 MINT5_X_9600_Y_2240 0 8.2129e-18
C_MINT5_X_9600_Y_2560 MINT5_X_9600_Y_2560 0 8.2129e-18
C_MINT5_X_9600_Y_2880 MINT5_X_9600_Y_2880 0 8.2129e-18
C_MINT5_X_9600_Y_320 MINT5_X_9600_Y_320 0 8.2129e-18
C_MINT5_X_9600_Y_3200 MINT5_X_9600_Y_3200 0 6.1597e-18
C_MINT5_X_9600_Y_3360 MINT5_X_9600_Y_3360 0 4.1064e-18
C_MINT5_X_9600_Y_3520 MINT5_X_9600_Y_3520 0 6.1597e-18
C_MINT5_X_9600_Y_3840 MINT5_X_9600_Y_3840 0 8.2129e-18
C_MINT5_X_9600_Y_4160 MINT5_X_9600_Y_4160 0 8.2129e-18
C_MINT5_X_9600_Y_4480 MINT5_X_9600_Y_4480 0 8.2129e-18
C_MINT5_X_9600_Y_4800 MINT5_X_9600_Y_4800 0 8.2129e-18
C_MINT5_X_9600_Y_5120 MINT5_X_9600_Y_5120 0 8.2129e-18
C_MINT5_X_9600_Y_5440 MINT5_X_9600_Y_5440 0 6.1597e-18
C_MINT5_X_9600_Y_5600 MINT5_X_9600_Y_5600 0 4.1064e-18
C_MINT5_X_9600_Y_5760 MINT5_X_9600_Y_5760 0 6.1597e-18
C_MINT5_X_9600_Y_6080 MINT5_X_9600_Y_6080 0 8.2129e-18
C_MINT5_X_9600_Y_640 MINT5_X_9600_Y_640 0 8.2129e-18
C_MINT5_X_9600_Y_6400 MINT5_X_9600_Y_6400 0 8.2129e-18
C_MINT5_X_9600_Y_6720 MINT5_X_9600_Y_6720 0 8.2129e-18
C_MINT5_X_9600_Y_7040 MINT5_X_9600_Y_7040 0 8.2129e-18
C_MINT5_X_9600_Y_7360 MINT5_X_9600_Y_7360 0 8.2129e-18
C_MINT5_X_9600_Y_7680 MINT5_X_9600_Y_7680 0 6.1597e-18
C_MINT5_X_9600_Y_7840 MINT5_X_9600_Y_7840 0 4.1064e-18
C_MINT5_X_9600_Y_8000 MINT5_X_9600_Y_8000 0 6.1597e-18
C_MINT5_X_9600_Y_8320 MINT5_X_9600_Y_8320 0 8.2129e-18
C_MINT5_X_9600_Y_8640 MINT5_X_9600_Y_8640 0 8.2129e-18
C_MINT5_X_9600_Y_8960 MINT5_X_9600_Y_8960 0 8.2129e-18
C_MINT5_X_9600_Y_9280 MINT5_X_9600_Y_9280 0 8.2129e-18
C_MINT5_X_9600_Y_960 MINT5_X_9600_Y_960 0 6.1597e-18
C_MINT5_X_9600_Y_9600 MINT5_X_9600_Y_9600 0 8.2129e-18
C_MINT5_X_9600_Y_9920 MINT5_X_9600_Y_9920 0 5.1331e-18
C_MINT5_X_960_Y_0 MINT5_X_960_Y_0 0 4.1064e-18
C_MINT5_X_960_Y_10000 MINT5_X_960_Y_10000 0 1.0266e-18
C_MINT5_X_960_Y_1280 MINT5_X_960_Y_1280 0 8.2129e-18
C_MINT5_X_960_Y_1600 MINT5_X_960_Y_1600 0 5.1331e-18
C_MINT5_X_960_Y_1680 MINT5_X_960_Y_1680 0 4.1064e-18
C_MINT5_X_960_Y_1920 MINT5_X_960_Y_1920 0 7.1863e-18
C_MINT5_X_960_Y_2240 MINT5_X_960_Y_2240 0 8.2129e-18
C_MINT5_X_960_Y_2560 MINT5_X_960_Y_2560 0 7.1863e-18
C_MINT5_X_960_Y_2800 MINT5_X_960_Y_2800 0 4.1064e-18
C_MINT5_X_960_Y_2880 MINT5_X_960_Y_2880 0 5.1331e-18
C_MINT5_X_960_Y_320 MINT5_X_960_Y_320 0 7.1863e-18
C_MINT5_X_960_Y_3200 MINT5_X_960_Y_3200 0 8.2129e-18
C_MINT5_X_960_Y_3520 MINT5_X_960_Y_3520 0 8.2129e-18
C_MINT5_X_960_Y_3840 MINT5_X_960_Y_3840 0 5.1331e-18
C_MINT5_X_960_Y_3920 MINT5_X_960_Y_3920 0 4.1064e-18
C_MINT5_X_960_Y_4160 MINT5_X_960_Y_4160 0 7.1863e-18
C_MINT5_X_960_Y_4480 MINT5_X_960_Y_4480 0 8.2129e-18
C_MINT5_X_960_Y_4800 MINT5_X_960_Y_4800 0 7.1863e-18
C_MINT5_X_960_Y_5040 MINT5_X_960_Y_5040 0 4.1064e-18
C_MINT5_X_960_Y_5120 MINT5_X_960_Y_5120 0 5.1331e-18
C_MINT5_X_960_Y_5440 MINT5_X_960_Y_5440 0 8.2129e-18
C_MINT5_X_960_Y_560 MINT5_X_960_Y_560 0 4.1064e-18
C_MINT5_X_960_Y_5760 MINT5_X_960_Y_5760 0 8.2129e-18
C_MINT5_X_960_Y_6080 MINT5_X_960_Y_6080 0 5.1331e-18
C_MINT5_X_960_Y_6160 MINT5_X_960_Y_6160 0 4.1064e-18
C_MINT5_X_960_Y_640 MINT5_X_960_Y_640 0 5.1331e-18
C_MINT5_X_960_Y_6400 MINT5_X_960_Y_6400 0 7.1863e-18
C_MINT5_X_960_Y_6720 MINT5_X_960_Y_6720 0 8.2129e-18
C_MINT5_X_960_Y_7040 MINT5_X_960_Y_7040 0 7.1863e-18
C_MINT5_X_960_Y_7280 MINT5_X_960_Y_7280 0 4.1064e-18
C_MINT5_X_960_Y_7360 MINT5_X_960_Y_7360 0 5.1331e-18
C_MINT5_X_960_Y_7680 MINT5_X_960_Y_7680 0 8.2129e-18
C_MINT5_X_960_Y_8000 MINT5_X_960_Y_8000 0 8.2129e-18
C_MINT5_X_960_Y_8320 MINT5_X_960_Y_8320 0 5.1331e-18
C_MINT5_X_960_Y_8400 MINT5_X_960_Y_8400 0 4.1064e-18
C_MINT5_X_960_Y_8640 MINT5_X_960_Y_8640 0 7.1863e-18
C_MINT5_X_960_Y_8960 MINT5_X_960_Y_8960 0 8.2129e-18
C_MINT5_X_960_Y_9280 MINT5_X_960_Y_9280 0 7.1863e-18
C_MINT5_X_960_Y_9520 MINT5_X_960_Y_9520 0 4.1064e-18
C_MINT5_X_960_Y_960 MINT5_X_960_Y_960 0 8.2129e-18
C_MINT5_X_960_Y_9600 MINT5_X_960_Y_9600 0 5.1331e-18
C_MINT5_X_960_Y_9920 MINT5_X_960_Y_9920 0 5.1331e-18
C_MINT5_X_9920_Y_0 MINT5_X_9920_Y_0 0 4.1064e-18
C_MINT5_X_9920_Y_10000 MINT5_X_9920_Y_10000 0 1.0266e-18
C_MINT5_X_9920_Y_1280 MINT5_X_9920_Y_1280 0 8.2129e-18
C_MINT5_X_9920_Y_1600 MINT5_X_9920_Y_1600 0 5.1331e-18
C_MINT5_X_9920_Y_1680 MINT5_X_9920_Y_1680 0 4.1064e-18
C_MINT5_X_9920_Y_1920 MINT5_X_9920_Y_1920 0 7.1863e-18
C_MINT5_X_9920_Y_2240 MINT5_X_9920_Y_2240 0 8.2129e-18
C_MINT5_X_9920_Y_2560 MINT5_X_9920_Y_2560 0 7.1863e-18
C_MINT5_X_9920_Y_2800 MINT5_X_9920_Y_2800 0 4.1064e-18
C_MINT5_X_9920_Y_2880 MINT5_X_9920_Y_2880 0 5.1331e-18
C_MINT5_X_9920_Y_320 MINT5_X_9920_Y_320 0 7.1863e-18
C_MINT5_X_9920_Y_3200 MINT5_X_9920_Y_3200 0 8.2129e-18
C_MINT5_X_9920_Y_3520 MINT5_X_9920_Y_3520 0 8.2129e-18
C_MINT5_X_9920_Y_3840 MINT5_X_9920_Y_3840 0 5.1331e-18
C_MINT5_X_9920_Y_3920 MINT5_X_9920_Y_3920 0 4.1064e-18
C_MINT5_X_9920_Y_4160 MINT5_X_9920_Y_4160 0 7.1863e-18
C_MINT5_X_9920_Y_4480 MINT5_X_9920_Y_4480 0 8.2129e-18
C_MINT5_X_9920_Y_4800 MINT5_X_9920_Y_4800 0 7.1863e-18
C_MINT5_X_9920_Y_5040 MINT5_X_9920_Y_5040 0 4.1064e-18
C_MINT5_X_9920_Y_5120 MINT5_X_9920_Y_5120 0 5.1331e-18
C_MINT5_X_9920_Y_5440 MINT5_X_9920_Y_5440 0 8.2129e-18
C_MINT5_X_9920_Y_560 MINT5_X_9920_Y_560 0 4.1064e-18
C_MINT5_X_9920_Y_5760 MINT5_X_9920_Y_5760 0 8.2129e-18
C_MINT5_X_9920_Y_6080 MINT5_X_9920_Y_6080 0 5.1331e-18
C_MINT5_X_9920_Y_6160 MINT5_X_9920_Y_6160 0 4.1064e-18
C_MINT5_X_9920_Y_640 MINT5_X_9920_Y_640 0 5.1331e-18
C_MINT5_X_9920_Y_6400 MINT5_X_9920_Y_6400 0 7.1863e-18
C_MINT5_X_9920_Y_6720 MINT5_X_9920_Y_6720 0 8.2129e-18
C_MINT5_X_9920_Y_7040 MINT5_X_9920_Y_7040 0 7.1863e-18
C_MINT5_X_9920_Y_7280 MINT5_X_9920_Y_7280 0 4.1064e-18
C_MINT5_X_9920_Y_7360 MINT5_X_9920_Y_7360 0 5.1331e-18
C_MINT5_X_9920_Y_7680 MINT5_X_9920_Y_7680 0 8.2129e-18
C_MINT5_X_9920_Y_8000 MINT5_X_9920_Y_8000 0 8.2129e-18
C_MINT5_X_9920_Y_8320 MINT5_X_9920_Y_8320 0 5.1331e-18
C_MINT5_X_9920_Y_8400 MINT5_X_9920_Y_8400 0 4.1064e-18
C_MINT5_X_9920_Y_8640 MINT5_X_9920_Y_8640 0 7.1863e-18
C_MINT5_X_9920_Y_8960 MINT5_X_9920_Y_8960 0 8.2129e-18
C_MINT5_X_9920_Y_9280 MINT5_X_9920_Y_9280 0 7.1863e-18
C_MINT5_X_9920_Y_9520 MINT5_X_9920_Y_9520 0 4.1064e-18
C_MINT5_X_9920_Y_960 MINT5_X_9920_Y_960 0 8.2129e-18
C_MINT5_X_9920_Y_9600 MINT5_X_9920_Y_9600 0 5.1331e-18
C_MINT5_X_9920_Y_9920 MINT5_X_9920_Y_9920 0 5.1331e-18
C_MSMG1_X_0_Y_0 MSMG1_X_0_Y_0 0 9.8598e-18
C_MSMG1_X_0_Y_1120 MSMG1_X_0_Y_1120 0 9.8598e-18
C_MSMG1_X_0_Y_1680 MSMG1_X_0_Y_1680 0 5.6342e-18
C_MSMG1_X_0_Y_2240 MSMG1_X_0_Y_2240 0 9.8598e-18
C_MSMG1_X_0_Y_2800 MSMG1_X_0_Y_2800 0 5.6342e-18
C_MSMG1_X_0_Y_3360 MSMG1_X_0_Y_3360 0 9.8598e-18
C_MSMG1_X_0_Y_3920 MSMG1_X_0_Y_3920 0 5.6342e-18
C_MSMG1_X_0_Y_4480 MSMG1_X_0_Y_4480 0 9.8598e-18
C_MSMG1_X_0_Y_5040 MSMG1_X_0_Y_5040 0 5.6342e-18
C_MSMG1_X_0_Y_560 MSMG1_X_0_Y_560 0 5.6342e-18
C_MSMG1_X_0_Y_5600 MSMG1_X_0_Y_5600 0 9.8598e-18
C_MSMG1_X_0_Y_6160 MSMG1_X_0_Y_6160 0 5.6342e-18
C_MSMG1_X_0_Y_6720 MSMG1_X_0_Y_6720 0 9.8598e-18
C_MSMG1_X_0_Y_7280 MSMG1_X_0_Y_7280 0 5.6342e-18
C_MSMG1_X_0_Y_7840 MSMG1_X_0_Y_7840 0 9.8598e-18
C_MSMG1_X_0_Y_8400 MSMG1_X_0_Y_8400 0 5.6342e-18
C_MSMG1_X_0_Y_8960 MSMG1_X_0_Y_8960 0 9.8598e-18
C_MSMG1_X_0_Y_9520 MSMG1_X_0_Y_9520 0 5.6342e-18
C_MSMG1_X_10000_Y_0 MSMG1_X_10000_Y_0 0 7.0427e-18
C_MSMG1_X_10000_Y_1120 MSMG1_X_10000_Y_1120 0 7.0427e-18
C_MSMG1_X_10000_Y_1680 MSMG1_X_10000_Y_1680 0 1.4085e-18
C_MSMG1_X_10000_Y_2240 MSMG1_X_10000_Y_2240 0 7.0427e-18
C_MSMG1_X_10000_Y_2800 MSMG1_X_10000_Y_2800 0 1.4085e-18
C_MSMG1_X_10000_Y_3360 MSMG1_X_10000_Y_3360 0 7.0427e-18
C_MSMG1_X_10000_Y_3920 MSMG1_X_10000_Y_3920 0 1.4085e-18
C_MSMG1_X_10000_Y_4480 MSMG1_X_10000_Y_4480 0 7.0427e-18
C_MSMG1_X_10000_Y_5040 MSMG1_X_10000_Y_5040 0 1.4085e-18
C_MSMG1_X_10000_Y_560 MSMG1_X_10000_Y_560 0 1.4085e-18
C_MSMG1_X_10000_Y_5600 MSMG1_X_10000_Y_5600 0 7.0427e-18
C_MSMG1_X_10000_Y_6160 MSMG1_X_10000_Y_6160 0 1.4085e-18
C_MSMG1_X_10000_Y_6720 MSMG1_X_10000_Y_6720 0 7.0427e-18
C_MSMG1_X_10000_Y_7280 MSMG1_X_10000_Y_7280 0 1.4085e-18
C_MSMG1_X_10000_Y_7840 MSMG1_X_10000_Y_7840 0 7.0427e-18
C_MSMG1_X_10000_Y_8400 MSMG1_X_10000_Y_8400 0 1.4085e-18
C_MSMG1_X_10000_Y_8960 MSMG1_X_10000_Y_8960 0 7.0427e-18
C_MSMG1_X_10000_Y_9520 MSMG1_X_10000_Y_9520 0 1.4085e-18
C_MSMG1_X_1120_Y_0 MSMG1_X_1120_Y_0 0 1.1268e-17
C_MSMG1_X_1120_Y_1120 MSMG1_X_1120_Y_1120 0 1.1268e-17
C_MSMG1_X_1120_Y_1680 MSMG1_X_1120_Y_1680 0 1.1268e-17
C_MSMG1_X_1120_Y_2240 MSMG1_X_1120_Y_2240 0 1.1268e-17
C_MSMG1_X_1120_Y_2800 MSMG1_X_1120_Y_2800 0 1.1268e-17
C_MSMG1_X_1120_Y_3360 MSMG1_X_1120_Y_3360 0 1.1268e-17
C_MSMG1_X_1120_Y_3920 MSMG1_X_1120_Y_3920 0 1.1268e-17
C_MSMG1_X_1120_Y_4480 MSMG1_X_1120_Y_4480 0 1.1268e-17
C_MSMG1_X_1120_Y_5040 MSMG1_X_1120_Y_5040 0 1.1268e-17
C_MSMG1_X_1120_Y_560 MSMG1_X_1120_Y_560 0 1.1268e-17
C_MSMG1_X_1120_Y_5600 MSMG1_X_1120_Y_5600 0 1.1268e-17
C_MSMG1_X_1120_Y_6160 MSMG1_X_1120_Y_6160 0 1.1268e-17
C_MSMG1_X_1120_Y_6720 MSMG1_X_1120_Y_6720 0 1.1268e-17
C_MSMG1_X_1120_Y_7280 MSMG1_X_1120_Y_7280 0 1.1268e-17
C_MSMG1_X_1120_Y_7840 MSMG1_X_1120_Y_7840 0 1.1268e-17
C_MSMG1_X_1120_Y_8400 MSMG1_X_1120_Y_8400 0 1.1268e-17
C_MSMG1_X_1120_Y_8960 MSMG1_X_1120_Y_8960 0 1.1268e-17
C_MSMG1_X_1120_Y_9520 MSMG1_X_1120_Y_9520 0 1.1268e-17
C_MSMG1_X_1280_Y_0 MSMG1_X_1280_Y_0 0 9.8598e-18
C_MSMG1_X_1280_Y_1120 MSMG1_X_1280_Y_1120 0 9.8598e-18
C_MSMG1_X_1280_Y_2240 MSMG1_X_1280_Y_2240 0 9.8598e-18
C_MSMG1_X_1280_Y_3360 MSMG1_X_1280_Y_3360 0 9.8598e-18
C_MSMG1_X_1280_Y_4480 MSMG1_X_1280_Y_4480 0 9.8598e-18
C_MSMG1_X_1280_Y_5600 MSMG1_X_1280_Y_5600 0 9.8598e-18
C_MSMG1_X_1280_Y_6720 MSMG1_X_1280_Y_6720 0 9.8598e-18
C_MSMG1_X_1280_Y_7840 MSMG1_X_1280_Y_7840 0 9.8598e-18
C_MSMG1_X_1280_Y_8960 MSMG1_X_1280_Y_8960 0 9.8598e-18
C_MSMG1_X_1600_Y_1680 MSMG1_X_1600_Y_1680 0 9.8598e-18
C_MSMG1_X_1600_Y_2800 MSMG1_X_1600_Y_2800 0 9.8598e-18
C_MSMG1_X_1600_Y_3920 MSMG1_X_1600_Y_3920 0 9.8598e-18
C_MSMG1_X_1600_Y_5040 MSMG1_X_1600_Y_5040 0 9.8598e-18
C_MSMG1_X_1600_Y_560 MSMG1_X_1600_Y_560 0 9.8598e-18
C_MSMG1_X_1600_Y_6160 MSMG1_X_1600_Y_6160 0 9.8598e-18
C_MSMG1_X_1600_Y_7280 MSMG1_X_1600_Y_7280 0 9.8598e-18
C_MSMG1_X_1600_Y_8400 MSMG1_X_1600_Y_8400 0 9.8598e-18
C_MSMG1_X_1600_Y_9520 MSMG1_X_1600_Y_9520 0 9.8598e-18
C_MSMG1_X_1680_Y_0 MSMG1_X_1680_Y_0 0 1.1268e-17
C_MSMG1_X_1680_Y_1120 MSMG1_X_1680_Y_1120 0 1.1268e-17
C_MSMG1_X_1680_Y_1680 MSMG1_X_1680_Y_1680 0 1.1268e-17
C_MSMG1_X_1680_Y_2240 MSMG1_X_1680_Y_2240 0 1.1268e-17
C_MSMG1_X_1680_Y_2800 MSMG1_X_1680_Y_2800 0 1.1268e-17
C_MSMG1_X_1680_Y_3360 MSMG1_X_1680_Y_3360 0 1.1268e-17
C_MSMG1_X_1680_Y_3920 MSMG1_X_1680_Y_3920 0 1.1268e-17
C_MSMG1_X_1680_Y_4480 MSMG1_X_1680_Y_4480 0 1.1268e-17
C_MSMG1_X_1680_Y_5040 MSMG1_X_1680_Y_5040 0 1.1268e-17
C_MSMG1_X_1680_Y_560 MSMG1_X_1680_Y_560 0 1.1268e-17
C_MSMG1_X_1680_Y_5600 MSMG1_X_1680_Y_5600 0 1.1268e-17
C_MSMG1_X_1680_Y_6160 MSMG1_X_1680_Y_6160 0 1.1268e-17
C_MSMG1_X_1680_Y_6720 MSMG1_X_1680_Y_6720 0 1.1268e-17
C_MSMG1_X_1680_Y_7280 MSMG1_X_1680_Y_7280 0 1.1268e-17
C_MSMG1_X_1680_Y_7840 MSMG1_X_1680_Y_7840 0 1.1268e-17
C_MSMG1_X_1680_Y_8400 MSMG1_X_1680_Y_8400 0 1.1268e-17
C_MSMG1_X_1680_Y_8960 MSMG1_X_1680_Y_8960 0 1.1268e-17
C_MSMG1_X_1680_Y_9520 MSMG1_X_1680_Y_9520 0 1.1268e-17
C_MSMG1_X_1920_Y_0 MSMG1_X_1920_Y_0 0 9.8598e-18
C_MSMG1_X_1920_Y_1120 MSMG1_X_1920_Y_1120 0 9.8598e-18
C_MSMG1_X_1920_Y_2240 MSMG1_X_1920_Y_2240 0 9.8598e-18
C_MSMG1_X_1920_Y_3360 MSMG1_X_1920_Y_3360 0 9.8598e-18
C_MSMG1_X_1920_Y_4480 MSMG1_X_1920_Y_4480 0 9.8598e-18
C_MSMG1_X_1920_Y_5600 MSMG1_X_1920_Y_5600 0 9.8598e-18
C_MSMG1_X_1920_Y_6720 MSMG1_X_1920_Y_6720 0 9.8598e-18
C_MSMG1_X_1920_Y_7840 MSMG1_X_1920_Y_7840 0 9.8598e-18
C_MSMG1_X_1920_Y_8960 MSMG1_X_1920_Y_8960 0 9.8598e-18
C_MSMG1_X_2240_Y_0 MSMG1_X_2240_Y_0 0 1.1268e-17
C_MSMG1_X_2240_Y_1120 MSMG1_X_2240_Y_1120 0 1.1268e-17
C_MSMG1_X_2240_Y_1680 MSMG1_X_2240_Y_1680 0 1.9720e-17
C_MSMG1_X_2240_Y_2240 MSMG1_X_2240_Y_2240 0 1.1268e-17
C_MSMG1_X_2240_Y_2800 MSMG1_X_2240_Y_2800 0 1.9720e-17
C_MSMG1_X_2240_Y_3360 MSMG1_X_2240_Y_3360 0 1.1268e-17
C_MSMG1_X_2240_Y_3920 MSMG1_X_2240_Y_3920 0 1.9720e-17
C_MSMG1_X_2240_Y_4480 MSMG1_X_2240_Y_4480 0 1.1268e-17
C_MSMG1_X_2240_Y_5040 MSMG1_X_2240_Y_5040 0 1.9720e-17
C_MSMG1_X_2240_Y_560 MSMG1_X_2240_Y_560 0 1.9720e-17
C_MSMG1_X_2240_Y_5600 MSMG1_X_2240_Y_5600 0 1.1268e-17
C_MSMG1_X_2240_Y_6160 MSMG1_X_2240_Y_6160 0 1.9720e-17
C_MSMG1_X_2240_Y_6720 MSMG1_X_2240_Y_6720 0 1.1268e-17
C_MSMG1_X_2240_Y_7280 MSMG1_X_2240_Y_7280 0 1.9720e-17
C_MSMG1_X_2240_Y_7840 MSMG1_X_2240_Y_7840 0 1.1268e-17
C_MSMG1_X_2240_Y_8400 MSMG1_X_2240_Y_8400 0 1.9720e-17
C_MSMG1_X_2240_Y_8960 MSMG1_X_2240_Y_8960 0 1.1268e-17
C_MSMG1_X_2240_Y_9520 MSMG1_X_2240_Y_9520 0 1.9720e-17
C_MSMG1_X_2560_Y_0 MSMG1_X_2560_Y_0 0 9.8598e-18
C_MSMG1_X_2560_Y_1120 MSMG1_X_2560_Y_1120 0 9.8598e-18
C_MSMG1_X_2560_Y_2240 MSMG1_X_2560_Y_2240 0 9.8598e-18
C_MSMG1_X_2560_Y_3360 MSMG1_X_2560_Y_3360 0 9.8598e-18
C_MSMG1_X_2560_Y_4480 MSMG1_X_2560_Y_4480 0 9.8598e-18
C_MSMG1_X_2560_Y_5600 MSMG1_X_2560_Y_5600 0 9.8598e-18
C_MSMG1_X_2560_Y_6720 MSMG1_X_2560_Y_6720 0 9.8598e-18
C_MSMG1_X_2560_Y_7840 MSMG1_X_2560_Y_7840 0 9.8598e-18
C_MSMG1_X_2560_Y_8960 MSMG1_X_2560_Y_8960 0 9.8598e-18
C_MSMG1_X_2800_Y_0 MSMG1_X_2800_Y_0 0 1.1268e-17
C_MSMG1_X_2800_Y_1120 MSMG1_X_2800_Y_1120 0 1.1268e-17
C_MSMG1_X_2800_Y_1680 MSMG1_X_2800_Y_1680 0 1.1268e-17
C_MSMG1_X_2800_Y_2240 MSMG1_X_2800_Y_2240 0 1.1268e-17
C_MSMG1_X_2800_Y_2800 MSMG1_X_2800_Y_2800 0 1.1268e-17
C_MSMG1_X_2800_Y_3360 MSMG1_X_2800_Y_3360 0 1.1268e-17
C_MSMG1_X_2800_Y_3920 MSMG1_X_2800_Y_3920 0 1.1268e-17
C_MSMG1_X_2800_Y_4480 MSMG1_X_2800_Y_4480 0 1.1268e-17
C_MSMG1_X_2800_Y_5040 MSMG1_X_2800_Y_5040 0 1.1268e-17
C_MSMG1_X_2800_Y_560 MSMG1_X_2800_Y_560 0 1.1268e-17
C_MSMG1_X_2800_Y_5600 MSMG1_X_2800_Y_5600 0 1.1268e-17
C_MSMG1_X_2800_Y_6160 MSMG1_X_2800_Y_6160 0 1.1268e-17
C_MSMG1_X_2800_Y_6720 MSMG1_X_2800_Y_6720 0 1.1268e-17
C_MSMG1_X_2800_Y_7280 MSMG1_X_2800_Y_7280 0 1.1268e-17
C_MSMG1_X_2800_Y_7840 MSMG1_X_2800_Y_7840 0 1.1268e-17
C_MSMG1_X_2800_Y_8400 MSMG1_X_2800_Y_8400 0 1.1268e-17
C_MSMG1_X_2800_Y_8960 MSMG1_X_2800_Y_8960 0 1.1268e-17
C_MSMG1_X_2800_Y_9520 MSMG1_X_2800_Y_9520 0 1.1268e-17
C_MSMG1_X_2880_Y_1680 MSMG1_X_2880_Y_1680 0 9.8598e-18
C_MSMG1_X_2880_Y_2800 MSMG1_X_2880_Y_2800 0 9.8598e-18
C_MSMG1_X_2880_Y_3920 MSMG1_X_2880_Y_3920 0 9.8598e-18
C_MSMG1_X_2880_Y_5040 MSMG1_X_2880_Y_5040 0 9.8598e-18
C_MSMG1_X_2880_Y_560 MSMG1_X_2880_Y_560 0 9.8598e-18
C_MSMG1_X_2880_Y_6160 MSMG1_X_2880_Y_6160 0 9.8598e-18
C_MSMG1_X_2880_Y_7280 MSMG1_X_2880_Y_7280 0 9.8598e-18
C_MSMG1_X_2880_Y_8400 MSMG1_X_2880_Y_8400 0 9.8598e-18
C_MSMG1_X_2880_Y_9520 MSMG1_X_2880_Y_9520 0 9.8598e-18
C_MSMG1_X_3200_Y_0 MSMG1_X_3200_Y_0 0 9.8598e-18
C_MSMG1_X_3200_Y_1120 MSMG1_X_3200_Y_1120 0 9.8598e-18
C_MSMG1_X_3200_Y_2240 MSMG1_X_3200_Y_2240 0 9.8598e-18
C_MSMG1_X_3200_Y_3360 MSMG1_X_3200_Y_3360 0 9.8598e-18
C_MSMG1_X_3200_Y_4480 MSMG1_X_3200_Y_4480 0 9.8598e-18
C_MSMG1_X_3200_Y_5600 MSMG1_X_3200_Y_5600 0 9.8598e-18
C_MSMG1_X_3200_Y_6720 MSMG1_X_3200_Y_6720 0 9.8598e-18
C_MSMG1_X_3200_Y_7840 MSMG1_X_3200_Y_7840 0 9.8598e-18
C_MSMG1_X_3200_Y_8960 MSMG1_X_3200_Y_8960 0 9.8598e-18
C_MSMG1_X_320_Y_1680 MSMG1_X_320_Y_1680 0 9.8598e-18
C_MSMG1_X_320_Y_2800 MSMG1_X_320_Y_2800 0 9.8598e-18
C_MSMG1_X_320_Y_3920 MSMG1_X_320_Y_3920 0 9.8598e-18
C_MSMG1_X_320_Y_5040 MSMG1_X_320_Y_5040 0 9.8598e-18
C_MSMG1_X_320_Y_560 MSMG1_X_320_Y_560 0 9.8598e-18
C_MSMG1_X_320_Y_6160 MSMG1_X_320_Y_6160 0 9.8598e-18
C_MSMG1_X_320_Y_7280 MSMG1_X_320_Y_7280 0 9.8598e-18
C_MSMG1_X_320_Y_8400 MSMG1_X_320_Y_8400 0 9.8598e-18
C_MSMG1_X_320_Y_9520 MSMG1_X_320_Y_9520 0 9.8598e-18
C_MSMG1_X_3360_Y_0 MSMG1_X_3360_Y_0 0 1.1268e-17
C_MSMG1_X_3360_Y_1120 MSMG1_X_3360_Y_1120 0 1.1268e-17
C_MSMG1_X_3360_Y_1680 MSMG1_X_3360_Y_1680 0 1.1268e-17
C_MSMG1_X_3360_Y_2240 MSMG1_X_3360_Y_2240 0 1.1268e-17
C_MSMG1_X_3360_Y_2800 MSMG1_X_3360_Y_2800 0 1.1268e-17
C_MSMG1_X_3360_Y_3360 MSMG1_X_3360_Y_3360 0 1.1268e-17
C_MSMG1_X_3360_Y_3920 MSMG1_X_3360_Y_3920 0 1.1268e-17
C_MSMG1_X_3360_Y_4480 MSMG1_X_3360_Y_4480 0 1.1268e-17
C_MSMG1_X_3360_Y_5040 MSMG1_X_3360_Y_5040 0 1.1268e-17
C_MSMG1_X_3360_Y_560 MSMG1_X_3360_Y_560 0 1.1268e-17
C_MSMG1_X_3360_Y_5600 MSMG1_X_3360_Y_5600 0 1.1268e-17
C_MSMG1_X_3360_Y_6160 MSMG1_X_3360_Y_6160 0 1.1268e-17
C_MSMG1_X_3360_Y_6720 MSMG1_X_3360_Y_6720 0 1.1268e-17
C_MSMG1_X_3360_Y_7280 MSMG1_X_3360_Y_7280 0 1.1268e-17
C_MSMG1_X_3360_Y_7840 MSMG1_X_3360_Y_7840 0 1.1268e-17
C_MSMG1_X_3360_Y_8400 MSMG1_X_3360_Y_8400 0 1.1268e-17
C_MSMG1_X_3360_Y_8960 MSMG1_X_3360_Y_8960 0 1.1268e-17
C_MSMG1_X_3360_Y_9520 MSMG1_X_3360_Y_9520 0 1.1268e-17
C_MSMG1_X_3520_Y_1680 MSMG1_X_3520_Y_1680 0 9.8598e-18
C_MSMG1_X_3520_Y_2800 MSMG1_X_3520_Y_2800 0 9.8598e-18
C_MSMG1_X_3520_Y_3920 MSMG1_X_3520_Y_3920 0 9.8598e-18
C_MSMG1_X_3520_Y_5040 MSMG1_X_3520_Y_5040 0 9.8598e-18
C_MSMG1_X_3520_Y_560 MSMG1_X_3520_Y_560 0 9.8598e-18
C_MSMG1_X_3520_Y_6160 MSMG1_X_3520_Y_6160 0 9.8598e-18
C_MSMG1_X_3520_Y_7280 MSMG1_X_3520_Y_7280 0 9.8598e-18
C_MSMG1_X_3520_Y_8400 MSMG1_X_3520_Y_8400 0 9.8598e-18
C_MSMG1_X_3520_Y_9520 MSMG1_X_3520_Y_9520 0 9.8598e-18
C_MSMG1_X_3840_Y_0 MSMG1_X_3840_Y_0 0 9.8598e-18
C_MSMG1_X_3840_Y_1120 MSMG1_X_3840_Y_1120 0 9.8598e-18
C_MSMG1_X_3840_Y_2240 MSMG1_X_3840_Y_2240 0 9.8598e-18
C_MSMG1_X_3840_Y_3360 MSMG1_X_3840_Y_3360 0 9.8598e-18
C_MSMG1_X_3840_Y_4480 MSMG1_X_3840_Y_4480 0 9.8598e-18
C_MSMG1_X_3840_Y_5600 MSMG1_X_3840_Y_5600 0 9.8598e-18
C_MSMG1_X_3840_Y_6720 MSMG1_X_3840_Y_6720 0 9.8598e-18
C_MSMG1_X_3840_Y_7840 MSMG1_X_3840_Y_7840 0 9.8598e-18
C_MSMG1_X_3840_Y_8960 MSMG1_X_3840_Y_8960 0 9.8598e-18
C_MSMG1_X_3920_Y_0 MSMG1_X_3920_Y_0 0 1.1268e-17
C_MSMG1_X_3920_Y_1120 MSMG1_X_3920_Y_1120 0 1.1268e-17
C_MSMG1_X_3920_Y_1680 MSMG1_X_3920_Y_1680 0 1.1268e-17
C_MSMG1_X_3920_Y_2240 MSMG1_X_3920_Y_2240 0 1.1268e-17
C_MSMG1_X_3920_Y_2800 MSMG1_X_3920_Y_2800 0 1.1268e-17
C_MSMG1_X_3920_Y_3360 MSMG1_X_3920_Y_3360 0 1.1268e-17
C_MSMG1_X_3920_Y_3920 MSMG1_X_3920_Y_3920 0 1.1268e-17
C_MSMG1_X_3920_Y_4480 MSMG1_X_3920_Y_4480 0 1.1268e-17
C_MSMG1_X_3920_Y_5040 MSMG1_X_3920_Y_5040 0 1.1268e-17
C_MSMG1_X_3920_Y_560 MSMG1_X_3920_Y_560 0 1.1268e-17
C_MSMG1_X_3920_Y_5600 MSMG1_X_3920_Y_5600 0 1.1268e-17
C_MSMG1_X_3920_Y_6160 MSMG1_X_3920_Y_6160 0 1.1268e-17
C_MSMG1_X_3920_Y_6720 MSMG1_X_3920_Y_6720 0 1.1268e-17
C_MSMG1_X_3920_Y_7280 MSMG1_X_3920_Y_7280 0 1.1268e-17
C_MSMG1_X_3920_Y_7840 MSMG1_X_3920_Y_7840 0 1.1268e-17
C_MSMG1_X_3920_Y_8400 MSMG1_X_3920_Y_8400 0 1.1268e-17
C_MSMG1_X_3920_Y_8960 MSMG1_X_3920_Y_8960 0 1.1268e-17
C_MSMG1_X_3920_Y_9520 MSMG1_X_3920_Y_9520 0 1.1268e-17
C_MSMG1_X_4160_Y_1680 MSMG1_X_4160_Y_1680 0 9.8598e-18
C_MSMG1_X_4160_Y_2800 MSMG1_X_4160_Y_2800 0 9.8598e-18
C_MSMG1_X_4160_Y_3920 MSMG1_X_4160_Y_3920 0 9.8598e-18
C_MSMG1_X_4160_Y_5040 MSMG1_X_4160_Y_5040 0 9.8598e-18
C_MSMG1_X_4160_Y_560 MSMG1_X_4160_Y_560 0 9.8598e-18
C_MSMG1_X_4160_Y_6160 MSMG1_X_4160_Y_6160 0 9.8598e-18
C_MSMG1_X_4160_Y_7280 MSMG1_X_4160_Y_7280 0 9.8598e-18
C_MSMG1_X_4160_Y_8400 MSMG1_X_4160_Y_8400 0 9.8598e-18
C_MSMG1_X_4160_Y_9520 MSMG1_X_4160_Y_9520 0 9.8598e-18
C_MSMG1_X_4480_Y_0 MSMG1_X_4480_Y_0 0 1.9720e-17
C_MSMG1_X_4480_Y_1120 MSMG1_X_4480_Y_1120 0 1.9720e-17
C_MSMG1_X_4480_Y_1680 MSMG1_X_4480_Y_1680 0 1.1268e-17
C_MSMG1_X_4480_Y_2240 MSMG1_X_4480_Y_2240 0 1.9720e-17
C_MSMG1_X_4480_Y_2800 MSMG1_X_4480_Y_2800 0 1.1268e-17
C_MSMG1_X_4480_Y_3360 MSMG1_X_4480_Y_3360 0 1.9720e-17
C_MSMG1_X_4480_Y_3920 MSMG1_X_4480_Y_3920 0 1.1268e-17
C_MSMG1_X_4480_Y_4480 MSMG1_X_4480_Y_4480 0 1.9720e-17
C_MSMG1_X_4480_Y_5040 MSMG1_X_4480_Y_5040 0 1.1268e-17
C_MSMG1_X_4480_Y_560 MSMG1_X_4480_Y_560 0 1.1268e-17
C_MSMG1_X_4480_Y_5600 MSMG1_X_4480_Y_5600 0 1.9720e-17
C_MSMG1_X_4480_Y_6160 MSMG1_X_4480_Y_6160 0 1.1268e-17
C_MSMG1_X_4480_Y_6720 MSMG1_X_4480_Y_6720 0 1.9720e-17
C_MSMG1_X_4480_Y_7280 MSMG1_X_4480_Y_7280 0 1.1268e-17
C_MSMG1_X_4480_Y_7840 MSMG1_X_4480_Y_7840 0 1.9720e-17
C_MSMG1_X_4480_Y_8400 MSMG1_X_4480_Y_8400 0 1.1268e-17
C_MSMG1_X_4480_Y_8960 MSMG1_X_4480_Y_8960 0 1.9720e-17
C_MSMG1_X_4480_Y_9520 MSMG1_X_4480_Y_9520 0 1.1268e-17
C_MSMG1_X_4800_Y_1680 MSMG1_X_4800_Y_1680 0 9.8598e-18
C_MSMG1_X_4800_Y_2800 MSMG1_X_4800_Y_2800 0 9.8598e-18
C_MSMG1_X_4800_Y_3920 MSMG1_X_4800_Y_3920 0 9.8598e-18
C_MSMG1_X_4800_Y_5040 MSMG1_X_4800_Y_5040 0 9.8598e-18
C_MSMG1_X_4800_Y_560 MSMG1_X_4800_Y_560 0 9.8598e-18
C_MSMG1_X_4800_Y_6160 MSMG1_X_4800_Y_6160 0 9.8598e-18
C_MSMG1_X_4800_Y_7280 MSMG1_X_4800_Y_7280 0 9.8598e-18
C_MSMG1_X_4800_Y_8400 MSMG1_X_4800_Y_8400 0 9.8598e-18
C_MSMG1_X_4800_Y_9520 MSMG1_X_4800_Y_9520 0 9.8598e-18
C_MSMG1_X_5040_Y_0 MSMG1_X_5040_Y_0 0 1.1268e-17
C_MSMG1_X_5040_Y_1120 MSMG1_X_5040_Y_1120 0 1.1268e-17
C_MSMG1_X_5040_Y_1680 MSMG1_X_5040_Y_1680 0 1.1268e-17
C_MSMG1_X_5040_Y_2240 MSMG1_X_5040_Y_2240 0 1.1268e-17
C_MSMG1_X_5040_Y_2800 MSMG1_X_5040_Y_2800 0 1.1268e-17
C_MSMG1_X_5040_Y_3360 MSMG1_X_5040_Y_3360 0 1.1268e-17
C_MSMG1_X_5040_Y_3920 MSMG1_X_5040_Y_3920 0 1.1268e-17
C_MSMG1_X_5040_Y_4480 MSMG1_X_5040_Y_4480 0 1.1268e-17
C_MSMG1_X_5040_Y_5040 MSMG1_X_5040_Y_5040 0 1.1268e-17
C_MSMG1_X_5040_Y_560 MSMG1_X_5040_Y_560 0 1.1268e-17
C_MSMG1_X_5040_Y_5600 MSMG1_X_5040_Y_5600 0 1.1268e-17
C_MSMG1_X_5040_Y_6160 MSMG1_X_5040_Y_6160 0 1.1268e-17
C_MSMG1_X_5040_Y_6720 MSMG1_X_5040_Y_6720 0 1.1268e-17
C_MSMG1_X_5040_Y_7280 MSMG1_X_5040_Y_7280 0 1.1268e-17
C_MSMG1_X_5040_Y_7840 MSMG1_X_5040_Y_7840 0 1.1268e-17
C_MSMG1_X_5040_Y_8400 MSMG1_X_5040_Y_8400 0 1.1268e-17
C_MSMG1_X_5040_Y_8960 MSMG1_X_5040_Y_8960 0 1.1268e-17
C_MSMG1_X_5040_Y_9520 MSMG1_X_5040_Y_9520 0 1.1268e-17
C_MSMG1_X_5120_Y_0 MSMG1_X_5120_Y_0 0 9.8598e-18
C_MSMG1_X_5120_Y_1120 MSMG1_X_5120_Y_1120 0 9.8598e-18
C_MSMG1_X_5120_Y_2240 MSMG1_X_5120_Y_2240 0 9.8598e-18
C_MSMG1_X_5120_Y_3360 MSMG1_X_5120_Y_3360 0 9.8598e-18
C_MSMG1_X_5120_Y_4480 MSMG1_X_5120_Y_4480 0 9.8598e-18
C_MSMG1_X_5120_Y_5600 MSMG1_X_5120_Y_5600 0 9.8598e-18
C_MSMG1_X_5120_Y_6720 MSMG1_X_5120_Y_6720 0 9.8598e-18
C_MSMG1_X_5120_Y_7840 MSMG1_X_5120_Y_7840 0 9.8598e-18
C_MSMG1_X_5120_Y_8960 MSMG1_X_5120_Y_8960 0 9.8598e-18
C_MSMG1_X_5440_Y_1680 MSMG1_X_5440_Y_1680 0 9.8598e-18
C_MSMG1_X_5440_Y_2800 MSMG1_X_5440_Y_2800 0 9.8598e-18
C_MSMG1_X_5440_Y_3920 MSMG1_X_5440_Y_3920 0 9.8598e-18
C_MSMG1_X_5440_Y_5040 MSMG1_X_5440_Y_5040 0 9.8598e-18
C_MSMG1_X_5440_Y_560 MSMG1_X_5440_Y_560 0 9.8598e-18
C_MSMG1_X_5440_Y_6160 MSMG1_X_5440_Y_6160 0 9.8598e-18
C_MSMG1_X_5440_Y_7280 MSMG1_X_5440_Y_7280 0 9.8598e-18
C_MSMG1_X_5440_Y_8400 MSMG1_X_5440_Y_8400 0 9.8598e-18
C_MSMG1_X_5440_Y_9520 MSMG1_X_5440_Y_9520 0 9.8598e-18
C_MSMG1_X_5600_Y_0 MSMG1_X_5600_Y_0 0 1.1268e-17
C_MSMG1_X_5600_Y_1120 MSMG1_X_5600_Y_1120 0 1.1268e-17
C_MSMG1_X_5600_Y_1680 MSMG1_X_5600_Y_1680 0 1.1268e-17
C_MSMG1_X_5600_Y_2240 MSMG1_X_5600_Y_2240 0 1.1268e-17
C_MSMG1_X_5600_Y_2800 MSMG1_X_5600_Y_2800 0 1.1268e-17
C_MSMG1_X_5600_Y_3360 MSMG1_X_5600_Y_3360 0 1.1268e-17
C_MSMG1_X_5600_Y_3920 MSMG1_X_5600_Y_3920 0 1.1268e-17
C_MSMG1_X_5600_Y_4480 MSMG1_X_5600_Y_4480 0 1.1268e-17
C_MSMG1_X_5600_Y_5040 MSMG1_X_5600_Y_5040 0 1.1268e-17
C_MSMG1_X_5600_Y_560 MSMG1_X_5600_Y_560 0 1.1268e-17
C_MSMG1_X_5600_Y_5600 MSMG1_X_5600_Y_5600 0 1.1268e-17
C_MSMG1_X_5600_Y_6160 MSMG1_X_5600_Y_6160 0 1.1268e-17
C_MSMG1_X_5600_Y_6720 MSMG1_X_5600_Y_6720 0 1.1268e-17
C_MSMG1_X_5600_Y_7280 MSMG1_X_5600_Y_7280 0 1.1268e-17
C_MSMG1_X_5600_Y_7840 MSMG1_X_5600_Y_7840 0 1.1268e-17
C_MSMG1_X_5600_Y_8400 MSMG1_X_5600_Y_8400 0 1.1268e-17
C_MSMG1_X_5600_Y_8960 MSMG1_X_5600_Y_8960 0 1.1268e-17
C_MSMG1_X_5600_Y_9520 MSMG1_X_5600_Y_9520 0 1.1268e-17
C_MSMG1_X_560_Y_0 MSMG1_X_560_Y_0 0 1.1268e-17
C_MSMG1_X_560_Y_1120 MSMG1_X_560_Y_1120 0 1.1268e-17
C_MSMG1_X_560_Y_1680 MSMG1_X_560_Y_1680 0 1.1268e-17
C_MSMG1_X_560_Y_2240 MSMG1_X_560_Y_2240 0 1.1268e-17
C_MSMG1_X_560_Y_2800 MSMG1_X_560_Y_2800 0 1.1268e-17
C_MSMG1_X_560_Y_3360 MSMG1_X_560_Y_3360 0 1.1268e-17
C_MSMG1_X_560_Y_3920 MSMG1_X_560_Y_3920 0 1.1268e-17
C_MSMG1_X_560_Y_4480 MSMG1_X_560_Y_4480 0 1.1268e-17
C_MSMG1_X_560_Y_5040 MSMG1_X_560_Y_5040 0 1.1268e-17
C_MSMG1_X_560_Y_560 MSMG1_X_560_Y_560 0 1.1268e-17
C_MSMG1_X_560_Y_5600 MSMG1_X_560_Y_5600 0 1.1268e-17
C_MSMG1_X_560_Y_6160 MSMG1_X_560_Y_6160 0 1.1268e-17
C_MSMG1_X_560_Y_6720 MSMG1_X_560_Y_6720 0 1.1268e-17
C_MSMG1_X_560_Y_7280 MSMG1_X_560_Y_7280 0 1.1268e-17
C_MSMG1_X_560_Y_7840 MSMG1_X_560_Y_7840 0 1.1268e-17
C_MSMG1_X_560_Y_8400 MSMG1_X_560_Y_8400 0 1.1268e-17
C_MSMG1_X_560_Y_8960 MSMG1_X_560_Y_8960 0 1.1268e-17
C_MSMG1_X_560_Y_9520 MSMG1_X_560_Y_9520 0 1.1268e-17
C_MSMG1_X_5760_Y_0 MSMG1_X_5760_Y_0 0 9.8598e-18
C_MSMG1_X_5760_Y_1120 MSMG1_X_5760_Y_1120 0 9.8598e-18
C_MSMG1_X_5760_Y_2240 MSMG1_X_5760_Y_2240 0 9.8598e-18
C_MSMG1_X_5760_Y_3360 MSMG1_X_5760_Y_3360 0 9.8598e-18
C_MSMG1_X_5760_Y_4480 MSMG1_X_5760_Y_4480 0 9.8598e-18
C_MSMG1_X_5760_Y_5600 MSMG1_X_5760_Y_5600 0 9.8598e-18
C_MSMG1_X_5760_Y_6720 MSMG1_X_5760_Y_6720 0 9.8598e-18
C_MSMG1_X_5760_Y_7840 MSMG1_X_5760_Y_7840 0 9.8598e-18
C_MSMG1_X_5760_Y_8960 MSMG1_X_5760_Y_8960 0 9.8598e-18
C_MSMG1_X_6080_Y_1680 MSMG1_X_6080_Y_1680 0 9.8598e-18
C_MSMG1_X_6080_Y_2800 MSMG1_X_6080_Y_2800 0 9.8598e-18
C_MSMG1_X_6080_Y_3920 MSMG1_X_6080_Y_3920 0 9.8598e-18
C_MSMG1_X_6080_Y_5040 MSMG1_X_6080_Y_5040 0 9.8598e-18
C_MSMG1_X_6080_Y_560 MSMG1_X_6080_Y_560 0 9.8598e-18
C_MSMG1_X_6080_Y_6160 MSMG1_X_6080_Y_6160 0 9.8598e-18
C_MSMG1_X_6080_Y_7280 MSMG1_X_6080_Y_7280 0 9.8598e-18
C_MSMG1_X_6080_Y_8400 MSMG1_X_6080_Y_8400 0 9.8598e-18
C_MSMG1_X_6080_Y_9520 MSMG1_X_6080_Y_9520 0 9.8598e-18
C_MSMG1_X_6160_Y_0 MSMG1_X_6160_Y_0 0 1.1268e-17
C_MSMG1_X_6160_Y_1120 MSMG1_X_6160_Y_1120 0 1.1268e-17
C_MSMG1_X_6160_Y_1680 MSMG1_X_6160_Y_1680 0 1.1268e-17
C_MSMG1_X_6160_Y_2240 MSMG1_X_6160_Y_2240 0 1.1268e-17
C_MSMG1_X_6160_Y_2800 MSMG1_X_6160_Y_2800 0 1.1268e-17
C_MSMG1_X_6160_Y_3360 MSMG1_X_6160_Y_3360 0 1.1268e-17
C_MSMG1_X_6160_Y_3920 MSMG1_X_6160_Y_3920 0 1.1268e-17
C_MSMG1_X_6160_Y_4480 MSMG1_X_6160_Y_4480 0 1.1268e-17
C_MSMG1_X_6160_Y_5040 MSMG1_X_6160_Y_5040 0 1.1268e-17
C_MSMG1_X_6160_Y_560 MSMG1_X_6160_Y_560 0 1.1268e-17
C_MSMG1_X_6160_Y_5600 MSMG1_X_6160_Y_5600 0 1.1268e-17
C_MSMG1_X_6160_Y_6160 MSMG1_X_6160_Y_6160 0 1.1268e-17
C_MSMG1_X_6160_Y_6720 MSMG1_X_6160_Y_6720 0 1.1268e-17
C_MSMG1_X_6160_Y_7280 MSMG1_X_6160_Y_7280 0 1.1268e-17
C_MSMG1_X_6160_Y_7840 MSMG1_X_6160_Y_7840 0 1.1268e-17
C_MSMG1_X_6160_Y_8400 MSMG1_X_6160_Y_8400 0 1.1268e-17
C_MSMG1_X_6160_Y_8960 MSMG1_X_6160_Y_8960 0 1.1268e-17
C_MSMG1_X_6160_Y_9520 MSMG1_X_6160_Y_9520 0 1.1268e-17
C_MSMG1_X_6400_Y_0 MSMG1_X_6400_Y_0 0 9.8598e-18
C_MSMG1_X_6400_Y_1120 MSMG1_X_6400_Y_1120 0 9.8598e-18
C_MSMG1_X_6400_Y_2240 MSMG1_X_6400_Y_2240 0 9.8598e-18
C_MSMG1_X_6400_Y_3360 MSMG1_X_6400_Y_3360 0 9.8598e-18
C_MSMG1_X_6400_Y_4480 MSMG1_X_6400_Y_4480 0 9.8598e-18
C_MSMG1_X_6400_Y_5600 MSMG1_X_6400_Y_5600 0 9.8598e-18
C_MSMG1_X_6400_Y_6720 MSMG1_X_6400_Y_6720 0 9.8598e-18
C_MSMG1_X_6400_Y_7840 MSMG1_X_6400_Y_7840 0 9.8598e-18
C_MSMG1_X_6400_Y_8960 MSMG1_X_6400_Y_8960 0 9.8598e-18
C_MSMG1_X_640_Y_0 MSMG1_X_640_Y_0 0 9.8598e-18
C_MSMG1_X_640_Y_1120 MSMG1_X_640_Y_1120 0 9.8598e-18
C_MSMG1_X_640_Y_2240 MSMG1_X_640_Y_2240 0 9.8598e-18
C_MSMG1_X_640_Y_3360 MSMG1_X_640_Y_3360 0 9.8598e-18
C_MSMG1_X_640_Y_4480 MSMG1_X_640_Y_4480 0 9.8598e-18
C_MSMG1_X_640_Y_5600 MSMG1_X_640_Y_5600 0 9.8598e-18
C_MSMG1_X_640_Y_6720 MSMG1_X_640_Y_6720 0 9.8598e-18
C_MSMG1_X_640_Y_7840 MSMG1_X_640_Y_7840 0 9.8598e-18
C_MSMG1_X_640_Y_8960 MSMG1_X_640_Y_8960 0 9.8598e-18
C_MSMG1_X_6720_Y_0 MSMG1_X_6720_Y_0 0 1.1268e-17
C_MSMG1_X_6720_Y_1120 MSMG1_X_6720_Y_1120 0 1.1268e-17
C_MSMG1_X_6720_Y_1680 MSMG1_X_6720_Y_1680 0 1.9720e-17
C_MSMG1_X_6720_Y_2240 MSMG1_X_6720_Y_2240 0 1.1268e-17
C_MSMG1_X_6720_Y_2800 MSMG1_X_6720_Y_2800 0 1.9720e-17
C_MSMG1_X_6720_Y_3360 MSMG1_X_6720_Y_3360 0 1.1268e-17
C_MSMG1_X_6720_Y_3920 MSMG1_X_6720_Y_3920 0 1.9720e-17
C_MSMG1_X_6720_Y_4480 MSMG1_X_6720_Y_4480 0 1.1268e-17
C_MSMG1_X_6720_Y_5040 MSMG1_X_6720_Y_5040 0 1.9720e-17
C_MSMG1_X_6720_Y_560 MSMG1_X_6720_Y_560 0 1.9720e-17
C_MSMG1_X_6720_Y_5600 MSMG1_X_6720_Y_5600 0 1.1268e-17
C_MSMG1_X_6720_Y_6160 MSMG1_X_6720_Y_6160 0 1.9720e-17
C_MSMG1_X_6720_Y_6720 MSMG1_X_6720_Y_6720 0 1.1268e-17
C_MSMG1_X_6720_Y_7280 MSMG1_X_6720_Y_7280 0 1.9720e-17
C_MSMG1_X_6720_Y_7840 MSMG1_X_6720_Y_7840 0 1.1268e-17
C_MSMG1_X_6720_Y_8400 MSMG1_X_6720_Y_8400 0 1.9720e-17
C_MSMG1_X_6720_Y_8960 MSMG1_X_6720_Y_8960 0 1.1268e-17
C_MSMG1_X_6720_Y_9520 MSMG1_X_6720_Y_9520 0 1.9720e-17
C_MSMG1_X_7040_Y_0 MSMG1_X_7040_Y_0 0 9.8598e-18
C_MSMG1_X_7040_Y_1120 MSMG1_X_7040_Y_1120 0 9.8598e-18
C_MSMG1_X_7040_Y_2240 MSMG1_X_7040_Y_2240 0 9.8598e-18
C_MSMG1_X_7040_Y_3360 MSMG1_X_7040_Y_3360 0 9.8598e-18
C_MSMG1_X_7040_Y_4480 MSMG1_X_7040_Y_4480 0 9.8598e-18
C_MSMG1_X_7040_Y_5600 MSMG1_X_7040_Y_5600 0 9.8598e-18
C_MSMG1_X_7040_Y_6720 MSMG1_X_7040_Y_6720 0 9.8598e-18
C_MSMG1_X_7040_Y_7840 MSMG1_X_7040_Y_7840 0 9.8598e-18
C_MSMG1_X_7040_Y_8960 MSMG1_X_7040_Y_8960 0 9.8598e-18
C_MSMG1_X_7280_Y_0 MSMG1_X_7280_Y_0 0 1.1268e-17
C_MSMG1_X_7280_Y_1120 MSMG1_X_7280_Y_1120 0 1.1268e-17
C_MSMG1_X_7280_Y_1680 MSMG1_X_7280_Y_1680 0 1.1268e-17
C_MSMG1_X_7280_Y_2240 MSMG1_X_7280_Y_2240 0 1.1268e-17
C_MSMG1_X_7280_Y_2800 MSMG1_X_7280_Y_2800 0 1.1268e-17
C_MSMG1_X_7280_Y_3360 MSMG1_X_7280_Y_3360 0 1.1268e-17
C_MSMG1_X_7280_Y_3920 MSMG1_X_7280_Y_3920 0 1.1268e-17
C_MSMG1_X_7280_Y_4480 MSMG1_X_7280_Y_4480 0 1.1268e-17
C_MSMG1_X_7280_Y_5040 MSMG1_X_7280_Y_5040 0 1.1268e-17
C_MSMG1_X_7280_Y_560 MSMG1_X_7280_Y_560 0 1.1268e-17
C_MSMG1_X_7280_Y_5600 MSMG1_X_7280_Y_5600 0 1.1268e-17
C_MSMG1_X_7280_Y_6160 MSMG1_X_7280_Y_6160 0 1.1268e-17
C_MSMG1_X_7280_Y_6720 MSMG1_X_7280_Y_6720 0 1.1268e-17
C_MSMG1_X_7280_Y_7280 MSMG1_X_7280_Y_7280 0 1.1268e-17
C_MSMG1_X_7280_Y_7840 MSMG1_X_7280_Y_7840 0 1.1268e-17
C_MSMG1_X_7280_Y_8400 MSMG1_X_7280_Y_8400 0 1.1268e-17
C_MSMG1_X_7280_Y_8960 MSMG1_X_7280_Y_8960 0 1.1268e-17
C_MSMG1_X_7280_Y_9520 MSMG1_X_7280_Y_9520 0 1.1268e-17
C_MSMG1_X_7360_Y_1680 MSMG1_X_7360_Y_1680 0 9.8598e-18
C_MSMG1_X_7360_Y_2800 MSMG1_X_7360_Y_2800 0 9.8598e-18
C_MSMG1_X_7360_Y_3920 MSMG1_X_7360_Y_3920 0 9.8598e-18
C_MSMG1_X_7360_Y_5040 MSMG1_X_7360_Y_5040 0 9.8598e-18
C_MSMG1_X_7360_Y_560 MSMG1_X_7360_Y_560 0 9.8598e-18
C_MSMG1_X_7360_Y_6160 MSMG1_X_7360_Y_6160 0 9.8598e-18
C_MSMG1_X_7360_Y_7280 MSMG1_X_7360_Y_7280 0 9.8598e-18
C_MSMG1_X_7360_Y_8400 MSMG1_X_7360_Y_8400 0 9.8598e-18
C_MSMG1_X_7360_Y_9520 MSMG1_X_7360_Y_9520 0 9.8598e-18
C_MSMG1_X_7680_Y_0 MSMG1_X_7680_Y_0 0 9.8598e-18
C_MSMG1_X_7680_Y_1120 MSMG1_X_7680_Y_1120 0 9.8598e-18
C_MSMG1_X_7680_Y_2240 MSMG1_X_7680_Y_2240 0 9.8598e-18
C_MSMG1_X_7680_Y_3360 MSMG1_X_7680_Y_3360 0 9.8598e-18
C_MSMG1_X_7680_Y_4480 MSMG1_X_7680_Y_4480 0 9.8598e-18
C_MSMG1_X_7680_Y_5600 MSMG1_X_7680_Y_5600 0 9.8598e-18
C_MSMG1_X_7680_Y_6720 MSMG1_X_7680_Y_6720 0 9.8598e-18
C_MSMG1_X_7680_Y_7840 MSMG1_X_7680_Y_7840 0 9.8598e-18
C_MSMG1_X_7680_Y_8960 MSMG1_X_7680_Y_8960 0 9.8598e-18
C_MSMG1_X_7840_Y_0 MSMG1_X_7840_Y_0 0 1.1268e-17
C_MSMG1_X_7840_Y_1120 MSMG1_X_7840_Y_1120 0 1.1268e-17
C_MSMG1_X_7840_Y_1680 MSMG1_X_7840_Y_1680 0 1.1268e-17
C_MSMG1_X_7840_Y_2240 MSMG1_X_7840_Y_2240 0 1.1268e-17
C_MSMG1_X_7840_Y_2800 MSMG1_X_7840_Y_2800 0 1.1268e-17
C_MSMG1_X_7840_Y_3360 MSMG1_X_7840_Y_3360 0 1.1268e-17
C_MSMG1_X_7840_Y_3920 MSMG1_X_7840_Y_3920 0 1.1268e-17
C_MSMG1_X_7840_Y_4480 MSMG1_X_7840_Y_4480 0 1.1268e-17
C_MSMG1_X_7840_Y_5040 MSMG1_X_7840_Y_5040 0 1.1268e-17
C_MSMG1_X_7840_Y_560 MSMG1_X_7840_Y_560 0 1.1268e-17
C_MSMG1_X_7840_Y_5600 MSMG1_X_7840_Y_5600 0 1.1268e-17
C_MSMG1_X_7840_Y_6160 MSMG1_X_7840_Y_6160 0 1.1268e-17
C_MSMG1_X_7840_Y_6720 MSMG1_X_7840_Y_6720 0 1.1268e-17
C_MSMG1_X_7840_Y_7280 MSMG1_X_7840_Y_7280 0 1.1268e-17
C_MSMG1_X_7840_Y_7840 MSMG1_X_7840_Y_7840 0 1.1268e-17
C_MSMG1_X_7840_Y_8400 MSMG1_X_7840_Y_8400 0 1.1268e-17
C_MSMG1_X_7840_Y_8960 MSMG1_X_7840_Y_8960 0 1.1268e-17
C_MSMG1_X_7840_Y_9520 MSMG1_X_7840_Y_9520 0 1.1268e-17
C_MSMG1_X_8000_Y_1680 MSMG1_X_8000_Y_1680 0 9.8598e-18
C_MSMG1_X_8000_Y_2800 MSMG1_X_8000_Y_2800 0 9.8598e-18
C_MSMG1_X_8000_Y_3920 MSMG1_X_8000_Y_3920 0 9.8598e-18
C_MSMG1_X_8000_Y_5040 MSMG1_X_8000_Y_5040 0 9.8598e-18
C_MSMG1_X_8000_Y_560 MSMG1_X_8000_Y_560 0 9.8598e-18
C_MSMG1_X_8000_Y_6160 MSMG1_X_8000_Y_6160 0 9.8598e-18
C_MSMG1_X_8000_Y_7280 MSMG1_X_8000_Y_7280 0 9.8598e-18
C_MSMG1_X_8000_Y_8400 MSMG1_X_8000_Y_8400 0 9.8598e-18
C_MSMG1_X_8000_Y_9520 MSMG1_X_8000_Y_9520 0 9.8598e-18
C_MSMG1_X_8320_Y_0 MSMG1_X_8320_Y_0 0 9.8598e-18
C_MSMG1_X_8320_Y_1120 MSMG1_X_8320_Y_1120 0 9.8598e-18
C_MSMG1_X_8320_Y_2240 MSMG1_X_8320_Y_2240 0 9.8598e-18
C_MSMG1_X_8320_Y_3360 MSMG1_X_8320_Y_3360 0 9.8598e-18
C_MSMG1_X_8320_Y_4480 MSMG1_X_8320_Y_4480 0 9.8598e-18
C_MSMG1_X_8320_Y_5600 MSMG1_X_8320_Y_5600 0 9.8598e-18
C_MSMG1_X_8320_Y_6720 MSMG1_X_8320_Y_6720 0 9.8598e-18
C_MSMG1_X_8320_Y_7840 MSMG1_X_8320_Y_7840 0 9.8598e-18
C_MSMG1_X_8320_Y_8960 MSMG1_X_8320_Y_8960 0 9.8598e-18
C_MSMG1_X_8400_Y_0 MSMG1_X_8400_Y_0 0 1.1268e-17
C_MSMG1_X_8400_Y_1120 MSMG1_X_8400_Y_1120 0 1.1268e-17
C_MSMG1_X_8400_Y_1680 MSMG1_X_8400_Y_1680 0 1.1268e-17
C_MSMG1_X_8400_Y_2240 MSMG1_X_8400_Y_2240 0 1.1268e-17
C_MSMG1_X_8400_Y_2800 MSMG1_X_8400_Y_2800 0 1.1268e-17
C_MSMG1_X_8400_Y_3360 MSMG1_X_8400_Y_3360 0 1.1268e-17
C_MSMG1_X_8400_Y_3920 MSMG1_X_8400_Y_3920 0 1.1268e-17
C_MSMG1_X_8400_Y_4480 MSMG1_X_8400_Y_4480 0 1.1268e-17
C_MSMG1_X_8400_Y_5040 MSMG1_X_8400_Y_5040 0 1.1268e-17
C_MSMG1_X_8400_Y_560 MSMG1_X_8400_Y_560 0 1.1268e-17
C_MSMG1_X_8400_Y_5600 MSMG1_X_8400_Y_5600 0 1.1268e-17
C_MSMG1_X_8400_Y_6160 MSMG1_X_8400_Y_6160 0 1.1268e-17
C_MSMG1_X_8400_Y_6720 MSMG1_X_8400_Y_6720 0 1.1268e-17
C_MSMG1_X_8400_Y_7280 MSMG1_X_8400_Y_7280 0 1.1268e-17
C_MSMG1_X_8400_Y_7840 MSMG1_X_8400_Y_7840 0 1.1268e-17
C_MSMG1_X_8400_Y_8400 MSMG1_X_8400_Y_8400 0 1.1268e-17
C_MSMG1_X_8400_Y_8960 MSMG1_X_8400_Y_8960 0 1.1268e-17
C_MSMG1_X_8400_Y_9520 MSMG1_X_8400_Y_9520 0 1.1268e-17
C_MSMG1_X_8640_Y_1680 MSMG1_X_8640_Y_1680 0 9.8598e-18
C_MSMG1_X_8640_Y_2800 MSMG1_X_8640_Y_2800 0 9.8598e-18
C_MSMG1_X_8640_Y_3920 MSMG1_X_8640_Y_3920 0 9.8598e-18
C_MSMG1_X_8640_Y_5040 MSMG1_X_8640_Y_5040 0 9.8598e-18
C_MSMG1_X_8640_Y_560 MSMG1_X_8640_Y_560 0 9.8598e-18
C_MSMG1_X_8640_Y_6160 MSMG1_X_8640_Y_6160 0 9.8598e-18
C_MSMG1_X_8640_Y_7280 MSMG1_X_8640_Y_7280 0 9.8598e-18
C_MSMG1_X_8640_Y_8400 MSMG1_X_8640_Y_8400 0 9.8598e-18
C_MSMG1_X_8640_Y_9520 MSMG1_X_8640_Y_9520 0 9.8598e-18
C_MSMG1_X_8960_Y_0 MSMG1_X_8960_Y_0 0 1.9720e-17
C_MSMG1_X_8960_Y_1120 MSMG1_X_8960_Y_1120 0 1.9720e-17
C_MSMG1_X_8960_Y_1680 MSMG1_X_8960_Y_1680 0 1.1268e-17
C_MSMG1_X_8960_Y_2240 MSMG1_X_8960_Y_2240 0 1.9720e-17
C_MSMG1_X_8960_Y_2800 MSMG1_X_8960_Y_2800 0 1.1268e-17
C_MSMG1_X_8960_Y_3360 MSMG1_X_8960_Y_3360 0 1.9720e-17
C_MSMG1_X_8960_Y_3920 MSMG1_X_8960_Y_3920 0 1.1268e-17
C_MSMG1_X_8960_Y_4480 MSMG1_X_8960_Y_4480 0 1.9720e-17
C_MSMG1_X_8960_Y_5040 MSMG1_X_8960_Y_5040 0 1.1268e-17
C_MSMG1_X_8960_Y_560 MSMG1_X_8960_Y_560 0 1.1268e-17
C_MSMG1_X_8960_Y_5600 MSMG1_X_8960_Y_5600 0 1.9720e-17
C_MSMG1_X_8960_Y_6160 MSMG1_X_8960_Y_6160 0 1.1268e-17
C_MSMG1_X_8960_Y_6720 MSMG1_X_8960_Y_6720 0 1.9720e-17
C_MSMG1_X_8960_Y_7280 MSMG1_X_8960_Y_7280 0 1.1268e-17
C_MSMG1_X_8960_Y_7840 MSMG1_X_8960_Y_7840 0 1.9720e-17
C_MSMG1_X_8960_Y_8400 MSMG1_X_8960_Y_8400 0 1.1268e-17
C_MSMG1_X_8960_Y_8960 MSMG1_X_8960_Y_8960 0 1.9720e-17
C_MSMG1_X_8960_Y_9520 MSMG1_X_8960_Y_9520 0 1.1268e-17
C_MSMG1_X_9280_Y_1680 MSMG1_X_9280_Y_1680 0 9.8598e-18
C_MSMG1_X_9280_Y_2800 MSMG1_X_9280_Y_2800 0 9.8598e-18
C_MSMG1_X_9280_Y_3920 MSMG1_X_9280_Y_3920 0 9.8598e-18
C_MSMG1_X_9280_Y_5040 MSMG1_X_9280_Y_5040 0 9.8598e-18
C_MSMG1_X_9280_Y_560 MSMG1_X_9280_Y_560 0 9.8598e-18
C_MSMG1_X_9280_Y_6160 MSMG1_X_9280_Y_6160 0 9.8598e-18
C_MSMG1_X_9280_Y_7280 MSMG1_X_9280_Y_7280 0 9.8598e-18
C_MSMG1_X_9280_Y_8400 MSMG1_X_9280_Y_8400 0 9.8598e-18
C_MSMG1_X_9280_Y_9520 MSMG1_X_9280_Y_9520 0 9.8598e-18
C_MSMG1_X_9520_Y_0 MSMG1_X_9520_Y_0 0 1.1268e-17
C_MSMG1_X_9520_Y_1120 MSMG1_X_9520_Y_1120 0 1.1268e-17
C_MSMG1_X_9520_Y_1680 MSMG1_X_9520_Y_1680 0 1.1268e-17
C_MSMG1_X_9520_Y_2240 MSMG1_X_9520_Y_2240 0 1.1268e-17
C_MSMG1_X_9520_Y_2800 MSMG1_X_9520_Y_2800 0 1.1268e-17
C_MSMG1_X_9520_Y_3360 MSMG1_X_9520_Y_3360 0 1.1268e-17
C_MSMG1_X_9520_Y_3920 MSMG1_X_9520_Y_3920 0 1.1268e-17
C_MSMG1_X_9520_Y_4480 MSMG1_X_9520_Y_4480 0 1.1268e-17
C_MSMG1_X_9520_Y_5040 MSMG1_X_9520_Y_5040 0 1.1268e-17
C_MSMG1_X_9520_Y_560 MSMG1_X_9520_Y_560 0 1.1268e-17
C_MSMG1_X_9520_Y_5600 MSMG1_X_9520_Y_5600 0 1.1268e-17
C_MSMG1_X_9520_Y_6160 MSMG1_X_9520_Y_6160 0 1.1268e-17
C_MSMG1_X_9520_Y_6720 MSMG1_X_9520_Y_6720 0 1.1268e-17
C_MSMG1_X_9520_Y_7280 MSMG1_X_9520_Y_7280 0 1.1268e-17
C_MSMG1_X_9520_Y_7840 MSMG1_X_9520_Y_7840 0 1.1268e-17
C_MSMG1_X_9520_Y_8400 MSMG1_X_9520_Y_8400 0 1.1268e-17
C_MSMG1_X_9520_Y_8960 MSMG1_X_9520_Y_8960 0 1.1268e-17
C_MSMG1_X_9520_Y_9520 MSMG1_X_9520_Y_9520 0 1.1268e-17
C_MSMG1_X_9600_Y_0 MSMG1_X_9600_Y_0 0 8.4513e-18
C_MSMG1_X_9600_Y_1120 MSMG1_X_9600_Y_1120 0 8.4513e-18
C_MSMG1_X_9600_Y_2240 MSMG1_X_9600_Y_2240 0 8.4513e-18
C_MSMG1_X_9600_Y_3360 MSMG1_X_9600_Y_3360 0 8.4513e-18
C_MSMG1_X_9600_Y_4480 MSMG1_X_9600_Y_4480 0 8.4513e-18
C_MSMG1_X_9600_Y_5600 MSMG1_X_9600_Y_5600 0 8.4513e-18
C_MSMG1_X_9600_Y_6720 MSMG1_X_9600_Y_6720 0 8.4513e-18
C_MSMG1_X_9600_Y_7840 MSMG1_X_9600_Y_7840 0 8.4513e-18
C_MSMG1_X_9600_Y_8960 MSMG1_X_9600_Y_8960 0 8.4513e-18
C_MSMG1_X_960_Y_1680 MSMG1_X_960_Y_1680 0 9.8598e-18
C_MSMG1_X_960_Y_2800 MSMG1_X_960_Y_2800 0 9.8598e-18
C_MSMG1_X_960_Y_3920 MSMG1_X_960_Y_3920 0 9.8598e-18
C_MSMG1_X_960_Y_5040 MSMG1_X_960_Y_5040 0 9.8598e-18
C_MSMG1_X_960_Y_560 MSMG1_X_960_Y_560 0 9.8598e-18
C_MSMG1_X_960_Y_6160 MSMG1_X_960_Y_6160 0 9.8598e-18
C_MSMG1_X_960_Y_7280 MSMG1_X_960_Y_7280 0 9.8598e-18
C_MSMG1_X_960_Y_8400 MSMG1_X_960_Y_8400 0 9.8598e-18
C_MSMG1_X_960_Y_9520 MSMG1_X_960_Y_9520 0 9.8598e-18
C_MSMG1_X_9920_Y_1680 MSMG1_X_9920_Y_1680 0 8.4513e-18
C_MSMG1_X_9920_Y_2800 MSMG1_X_9920_Y_2800 0 8.4513e-18
C_MSMG1_X_9920_Y_3920 MSMG1_X_9920_Y_3920 0 8.4513e-18
C_MSMG1_X_9920_Y_5040 MSMG1_X_9920_Y_5040 0 8.4513e-18
C_MSMG1_X_9920_Y_560 MSMG1_X_9920_Y_560 0 8.4513e-18
C_MSMG1_X_9920_Y_6160 MSMG1_X_9920_Y_6160 0 8.4513e-18
C_MSMG1_X_9920_Y_7280 MSMG1_X_9920_Y_7280 0 8.4513e-18
C_MSMG1_X_9920_Y_8400 MSMG1_X_9920_Y_8400 0 8.4513e-18
C_MSMG1_X_9920_Y_9520 MSMG1_X_9920_Y_9520 0 8.4513e-18

* === Standard Cell Instances ===
XCELL_R0_C0 NC_0 NC_1 M1_X_2650_Y_0 M1_X_2650_Y_512 BUFX12
XCELL_R0_C1 NC_2 NC_3 M1_X_7650_Y_0 M1_X_7650_Y_512 BUFX12
XCELL_R1_C0 NC_4 NC_5 M1_X_2650_Y_1024 M1_X_2650_Y_512 BUFX12
XCELL_R1_C1 NC_6 NC_7 M1_X_7650_Y_1024 M1_X_7650_Y_512 BUFX12
XCELL_R2_C0 NC_8 NC_9 M1_X_2650_Y_1024 M1_X_2650_Y_1536 BUFX12
XCELL_R2_C1 NC_10 NC_11 M1_X_7650_Y_1024 M1_X_7650_Y_1536 BUFX12
XCELL_R3_C0 NC_12 NC_13 M1_X_2650_Y_2048 M1_X_2650_Y_1536 BUFX12
XCELL_R3_C1 NC_14 NC_15 M1_X_7650_Y_2048 M1_X_7650_Y_1536 BUFX12
XCELL_R4_C0 NC_16 NC_17 M1_X_2650_Y_2048 M1_X_2650_Y_2560 BUFX12
XCELL_R4_C1 NC_18 NC_19 M1_X_7650_Y_2048 M1_X_7650_Y_2560 BUFX12
XCELL_R5_C0 NC_20 NC_21 M1_X_2650_Y_3072 M1_X_2650_Y_2560 BUFX12
XCELL_R5_C1 NC_22 NC_23 M1_X_7650_Y_3072 M1_X_7650_Y_2560 BUFX12
XCELL_R6_C0 NC_24 NC_25 M1_X_2650_Y_3072 M1_X_2650_Y_3584 BUFX12
XCELL_R6_C1 NC_26 NC_27 M1_X_7650_Y_3072 M1_X_7650_Y_3584 BUFX12
XCELL_R7_C0 NC_28 NC_29 M1_X_2650_Y_4096 M1_X_2650_Y_3584 BUFX12
XCELL_R7_C1 NC_30 NC_31 M1_X_7650_Y_4096 M1_X_7650_Y_3584 BUFX12
XCELL_R8_C0 NC_32 NC_33 M1_X_2650_Y_4096 M1_X_2650_Y_4608 BUFX12
XCELL_R8_C1 NC_34 NC_35 M1_X_7650_Y_4096 M1_X_7650_Y_4608 BUFX12
XCELL_R9_C0 NC_36 NC_37 M1_X_2650_Y_5120 M1_X_2650_Y_4608 BUFX12
XCELL_R9_C1 NC_38 NC_39 M1_X_7650_Y_5120 M1_X_7650_Y_4608 BUFX12
XCELL_R10_C0 NC_40 NC_41 M1_X_2650_Y_5120 M1_X_2650_Y_5632 BUFX12
XCELL_R10_C1 NC_42 NC_43 M1_X_7650_Y_5120 M1_X_7650_Y_5632 BUFX12
XCELL_R11_C0 NC_44 NC_45 M1_X_2650_Y_6144 M1_X_2650_Y_5632 BUFX12
XCELL_R11_C1 NC_46 NC_47 M1_X_7650_Y_6144 M1_X_7650_Y_5632 BUFX12
XCELL_R12_C0 NC_48 NC_49 M1_X_2650_Y_6144 M1_X_2650_Y_6656 BUFX12
XCELL_R12_C1 NC_50 NC_51 M1_X_7650_Y_6144 M1_X_7650_Y_6656 BUFX12
XCELL_R13_C0 NC_52 NC_53 M1_X_2650_Y_7168 M1_X_2650_Y_6656 BUFX12
XCELL_R13_C1 NC_54 NC_55 M1_X_7650_Y_7168 M1_X_7650_Y_6656 BUFX12
XCELL_R14_C0 NC_56 NC_57 M1_X_2650_Y_7168 M1_X_2650_Y_7680 BUFX12
XCELL_R14_C1 NC_58 NC_59 M1_X_7650_Y_7168 M1_X_7650_Y_7680 BUFX12
XCELL_R15_C0 NC_60 NC_61 M1_X_2650_Y_8192 M1_X_2650_Y_7680 BUFX12
XCELL_R15_C1 NC_62 NC_63 M1_X_7650_Y_8192 M1_X_7650_Y_7680 BUFX12
XCELL_R16_C0 NC_64 NC_65 M1_X_2650_Y_8192 M1_X_2650_Y_8704 BUFX12
XCELL_R16_C1 NC_66 NC_67 M1_X_7650_Y_8192 M1_X_7650_Y_8704 BUFX12
XCELL_R17_C0 NC_68 NC_69 M1_X_2650_Y_9216 M1_X_2650_Y_8704 BUFX12
XCELL_R17_C1 NC_70 NC_71 M1_X_7650_Y_9216 M1_X_7650_Y_8704 BUFX12
XCELL_R18_C0 NC_72 NC_73 M1_X_2650_Y_9216 M1_X_2650_Y_9728 BUFX12
XCELL_R18_C1 NC_74 NC_75 M1_X_7650_Y_9216 M1_X_7650_Y_9728 BUFX12

.end
